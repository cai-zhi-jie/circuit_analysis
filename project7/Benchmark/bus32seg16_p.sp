*A BUS interconnect circuit with 34 bus line 16 segment.

Rin1 0 TDn1a1 10
Rin2 0 TDn2a1 10
Rin3 0 TDn3a1 10
Rin4 0 TDn4a1 10
Rin5 0 TDn5a1 10
Rin6 0 TDn6a1 10
Rin7 0 TDn7a1 10
Rin8 0 TDn8a1 10
Rin9 0 TDn9a1 10
Rin10 0 TDn10a1 10
Rin11 0 TDn11a1 10
Rin12 0 TDn12a1 10
Rin13 0 TDn13a1 10
Rin14 0 TDn14a1 10
Rin15 0 TDn15a1 10
Rin16 0 TDn16a1 10
Rin17 0 TDn17a1 10
Rin18 0 TDn18a1 10
Rin19 0 TDn19a1 10
Rin20 0 TDn20a1 10
Rin21 0 TDn21a1 10
Rin22 0 TDn22a1 10
Rin23 0 TDn23a1 10
Rin24 0 TDn24a1 10
Rin25 0 TDn25a1 10
Rin26 0 TDn26a1 10
Rin27 0 TDn27a1 10
Rin28 0 TDn28a1 10
Rin29 0 TDn29a1 10
Rin30 0 TDn30a1 10
Rin31 0 TDn31a1 10
Rin32 0 TDn32a1 10
*Iin1 TDn1a1 0 AC 1
*Iin1 TDn1a1 0 sin(0 1 0.1e9)
*Iin2 TDn2a1 0 sin(0 1 0.1e9)
*Iin3 TDn3a1 0 sin(0 1 0.1e9)
*Iin4 TDn4a1 0 sin(0 1 0.1e9)
*Iin5 TDn5a1 0 sin(0 1 0.1e9)
*Iin6 TDn6a1 0 sin(0 1 0.1e9)
*Iin7 TDn7a1 0 sin(0 1 0.1e9)
*Iin8 TDn8a1 0 sin(0 1 0.1e9)

Iin1 TDn1a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin2 TDn2a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin3 TDn3a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin4 TDn4a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin5 TDn5a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin6 TDn6a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin7 TDn7a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8
Iin8 TDn8a1 0 PULSE 0 3 1e-9 0.5e-9  0.5e-9 4e-9 1e-8

Rgndg TDnga1 0 1
Rvndg TDnva1 0 1
RRR TDnga9 TDnva9 1
Cout1 TDn1a9 TDnga9 0.1p
Cout2 TDn2a9 TDnga9 0.1p
Cout3 TDn3a9 TDnga9 0.1p
Cout4 TDn4a9 TDnga9 0.1p
Cout5 TDn5a9 TDnga9 0.1p
Cout6 TDn6a9 TDnga9 0.1p
Cout7 TDn7a9 TDnga9 0.1p
Cout8 TDn8a9 TDnga9 0.1p
Cout9 TDn9a9 TDnga9 0.1p
Cout10 TDn10a9 TDnga9 0.1p
Cout11 TDn11a9 TDnga9 0.1p
Cout12 TDn12a9 TDnga9 0.1p
Cout13 TDn13a9 TDnga9 0.1p
Cout14 TDn14a9 TDnga9 0.1p
Cout15 TDn15a9 TDnga9 0.1p
Cout16 TDn16a9 TDnga9 0.1p
Cout17 TDn17a9 TDnga9 0.1p
Cout18 TDn18a9 TDnga9 0.1p
Cout19 TDn19a9 TDnga9 0.1p
Cout20 TDn20a9 TDnga9 0.1p
Cout21 TDn21a9 TDnga9 0.1p
Cout22 TDn22a9 TDnga9 0.1p
Cout23 TDn23a9 TDnga9 0.1p
Cout24 TDn24a9 TDnga9 0.1p
Cout25 TDn25a9 TDnga9 0.1p
Cout26 TDn26a9 TDnga9 0.1p
Cout27 TDn27a9 TDnga9 0.1p
Cout28 TDn28a9 TDnga9 0.1p
Cout29 TDn29a9 TDnga9 0.1p
Cout30 TDn30a9 TDnga9 0.1p
Cout31 TDn31a9 TDnga9 0.1p
Cout32 TDn32a9 TDnga9 0.1p

X1 TDnga1 TDnga9 TDn1a1 TDn1a9 TDn2a1 TDn2a9 TDn3a1 TDn3a9 TDn4a1 TDn4a9 TDn5a1 TDn5a9 TDn6a1 TDn6a9 TDn7a1 TDn7a9 TDn8a1 TDn8a9 TDn9a1 TDn9a9 TDn10a1 TDn10a9 TDn11a1 TDn11a9 TDn12a1 TDn12a9 TDn13a1 TDn13a9 TDn14a1 TDn14a9 TDn15a1 TDn15a9 TDn16a1 TDn16a9 TDn17a1 TDn17a9 TDn18a1 TDn18a9 TDn19a1 TDn19a9 TDn20a1 TDn20a9 TDn21a1 TDn21a9 TDn22a1 TDn22a9 TDn23a1 TDn23a9 TDn24a1 TDn24a9 TDn25a1 TDn25a9 TDn26a1 TDn26a9 TDn27a1 TDn27a9 TDn28a1 TDn28a9 TDn29a1 TDn29a9 TDn30a1 TDn30a9 TDn31a1 TDn31a9 TDn32a1 TDn32a9 TDnva1 TDnva9 intercon
.SUBCKT intercon TDnga1 TDnga33 TDn1a1 TDn1a33 TDn2a1 TDn2a33 TDn3a1 TDn3a33 TDn4a1 TDn4a33 TDn5a1 TDn5a33 TDn6a1 TDn6a33 TDn7a1 TDn7a33 TDn8a1 TDn8a33 TDn9a1 TDn9a33 TDn10a1 TDn10a33 TDn11a1 TDn11a33 TDn12a1 TDn12a33 TDn13a1 TDn13a33 TDn14a1 TDn14a33 TDn15a1 TDn15a33 TDn16a1 TDn16a33 TDn17a1 TDn17a33 TDn18a1 TDn18a33 TDn19a1 TDn19a33 TDn20a1 TDn20a33 TDn21a1 TDn21a33 TDn22a1 TDn22a33 TDn23a1 TDn23a33 TDn24a1 TDn24a33 TDn25a1 TDn25a33 TDn26a1 TDn26a33 TDn27a1 TDn27a33 TDn28a1 TDn28a33 TDn29a1 TDn29a33 TDn30a1 TDn30a33 TDn31a1 TDn31a33 TDn32a1 TDn32a33 TDnva1 TDnva33

Rnga1 TDnga1 TDnga2 2.603750
Rnga2 TDnga3 TDnga4 2.603750
Rnga3 TDnga5 TDnga6 2.603750
Rnga4 TDnga7 TDnga8 2.603750
Rnga5 TDnga9 TDnga10 2.603750
Rnga6 TDnga11 TDnga12 2.603750
Rnga7 TDnga13 TDnga14 2.603750
Rnga8 TDnga15 TDnga16 2.603750
Rnga9 TDnga17 TDnga18 2.603750
Rnga10 TDnga19 TDnga20 2.603750
Rnga11 TDnga21 TDnga22 2.603750
Rnga12 TDnga23 TDnga24 2.603750
Rnga13 TDnga25 TDnga26 2.603750
Rnga14 TDnga27 TDnga28 2.603750
Rnga15 TDnga29 TDnga30 2.603750
Rnga16 TDnga31 TDnga32 2.603750
Rn1a1 TDn1a1 TDn1a2 2.604380
Rn1a2 TDn1a3 TDn1a4 2.604380
Rn1a3 TDn1a5 TDn1a6 2.604380
Rn1a4 TDn1a7 TDn1a8 2.604380
Rn1a5 TDn1a9 TDn1a10 2.604380
Rn1a6 TDn1a11 TDn1a12 2.604380
Rn1a7 TDn1a13 TDn1a14 2.604380
Rn1a8 TDn1a15 TDn1a16 2.604380
Rn1a9 TDn1a17 TDn1a18 2.604380
Rn1a10 TDn1a19 TDn1a20 2.604380
Rn1a11 TDn1a21 TDn1a22 2.604380
Rn1a12 TDn1a23 TDn1a24 2.604380
Rn1a13 TDn1a25 TDn1a26 2.604380
Rn1a14 TDn1a27 TDn1a28 2.604380
Rn1a15 TDn1a29 TDn1a30 2.604380
Rn1a16 TDn1a31 TDn1a32 2.604380
Rn2a1 TDn2a1 TDn2a2 2.604380
Rn2a2 TDn2a3 TDn2a4 2.604380
Rn2a3 TDn2a5 TDn2a6 2.604380
Rn2a4 TDn2a7 TDn2a8 2.604380
Rn2a5 TDn2a9 TDn2a10 2.604380
Rn2a6 TDn2a11 TDn2a12 2.604380
Rn2a7 TDn2a13 TDn2a14 2.604380
Rn2a8 TDn2a15 TDn2a16 2.604380
Rn2a9 TDn2a17 TDn2a18 2.604380
Rn2a10 TDn2a19 TDn2a20 2.604380
Rn2a11 TDn2a21 TDn2a22 2.604380
Rn2a12 TDn2a23 TDn2a24 2.604380
Rn2a13 TDn2a25 TDn2a26 2.604380
Rn2a14 TDn2a27 TDn2a28 2.604380
Rn2a15 TDn2a29 TDn2a30 2.604380
Rn2a16 TDn2a31 TDn2a32 2.604380
Rn3a1 TDn3a1 TDn3a2 2.604380
Rn3a2 TDn3a3 TDn3a4 2.604380
Rn3a3 TDn3a5 TDn3a6 2.604380
Rn3a4 TDn3a7 TDn3a8 2.604380
Rn3a5 TDn3a9 TDn3a10 2.604380
Rn3a6 TDn3a11 TDn3a12 2.604380
Rn3a7 TDn3a13 TDn3a14 2.604380
Rn3a8 TDn3a15 TDn3a16 2.604380
Rn3a9 TDn3a17 TDn3a18 2.604380
Rn3a10 TDn3a19 TDn3a20 2.604380
Rn3a11 TDn3a21 TDn3a22 2.604380
Rn3a12 TDn3a23 TDn3a24 2.604380
Rn3a13 TDn3a25 TDn3a26 2.604380
Rn3a14 TDn3a27 TDn3a28 2.604380
Rn3a15 TDn3a29 TDn3a30 2.604380
Rn3a16 TDn3a31 TDn3a32 2.604380
Rn4a1 TDn4a1 TDn4a2 2.604380
Rn4a2 TDn4a3 TDn4a4 2.604380
Rn4a3 TDn4a5 TDn4a6 2.604380
Rn4a4 TDn4a7 TDn4a8 2.604380
Rn4a5 TDn4a9 TDn4a10 2.604380
Rn4a6 TDn4a11 TDn4a12 2.604380
Rn4a7 TDn4a13 TDn4a14 2.604380
Rn4a8 TDn4a15 TDn4a16 2.604380
Rn4a9 TDn4a17 TDn4a18 2.604380
Rn4a10 TDn4a19 TDn4a20 2.604380
Rn4a11 TDn4a21 TDn4a22 2.604380
Rn4a12 TDn4a23 TDn4a24 2.604380
Rn4a13 TDn4a25 TDn4a26 2.604380
Rn4a14 TDn4a27 TDn4a28 2.604380
Rn4a15 TDn4a29 TDn4a30 2.604380
Rn4a16 TDn4a31 TDn4a32 2.604380
Rn5a1 TDn5a1 TDn5a2 2.604380
Rn5a2 TDn5a3 TDn5a4 2.604380
Rn5a3 TDn5a5 TDn5a6 2.604380
Rn5a4 TDn5a7 TDn5a8 2.604380
Rn5a5 TDn5a9 TDn5a10 2.604380
Rn5a6 TDn5a11 TDn5a12 2.604380
Rn5a7 TDn5a13 TDn5a14 2.604380
Rn5a8 TDn5a15 TDn5a16 2.604380
Rn5a9 TDn5a17 TDn5a18 2.604380
Rn5a10 TDn5a19 TDn5a20 2.604380
Rn5a11 TDn5a21 TDn5a22 2.604380
Rn5a12 TDn5a23 TDn5a24 2.604380
Rn5a13 TDn5a25 TDn5a26 2.604380
Rn5a14 TDn5a27 TDn5a28 2.604380
Rn5a15 TDn5a29 TDn5a30 2.604380
Rn5a16 TDn5a31 TDn5a32 2.604380
Rn6a1 TDn6a1 TDn6a2 2.604380
Rn6a2 TDn6a3 TDn6a4 2.604380
Rn6a3 TDn6a5 TDn6a6 2.604380
Rn6a4 TDn6a7 TDn6a8 2.604380
Rn6a5 TDn6a9 TDn6a10 2.604380
Rn6a6 TDn6a11 TDn6a12 2.604380
Rn6a7 TDn6a13 TDn6a14 2.604380
Rn6a8 TDn6a15 TDn6a16 2.604380
Rn6a9 TDn6a17 TDn6a18 2.604380
Rn6a10 TDn6a19 TDn6a20 2.604380
Rn6a11 TDn6a21 TDn6a22 2.604380
Rn6a12 TDn6a23 TDn6a24 2.604380
Rn6a13 TDn6a25 TDn6a26 2.604380
Rn6a14 TDn6a27 TDn6a28 2.604380
Rn6a15 TDn6a29 TDn6a30 2.604380
Rn6a16 TDn6a31 TDn6a32 2.604380
Rn7a1 TDn7a1 TDn7a2 2.604380
Rn7a2 TDn7a3 TDn7a4 2.604380
Rn7a3 TDn7a5 TDn7a6 2.604380
Rn7a4 TDn7a7 TDn7a8 2.604380
Rn7a5 TDn7a9 TDn7a10 2.604380
Rn7a6 TDn7a11 TDn7a12 2.604380
Rn7a7 TDn7a13 TDn7a14 2.604380
Rn7a8 TDn7a15 TDn7a16 2.604380
Rn7a9 TDn7a17 TDn7a18 2.604380
Rn7a10 TDn7a19 TDn7a20 2.604380
Rn7a11 TDn7a21 TDn7a22 2.604380
Rn7a12 TDn7a23 TDn7a24 2.604380
Rn7a13 TDn7a25 TDn7a26 2.604380
Rn7a14 TDn7a27 TDn7a28 2.604380
Rn7a15 TDn7a29 TDn7a30 2.604380
Rn7a16 TDn7a31 TDn7a32 2.604380
Rn8a1 TDn8a1 TDn8a2 2.604380
Rn8a2 TDn8a3 TDn8a4 2.604380
Rn8a3 TDn8a5 TDn8a6 2.604380
Rn8a4 TDn8a7 TDn8a8 2.604380
Rn8a5 TDn8a9 TDn8a10 2.604380
Rn8a6 TDn8a11 TDn8a12 2.604380
Rn8a7 TDn8a13 TDn8a14 2.604380
Rn8a8 TDn8a15 TDn8a16 2.604380
Rn8a9 TDn8a17 TDn8a18 2.604380
Rn8a10 TDn8a19 TDn8a20 2.604380
Rn8a11 TDn8a21 TDn8a22 2.604380
Rn8a12 TDn8a23 TDn8a24 2.604380
Rn8a13 TDn8a25 TDn8a26 2.604380
Rn8a14 TDn8a27 TDn8a28 2.604380
Rn8a15 TDn8a29 TDn8a30 2.604380
Rn8a16 TDn8a31 TDn8a32 2.604380
Rn9a1 TDn9a1 TDn9a2 2.604380
Rn9a2 TDn9a3 TDn9a4 2.604380
Rn9a3 TDn9a5 TDn9a6 2.604380
Rn9a4 TDn9a7 TDn9a8 2.604380
Rn9a5 TDn9a9 TDn9a10 2.604380
Rn9a6 TDn9a11 TDn9a12 2.604380
Rn9a7 TDn9a13 TDn9a14 2.604380
Rn9a8 TDn9a15 TDn9a16 2.604380
Rn9a9 TDn9a17 TDn9a18 2.604380
Rn9a10 TDn9a19 TDn9a20 2.604380
Rn9a11 TDn9a21 TDn9a22 2.604380
Rn9a12 TDn9a23 TDn9a24 2.604380
Rn9a13 TDn9a25 TDn9a26 2.604380
Rn9a14 TDn9a27 TDn9a28 2.604380
Rn9a15 TDn9a29 TDn9a30 2.604380
Rn9a16 TDn9a31 TDn9a32 2.604380
Rn10a1 TDn10a1 TDn10a2 2.604380
Rn10a2 TDn10a3 TDn10a4 2.604380
Rn10a3 TDn10a5 TDn10a6 2.604380
Rn10a4 TDn10a7 TDn10a8 2.604380
Rn10a5 TDn10a9 TDn10a10 2.604380
Rn10a6 TDn10a11 TDn10a12 2.604380
Rn10a7 TDn10a13 TDn10a14 2.604380
Rn10a8 TDn10a15 TDn10a16 2.604380
Rn10a9 TDn10a17 TDn10a18 2.604380
Rn10a10 TDn10a19 TDn10a20 2.604380
Rn10a11 TDn10a21 TDn10a22 2.604380
Rn10a12 TDn10a23 TDn10a24 2.604380
Rn10a13 TDn10a25 TDn10a26 2.604380
Rn10a14 TDn10a27 TDn10a28 2.604380
Rn10a15 TDn10a29 TDn10a30 2.604380
Rn10a16 TDn10a31 TDn10a32 2.604380
Rn11a1 TDn11a1 TDn11a2 2.604380
Rn11a2 TDn11a3 TDn11a4 2.604380
Rn11a3 TDn11a5 TDn11a6 2.604380
Rn11a4 TDn11a7 TDn11a8 2.604380
Rn11a5 TDn11a9 TDn11a10 2.604380
Rn11a6 TDn11a11 TDn11a12 2.604380
Rn11a7 TDn11a13 TDn11a14 2.604380
Rn11a8 TDn11a15 TDn11a16 2.604380
Rn11a9 TDn11a17 TDn11a18 2.604380
Rn11a10 TDn11a19 TDn11a20 2.604380
Rn11a11 TDn11a21 TDn11a22 2.604380
Rn11a12 TDn11a23 TDn11a24 2.604380
Rn11a13 TDn11a25 TDn11a26 2.604380
Rn11a14 TDn11a27 TDn11a28 2.604380
Rn11a15 TDn11a29 TDn11a30 2.604380
Rn11a16 TDn11a31 TDn11a32 2.604380
Rn12a1 TDn12a1 TDn12a2 2.604380
Rn12a2 TDn12a3 TDn12a4 2.604380
Rn12a3 TDn12a5 TDn12a6 2.604380
Rn12a4 TDn12a7 TDn12a8 2.604380
Rn12a5 TDn12a9 TDn12a10 2.604380
Rn12a6 TDn12a11 TDn12a12 2.604380
Rn12a7 TDn12a13 TDn12a14 2.604380
Rn12a8 TDn12a15 TDn12a16 2.604380
Rn12a9 TDn12a17 TDn12a18 2.604380
Rn12a10 TDn12a19 TDn12a20 2.604380
Rn12a11 TDn12a21 TDn12a22 2.604380
Rn12a12 TDn12a23 TDn12a24 2.604380
Rn12a13 TDn12a25 TDn12a26 2.604380
Rn12a14 TDn12a27 TDn12a28 2.604380
Rn12a15 TDn12a29 TDn12a30 2.604380
Rn12a16 TDn12a31 TDn12a32 2.604380
Rn13a1 TDn13a1 TDn13a2 2.604380
Rn13a2 TDn13a3 TDn13a4 2.604380
Rn13a3 TDn13a5 TDn13a6 2.604380
Rn13a4 TDn13a7 TDn13a8 2.604380
Rn13a5 TDn13a9 TDn13a10 2.604380
Rn13a6 TDn13a11 TDn13a12 2.604380
Rn13a7 TDn13a13 TDn13a14 2.604380
Rn13a8 TDn13a15 TDn13a16 2.604380
Rn13a9 TDn13a17 TDn13a18 2.604380
Rn13a10 TDn13a19 TDn13a20 2.604380
Rn13a11 TDn13a21 TDn13a22 2.604380
Rn13a12 TDn13a23 TDn13a24 2.604380
Rn13a13 TDn13a25 TDn13a26 2.604380
Rn13a14 TDn13a27 TDn13a28 2.604380
Rn13a15 TDn13a29 TDn13a30 2.604380
Rn13a16 TDn13a31 TDn13a32 2.604380
Rn14a1 TDn14a1 TDn14a2 2.604380
Rn14a2 TDn14a3 TDn14a4 2.604380
Rn14a3 TDn14a5 TDn14a6 2.604380
Rn14a4 TDn14a7 TDn14a8 2.604380
Rn14a5 TDn14a9 TDn14a10 2.604380
Rn14a6 TDn14a11 TDn14a12 2.604380
Rn14a7 TDn14a13 TDn14a14 2.604380
Rn14a8 TDn14a15 TDn14a16 2.604380
Rn14a9 TDn14a17 TDn14a18 2.604380
Rn14a10 TDn14a19 TDn14a20 2.604380
Rn14a11 TDn14a21 TDn14a22 2.604380
Rn14a12 TDn14a23 TDn14a24 2.604380
Rn14a13 TDn14a25 TDn14a26 2.604380
Rn14a14 TDn14a27 TDn14a28 2.604380
Rn14a15 TDn14a29 TDn14a30 2.604380
Rn14a16 TDn14a31 TDn14a32 2.604380
Rn15a1 TDn15a1 TDn15a2 2.604380
Rn15a2 TDn15a3 TDn15a4 2.604380
Rn15a3 TDn15a5 TDn15a6 2.604380
Rn15a4 TDn15a7 TDn15a8 2.604380
Rn15a5 TDn15a9 TDn15a10 2.604380
Rn15a6 TDn15a11 TDn15a12 2.604380
Rn15a7 TDn15a13 TDn15a14 2.604380
Rn15a8 TDn15a15 TDn15a16 2.604380
Rn15a9 TDn15a17 TDn15a18 2.604380
Rn15a10 TDn15a19 TDn15a20 2.604380
Rn15a11 TDn15a21 TDn15a22 2.604380
Rn15a12 TDn15a23 TDn15a24 2.604380
Rn15a13 TDn15a25 TDn15a26 2.604380
Rn15a14 TDn15a27 TDn15a28 2.604380
Rn15a15 TDn15a29 TDn15a30 2.604380
Rn15a16 TDn15a31 TDn15a32 2.604380
Rn16a1 TDn16a1 TDn16a2 2.604380
Rn16a2 TDn16a3 TDn16a4 2.604380
Rn16a3 TDn16a5 TDn16a6 2.604380
Rn16a4 TDn16a7 TDn16a8 2.604380
Rn16a5 TDn16a9 TDn16a10 2.604380
Rn16a6 TDn16a11 TDn16a12 2.604380
Rn16a7 TDn16a13 TDn16a14 2.604380
Rn16a8 TDn16a15 TDn16a16 2.604380
Rn16a9 TDn16a17 TDn16a18 2.604380
Rn16a10 TDn16a19 TDn16a20 2.604380
Rn16a11 TDn16a21 TDn16a22 2.604380
Rn16a12 TDn16a23 TDn16a24 2.604380
Rn16a13 TDn16a25 TDn16a26 2.604380
Rn16a14 TDn16a27 TDn16a28 2.604380
Rn16a15 TDn16a29 TDn16a30 2.604380
Rn16a16 TDn16a31 TDn16a32 2.604380
Rn17a1 TDn17a1 TDn17a2 2.604380
Rn17a2 TDn17a3 TDn17a4 2.604380
Rn17a3 TDn17a5 TDn17a6 2.604380
Rn17a4 TDn17a7 TDn17a8 2.604380
Rn17a5 TDn17a9 TDn17a10 2.604380
Rn17a6 TDn17a11 TDn17a12 2.604380
Rn17a7 TDn17a13 TDn17a14 2.604380
Rn17a8 TDn17a15 TDn17a16 2.604380
Rn17a9 TDn17a17 TDn17a18 2.604380
Rn17a10 TDn17a19 TDn17a20 2.604380
Rn17a11 TDn17a21 TDn17a22 2.604380
Rn17a12 TDn17a23 TDn17a24 2.604380
Rn17a13 TDn17a25 TDn17a26 2.604380
Rn17a14 TDn17a27 TDn17a28 2.604380
Rn17a15 TDn17a29 TDn17a30 2.604380
Rn17a16 TDn17a31 TDn17a32 2.604380
Rn18a1 TDn18a1 TDn18a2 2.604380
Rn18a2 TDn18a3 TDn18a4 2.604380
Rn18a3 TDn18a5 TDn18a6 2.604380
Rn18a4 TDn18a7 TDn18a8 2.604380
Rn18a5 TDn18a9 TDn18a10 2.604380
Rn18a6 TDn18a11 TDn18a12 2.604380
Rn18a7 TDn18a13 TDn18a14 2.604380
Rn18a8 TDn18a15 TDn18a16 2.604380
Rn18a9 TDn18a17 TDn18a18 2.604380
Rn18a10 TDn18a19 TDn18a20 2.604380
Rn18a11 TDn18a21 TDn18a22 2.604380
Rn18a12 TDn18a23 TDn18a24 2.604380
Rn18a13 TDn18a25 TDn18a26 2.604380
Rn18a14 TDn18a27 TDn18a28 2.604380
Rn18a15 TDn18a29 TDn18a30 2.604380
Rn18a16 TDn18a31 TDn18a32 2.604380
Rn19a1 TDn19a1 TDn19a2 2.604380
Rn19a2 TDn19a3 TDn19a4 2.604380
Rn19a3 TDn19a5 TDn19a6 2.604380
Rn19a4 TDn19a7 TDn19a8 2.604380
Rn19a5 TDn19a9 TDn19a10 2.604380
Rn19a6 TDn19a11 TDn19a12 2.604380
Rn19a7 TDn19a13 TDn19a14 2.604380
Rn19a8 TDn19a15 TDn19a16 2.604380
Rn19a9 TDn19a17 TDn19a18 2.604380
Rn19a10 TDn19a19 TDn19a20 2.604380
Rn19a11 TDn19a21 TDn19a22 2.604380
Rn19a12 TDn19a23 TDn19a24 2.604380
Rn19a13 TDn19a25 TDn19a26 2.604380
Rn19a14 TDn19a27 TDn19a28 2.604380
Rn19a15 TDn19a29 TDn19a30 2.604380
Rn19a16 TDn19a31 TDn19a32 2.604380
Rn20a1 TDn20a1 TDn20a2 2.604380
Rn20a2 TDn20a3 TDn20a4 2.604380
Rn20a3 TDn20a5 TDn20a6 2.604380
Rn20a4 TDn20a7 TDn20a8 2.604380
Rn20a5 TDn20a9 TDn20a10 2.604380
Rn20a6 TDn20a11 TDn20a12 2.604380
Rn20a7 TDn20a13 TDn20a14 2.604380
Rn20a8 TDn20a15 TDn20a16 2.604380
Rn20a9 TDn20a17 TDn20a18 2.604380
Rn20a10 TDn20a19 TDn20a20 2.604380
Rn20a11 TDn20a21 TDn20a22 2.604380
Rn20a12 TDn20a23 TDn20a24 2.604380
Rn20a13 TDn20a25 TDn20a26 2.604380
Rn20a14 TDn20a27 TDn20a28 2.604380
Rn20a15 TDn20a29 TDn20a30 2.604380
Rn20a16 TDn20a31 TDn20a32 2.604380
Rn21a1 TDn21a1 TDn21a2 2.604380
Rn21a2 TDn21a3 TDn21a4 2.604380
Rn21a3 TDn21a5 TDn21a6 2.604380
Rn21a4 TDn21a7 TDn21a8 2.604380
Rn21a5 TDn21a9 TDn21a10 2.604380
Rn21a6 TDn21a11 TDn21a12 2.604380
Rn21a7 TDn21a13 TDn21a14 2.604380
Rn21a8 TDn21a15 TDn21a16 2.604380
Rn21a9 TDn21a17 TDn21a18 2.604380
Rn21a10 TDn21a19 TDn21a20 2.604380
Rn21a11 TDn21a21 TDn21a22 2.604380
Rn21a12 TDn21a23 TDn21a24 2.604380
Rn21a13 TDn21a25 TDn21a26 2.604380
Rn21a14 TDn21a27 TDn21a28 2.604380
Rn21a15 TDn21a29 TDn21a30 2.604380
Rn21a16 TDn21a31 TDn21a32 2.604380
Rn22a1 TDn22a1 TDn22a2 2.604380
Rn22a2 TDn22a3 TDn22a4 2.604380
Rn22a3 TDn22a5 TDn22a6 2.604380
Rn22a4 TDn22a7 TDn22a8 2.604380
Rn22a5 TDn22a9 TDn22a10 2.604380
Rn22a6 TDn22a11 TDn22a12 2.604380
Rn22a7 TDn22a13 TDn22a14 2.604380
Rn22a8 TDn22a15 TDn22a16 2.604380
Rn22a9 TDn22a17 TDn22a18 2.604380
Rn22a10 TDn22a19 TDn22a20 2.604380
Rn22a11 TDn22a21 TDn22a22 2.604380
Rn22a12 TDn22a23 TDn22a24 2.604380
Rn22a13 TDn22a25 TDn22a26 2.604380
Rn22a14 TDn22a27 TDn22a28 2.604380
Rn22a15 TDn22a29 TDn22a30 2.604380
Rn22a16 TDn22a31 TDn22a32 2.604380
Rn23a1 TDn23a1 TDn23a2 2.604380
Rn23a2 TDn23a3 TDn23a4 2.604380
Rn23a3 TDn23a5 TDn23a6 2.604380
Rn23a4 TDn23a7 TDn23a8 2.604380
Rn23a5 TDn23a9 TDn23a10 2.604380
Rn23a6 TDn23a11 TDn23a12 2.604380
Rn23a7 TDn23a13 TDn23a14 2.604380
Rn23a8 TDn23a15 TDn23a16 2.604380
Rn23a9 TDn23a17 TDn23a18 2.604380
Rn23a10 TDn23a19 TDn23a20 2.604380
Rn23a11 TDn23a21 TDn23a22 2.604380
Rn23a12 TDn23a23 TDn23a24 2.604380
Rn23a13 TDn23a25 TDn23a26 2.604380
Rn23a14 TDn23a27 TDn23a28 2.604380
Rn23a15 TDn23a29 TDn23a30 2.604380
Rn23a16 TDn23a31 TDn23a32 2.604380
Rn24a1 TDn24a1 TDn24a2 2.604380
Rn24a2 TDn24a3 TDn24a4 2.604380
Rn24a3 TDn24a5 TDn24a6 2.604380
Rn24a4 TDn24a7 TDn24a8 2.604380
Rn24a5 TDn24a9 TDn24a10 2.604380
Rn24a6 TDn24a11 TDn24a12 2.604380
Rn24a7 TDn24a13 TDn24a14 2.604380
Rn24a8 TDn24a15 TDn24a16 2.604380
Rn24a9 TDn24a17 TDn24a18 2.604380
Rn24a10 TDn24a19 TDn24a20 2.604380
Rn24a11 TDn24a21 TDn24a22 2.604380
Rn24a12 TDn24a23 TDn24a24 2.604380
Rn24a13 TDn24a25 TDn24a26 2.604380
Rn24a14 TDn24a27 TDn24a28 2.604380
Rn24a15 TDn24a29 TDn24a30 2.604380
Rn24a16 TDn24a31 TDn24a32 2.604380
Rn25a1 TDn25a1 TDn25a2 2.604380
Rn25a2 TDn25a3 TDn25a4 2.604380
Rn25a3 TDn25a5 TDn25a6 2.604380
Rn25a4 TDn25a7 TDn25a8 2.604380
Rn25a5 TDn25a9 TDn25a10 2.604380
Rn25a6 TDn25a11 TDn25a12 2.604380
Rn25a7 TDn25a13 TDn25a14 2.604380
Rn25a8 TDn25a15 TDn25a16 2.604380
Rn25a9 TDn25a17 TDn25a18 2.604380
Rn25a10 TDn25a19 TDn25a20 2.604380
Rn25a11 TDn25a21 TDn25a22 2.604380
Rn25a12 TDn25a23 TDn25a24 2.604380
Rn25a13 TDn25a25 TDn25a26 2.604380
Rn25a14 TDn25a27 TDn25a28 2.604380
Rn25a15 TDn25a29 TDn25a30 2.604380
Rn25a16 TDn25a31 TDn25a32 2.604380
Rn26a1 TDn26a1 TDn26a2 2.604380
Rn26a2 TDn26a3 TDn26a4 2.604380
Rn26a3 TDn26a5 TDn26a6 2.604380
Rn26a4 TDn26a7 TDn26a8 2.604380
Rn26a5 TDn26a9 TDn26a10 2.604380
Rn26a6 TDn26a11 TDn26a12 2.604380
Rn26a7 TDn26a13 TDn26a14 2.604380
Rn26a8 TDn26a15 TDn26a16 2.604380
Rn26a9 TDn26a17 TDn26a18 2.604380
Rn26a10 TDn26a19 TDn26a20 2.604380
Rn26a11 TDn26a21 TDn26a22 2.604380
Rn26a12 TDn26a23 TDn26a24 2.604380
Rn26a13 TDn26a25 TDn26a26 2.604380
Rn26a14 TDn26a27 TDn26a28 2.604380
Rn26a15 TDn26a29 TDn26a30 2.604380
Rn26a16 TDn26a31 TDn26a32 2.604380
Rn27a1 TDn27a1 TDn27a2 2.604380
Rn27a2 TDn27a3 TDn27a4 2.604380
Rn27a3 TDn27a5 TDn27a6 2.604380
Rn27a4 TDn27a7 TDn27a8 2.604380
Rn27a5 TDn27a9 TDn27a10 2.604380
Rn27a6 TDn27a11 TDn27a12 2.604380
Rn27a7 TDn27a13 TDn27a14 2.604380
Rn27a8 TDn27a15 TDn27a16 2.604380
Rn27a9 TDn27a17 TDn27a18 2.604380
Rn27a10 TDn27a19 TDn27a20 2.604380
Rn27a11 TDn27a21 TDn27a22 2.604380
Rn27a12 TDn27a23 TDn27a24 2.604380
Rn27a13 TDn27a25 TDn27a26 2.604380
Rn27a14 TDn27a27 TDn27a28 2.604380
Rn27a15 TDn27a29 TDn27a30 2.604380
Rn27a16 TDn27a31 TDn27a32 2.604380
Rn28a1 TDn28a1 TDn28a2 2.604380
Rn28a2 TDn28a3 TDn28a4 2.604380
Rn28a3 TDn28a5 TDn28a6 2.604380
Rn28a4 TDn28a7 TDn28a8 2.604380
Rn28a5 TDn28a9 TDn28a10 2.604380
Rn28a6 TDn28a11 TDn28a12 2.604380
Rn28a7 TDn28a13 TDn28a14 2.604380
Rn28a8 TDn28a15 TDn28a16 2.604380
Rn28a9 TDn28a17 TDn28a18 2.604380
Rn28a10 TDn28a19 TDn28a20 2.604380
Rn28a11 TDn28a21 TDn28a22 2.604380
Rn28a12 TDn28a23 TDn28a24 2.604380
Rn28a13 TDn28a25 TDn28a26 2.604380
Rn28a14 TDn28a27 TDn28a28 2.604380
Rn28a15 TDn28a29 TDn28a30 2.604380
Rn28a16 TDn28a31 TDn28a32 2.604380
Rn29a1 TDn29a1 TDn29a2 2.604380
Rn29a2 TDn29a3 TDn29a4 2.604380
Rn29a3 TDn29a5 TDn29a6 2.604380
Rn29a4 TDn29a7 TDn29a8 2.604380
Rn29a5 TDn29a9 TDn29a10 2.604380
Rn29a6 TDn29a11 TDn29a12 2.604380
Rn29a7 TDn29a13 TDn29a14 2.604380
Rn29a8 TDn29a15 TDn29a16 2.604380
Rn29a9 TDn29a17 TDn29a18 2.604380
Rn29a10 TDn29a19 TDn29a20 2.604380
Rn29a11 TDn29a21 TDn29a22 2.604380
Rn29a12 TDn29a23 TDn29a24 2.604380
Rn29a13 TDn29a25 TDn29a26 2.604380
Rn29a14 TDn29a27 TDn29a28 2.604380
Rn29a15 TDn29a29 TDn29a30 2.604380
Rn29a16 TDn29a31 TDn29a32 2.604380
Rn30a1 TDn30a1 TDn30a2 2.604380
Rn30a2 TDn30a3 TDn30a4 2.604380
Rn30a3 TDn30a5 TDn30a6 2.604380
Rn30a4 TDn30a7 TDn30a8 2.604380
Rn30a5 TDn30a9 TDn30a10 2.604380
Rn30a6 TDn30a11 TDn30a12 2.604380
Rn30a7 TDn30a13 TDn30a14 2.604380
Rn30a8 TDn30a15 TDn30a16 2.604380
Rn30a9 TDn30a17 TDn30a18 2.604380
Rn30a10 TDn30a19 TDn30a20 2.604380
Rn30a11 TDn30a21 TDn30a22 2.604380
Rn30a12 TDn30a23 TDn30a24 2.604380
Rn30a13 TDn30a25 TDn30a26 2.604380
Rn30a14 TDn30a27 TDn30a28 2.604380
Rn30a15 TDn30a29 TDn30a30 2.604380
Rn30a16 TDn30a31 TDn30a32 2.604380
Rn31a1 TDn31a1 TDn31a2 2.604380
Rn31a2 TDn31a3 TDn31a4 2.604380
Rn31a3 TDn31a5 TDn31a6 2.604380
Rn31a4 TDn31a7 TDn31a8 2.604380
Rn31a5 TDn31a9 TDn31a10 2.604380
Rn31a6 TDn31a11 TDn31a12 2.604380
Rn31a7 TDn31a13 TDn31a14 2.604380
Rn31a8 TDn31a15 TDn31a16 2.604380
Rn31a9 TDn31a17 TDn31a18 2.604380
Rn31a10 TDn31a19 TDn31a20 2.604380
Rn31a11 TDn31a21 TDn31a22 2.604380
Rn31a12 TDn31a23 TDn31a24 2.604380
Rn31a13 TDn31a25 TDn31a26 2.604380
Rn31a14 TDn31a27 TDn31a28 2.604380
Rn31a15 TDn31a29 TDn31a30 2.604380
Rn31a16 TDn31a31 TDn31a32 2.604380
Rn32a1 TDn32a1 TDn32a2 2.604380
Rn32a2 TDn32a3 TDn32a4 2.604380
Rn32a3 TDn32a5 TDn32a6 2.604380
Rn32a4 TDn32a7 TDn32a8 2.604380
Rn32a5 TDn32a9 TDn32a10 2.604380
Rn32a6 TDn32a11 TDn32a12 2.604380
Rn32a7 TDn32a13 TDn32a14 2.604380
Rn32a8 TDn32a15 TDn32a16 2.604380
Rn32a9 TDn32a17 TDn32a18 2.604380
Rn32a10 TDn32a19 TDn32a20 2.604380
Rn32a11 TDn32a21 TDn32a22 2.604380
Rn32a12 TDn32a23 TDn32a24 2.604380
Rn32a13 TDn32a25 TDn32a26 2.604380
Rn32a14 TDn32a27 TDn32a28 2.604380
Rn32a15 TDn32a29 TDn32a30 2.604380
Rn32a16 TDn32a31 TDn32a32 2.604380
Rnva1 TDnva1 TDnva2 2.603750
Rnva2 TDnva3 TDnva4 2.603750
Rnva3 TDnva5 TDnva6 2.603750
Rnva4 TDnva7 TDnva8 2.603750
Rnva5 TDnva9 TDnva10 2.603750
Rnva6 TDnva11 TDnva12 2.603750
Rnva7 TDnva13 TDnva14 2.603750
Rnva8 TDnva15 TDnva16 2.603750
Rnva9 TDnva17 TDnva18 2.603750
Rnva10 TDnva19 TDnva20 2.603750
Rnva11 TDnva21 TDnva22 2.603750
Rnva12 TDnva23 TDnva24 2.603750
Rnva13 TDnva25 TDnva26 2.603750
Rnva14 TDnva27 TDnva28 2.603750
Rnva15 TDnva29 TDnva30 2.603750
Rnva16 TDnva31 TDnva32 2.603750
Lnga1 TDnga2 TDnga3 8.243750e-010
Lnga2 TDnga4 TDnga5 8.243750e-010
Lnga3 TDnga6 TDnga7 8.243750e-010
Lnga4 TDnga8 TDnga9 8.243750e-010
Lnga5 TDnga10 TDnga11 8.243750e-010
Lnga6 TDnga12 TDnga13 8.243750e-010
Lnga7 TDnga14 TDnga15 8.243750e-010
Lnga8 TDnga16 TDnga17 8.243750e-010
Lnga9 TDnga18 TDnga19 8.243750e-010
Lnga10 TDnga20 TDnga21 8.243750e-010
Lnga11 TDnga22 TDnga23 8.243750e-010
Lnga12 TDnga24 TDnga25 8.243750e-010
Lnga13 TDnga26 TDnga27 8.243750e-010
Lnga14 TDnga28 TDnga29 8.243750e-010
Lnga15 TDnga30 TDnga31 8.243750e-010
Lnga16 TDnga32 TDnga33 8.243750e-010
Ln1a1 TDn1a2 TDn1a3 8.243750e-010
Ln1a2 TDn1a4 TDn1a5 8.243750e-010
Ln1a3 TDn1a6 TDn1a7 8.243750e-010
Ln1a4 TDn1a8 TDn1a9 8.243750e-010
Ln1a5 TDn1a10 TDn1a11 8.243750e-010
Ln1a6 TDn1a12 TDn1a13 8.243750e-010
Ln1a7 TDn1a14 TDn1a15 8.243750e-010
Ln1a8 TDn1a16 TDn1a17 8.243750e-010
Ln1a9 TDn1a18 TDn1a19 8.243750e-010
Ln1a10 TDn1a20 TDn1a21 8.243750e-010
Ln1a11 TDn1a22 TDn1a23 8.243750e-010
Ln1a12 TDn1a24 TDn1a25 8.243750e-010
Ln1a13 TDn1a26 TDn1a27 8.243750e-010
Ln1a14 TDn1a28 TDn1a29 8.243750e-010
Ln1a15 TDn1a30 TDn1a31 8.243750e-010
Ln1a16 TDn1a32 TDn1a33 8.243750e-010
Ln2a1 TDn2a2 TDn2a3 8.243750e-010
Ln2a2 TDn2a4 TDn2a5 8.243750e-010
Ln2a3 TDn2a6 TDn2a7 8.243750e-010
Ln2a4 TDn2a8 TDn2a9 8.243750e-010
Ln2a5 TDn2a10 TDn2a11 8.243750e-010
Ln2a6 TDn2a12 TDn2a13 8.243750e-010
Ln2a7 TDn2a14 TDn2a15 8.243750e-010
Ln2a8 TDn2a16 TDn2a17 8.243750e-010
Ln2a9 TDn2a18 TDn2a19 8.243750e-010
Ln2a10 TDn2a20 TDn2a21 8.243750e-010
Ln2a11 TDn2a22 TDn2a23 8.243750e-010
Ln2a12 TDn2a24 TDn2a25 8.243750e-010
Ln2a13 TDn2a26 TDn2a27 8.243750e-010
Ln2a14 TDn2a28 TDn2a29 8.243750e-010
Ln2a15 TDn2a30 TDn2a31 8.243750e-010
Ln2a16 TDn2a32 TDn2a33 8.243750e-010
Ln3a1 TDn3a2 TDn3a3 8.243750e-010
Ln3a2 TDn3a4 TDn3a5 8.243750e-010
Ln3a3 TDn3a6 TDn3a7 8.243750e-010
Ln3a4 TDn3a8 TDn3a9 8.243750e-010
Ln3a5 TDn3a10 TDn3a11 8.243750e-010
Ln3a6 TDn3a12 TDn3a13 8.243750e-010
Ln3a7 TDn3a14 TDn3a15 8.243750e-010
Ln3a8 TDn3a16 TDn3a17 8.243750e-010
Ln3a9 TDn3a18 TDn3a19 8.243750e-010
Ln3a10 TDn3a20 TDn3a21 8.243750e-010
Ln3a11 TDn3a22 TDn3a23 8.243750e-010
Ln3a12 TDn3a24 TDn3a25 8.243750e-010
Ln3a13 TDn3a26 TDn3a27 8.243750e-010
Ln3a14 TDn3a28 TDn3a29 8.243750e-010
Ln3a15 TDn3a30 TDn3a31 8.243750e-010
Ln3a16 TDn3a32 TDn3a33 8.243750e-010
Ln4a1 TDn4a2 TDn4a3 8.243750e-010
Ln4a2 TDn4a4 TDn4a5 8.243750e-010
Ln4a3 TDn4a6 TDn4a7 8.243750e-010
Ln4a4 TDn4a8 TDn4a9 8.243750e-010
Ln4a5 TDn4a10 TDn4a11 8.243750e-010
Ln4a6 TDn4a12 TDn4a13 8.243750e-010
Ln4a7 TDn4a14 TDn4a15 8.243750e-010
Ln4a8 TDn4a16 TDn4a17 8.243750e-010
Ln4a9 TDn4a18 TDn4a19 8.243750e-010
Ln4a10 TDn4a20 TDn4a21 8.243750e-010
Ln4a11 TDn4a22 TDn4a23 8.243750e-010
Ln4a12 TDn4a24 TDn4a25 8.243750e-010
Ln4a13 TDn4a26 TDn4a27 8.243750e-010
Ln4a14 TDn4a28 TDn4a29 8.243750e-010
Ln4a15 TDn4a30 TDn4a31 8.243750e-010
Ln4a16 TDn4a32 TDn4a33 8.243750e-010
Ln5a1 TDn5a2 TDn5a3 8.243750e-010
Ln5a2 TDn5a4 TDn5a5 8.243750e-010
Ln5a3 TDn5a6 TDn5a7 8.243750e-010
Ln5a4 TDn5a8 TDn5a9 8.243750e-010
Ln5a5 TDn5a10 TDn5a11 8.243750e-010
Ln5a6 TDn5a12 TDn5a13 8.243750e-010
Ln5a7 TDn5a14 TDn5a15 8.243750e-010
Ln5a8 TDn5a16 TDn5a17 8.243750e-010
Ln5a9 TDn5a18 TDn5a19 8.243750e-010
Ln5a10 TDn5a20 TDn5a21 8.243750e-010
Ln5a11 TDn5a22 TDn5a23 8.243750e-010
Ln5a12 TDn5a24 TDn5a25 8.243750e-010
Ln5a13 TDn5a26 TDn5a27 8.243750e-010
Ln5a14 TDn5a28 TDn5a29 8.243750e-010
Ln5a15 TDn5a30 TDn5a31 8.243750e-010
Ln5a16 TDn5a32 TDn5a33 8.243750e-010
Ln6a1 TDn6a2 TDn6a3 8.243750e-010
Ln6a2 TDn6a4 TDn6a5 8.243750e-010
Ln6a3 TDn6a6 TDn6a7 8.243750e-010
Ln6a4 TDn6a8 TDn6a9 8.243750e-010
Ln6a5 TDn6a10 TDn6a11 8.243750e-010
Ln6a6 TDn6a12 TDn6a13 8.243750e-010
Ln6a7 TDn6a14 TDn6a15 8.243750e-010
Ln6a8 TDn6a16 TDn6a17 8.243750e-010
Ln6a9 TDn6a18 TDn6a19 8.243750e-010
Ln6a10 TDn6a20 TDn6a21 8.243750e-010
Ln6a11 TDn6a22 TDn6a23 8.243750e-010
Ln6a12 TDn6a24 TDn6a25 8.243750e-010
Ln6a13 TDn6a26 TDn6a27 8.243750e-010
Ln6a14 TDn6a28 TDn6a29 8.243750e-010
Ln6a15 TDn6a30 TDn6a31 8.243750e-010
Ln6a16 TDn6a32 TDn6a33 8.243750e-010
Ln7a1 TDn7a2 TDn7a3 8.243750e-010
Ln7a2 TDn7a4 TDn7a5 8.243750e-010
Ln7a3 TDn7a6 TDn7a7 8.243750e-010
Ln7a4 TDn7a8 TDn7a9 8.243750e-010
Ln7a5 TDn7a10 TDn7a11 8.243750e-010
Ln7a6 TDn7a12 TDn7a13 8.243750e-010
Ln7a7 TDn7a14 TDn7a15 8.243750e-010
Ln7a8 TDn7a16 TDn7a17 8.243750e-010
Ln7a9 TDn7a18 TDn7a19 8.243750e-010
Ln7a10 TDn7a20 TDn7a21 8.243750e-010
Ln7a11 TDn7a22 TDn7a23 8.243750e-010
Ln7a12 TDn7a24 TDn7a25 8.243750e-010
Ln7a13 TDn7a26 TDn7a27 8.243750e-010
Ln7a14 TDn7a28 TDn7a29 8.243750e-010
Ln7a15 TDn7a30 TDn7a31 8.243750e-010
Ln7a16 TDn7a32 TDn7a33 8.243750e-010
Ln8a1 TDn8a2 TDn8a3 8.243750e-010
Ln8a2 TDn8a4 TDn8a5 8.243750e-010
Ln8a3 TDn8a6 TDn8a7 8.243750e-010
Ln8a4 TDn8a8 TDn8a9 8.243750e-010
Ln8a5 TDn8a10 TDn8a11 8.243750e-010
Ln8a6 TDn8a12 TDn8a13 8.243750e-010
Ln8a7 TDn8a14 TDn8a15 8.243750e-010
Ln8a8 TDn8a16 TDn8a17 8.243750e-010
Ln8a9 TDn8a18 TDn8a19 8.243750e-010
Ln8a10 TDn8a20 TDn8a21 8.243750e-010
Ln8a11 TDn8a22 TDn8a23 8.243750e-010
Ln8a12 TDn8a24 TDn8a25 8.243750e-010
Ln8a13 TDn8a26 TDn8a27 8.243750e-010
Ln8a14 TDn8a28 TDn8a29 8.243750e-010
Ln8a15 TDn8a30 TDn8a31 8.243750e-010
Ln8a16 TDn8a32 TDn8a33 8.243750e-010
Ln9a1 TDn9a2 TDn9a3 8.243750e-010
Ln9a2 TDn9a4 TDn9a5 8.243750e-010
Ln9a3 TDn9a6 TDn9a7 8.243750e-010
Ln9a4 TDn9a8 TDn9a9 8.243750e-010
Ln9a5 TDn9a10 TDn9a11 8.243750e-010
Ln9a6 TDn9a12 TDn9a13 8.243750e-010
Ln9a7 TDn9a14 TDn9a15 8.243750e-010
Ln9a8 TDn9a16 TDn9a17 8.243750e-010
Ln9a9 TDn9a18 TDn9a19 8.243750e-010
Ln9a10 TDn9a20 TDn9a21 8.243750e-010
Ln9a11 TDn9a22 TDn9a23 8.243750e-010
Ln9a12 TDn9a24 TDn9a25 8.243750e-010
Ln9a13 TDn9a26 TDn9a27 8.243750e-010
Ln9a14 TDn9a28 TDn9a29 8.243750e-010
Ln9a15 TDn9a30 TDn9a31 8.243750e-010
Ln9a16 TDn9a32 TDn9a33 8.243750e-010
Ln10a1 TDn10a2 TDn10a3 8.243750e-010
Ln10a2 TDn10a4 TDn10a5 8.243750e-010
Ln10a3 TDn10a6 TDn10a7 8.243750e-010
Ln10a4 TDn10a8 TDn10a9 8.243750e-010
Ln10a5 TDn10a10 TDn10a11 8.243750e-010
Ln10a6 TDn10a12 TDn10a13 8.243750e-010
Ln10a7 TDn10a14 TDn10a15 8.243750e-010
Ln10a8 TDn10a16 TDn10a17 8.243750e-010
Ln10a9 TDn10a18 TDn10a19 8.243750e-010
Ln10a10 TDn10a20 TDn10a21 8.243750e-010
Ln10a11 TDn10a22 TDn10a23 8.243750e-010
Ln10a12 TDn10a24 TDn10a25 8.243750e-010
Ln10a13 TDn10a26 TDn10a27 8.243750e-010
Ln10a14 TDn10a28 TDn10a29 8.243750e-010
Ln10a15 TDn10a30 TDn10a31 8.243750e-010
Ln10a16 TDn10a32 TDn10a33 8.243750e-010
Ln11a1 TDn11a2 TDn11a3 8.243750e-010
Ln11a2 TDn11a4 TDn11a5 8.243750e-010
Ln11a3 TDn11a6 TDn11a7 8.243750e-010
Ln11a4 TDn11a8 TDn11a9 8.243750e-010
Ln11a5 TDn11a10 TDn11a11 8.243750e-010
Ln11a6 TDn11a12 TDn11a13 8.243750e-010
Ln11a7 TDn11a14 TDn11a15 8.243750e-010
Ln11a8 TDn11a16 TDn11a17 8.243750e-010
Ln11a9 TDn11a18 TDn11a19 8.243750e-010
Ln11a10 TDn11a20 TDn11a21 8.243750e-010
Ln11a11 TDn11a22 TDn11a23 8.243750e-010
Ln11a12 TDn11a24 TDn11a25 8.243750e-010
Ln11a13 TDn11a26 TDn11a27 8.243750e-010
Ln11a14 TDn11a28 TDn11a29 8.243750e-010
Ln11a15 TDn11a30 TDn11a31 8.243750e-010
Ln11a16 TDn11a32 TDn11a33 8.243750e-010
Ln12a1 TDn12a2 TDn12a3 8.243750e-010
Ln12a2 TDn12a4 TDn12a5 8.243750e-010
Ln12a3 TDn12a6 TDn12a7 8.243750e-010
Ln12a4 TDn12a8 TDn12a9 8.243750e-010
Ln12a5 TDn12a10 TDn12a11 8.243750e-010
Ln12a6 TDn12a12 TDn12a13 8.243750e-010
Ln12a7 TDn12a14 TDn12a15 8.243750e-010
Ln12a8 TDn12a16 TDn12a17 8.243750e-010
Ln12a9 TDn12a18 TDn12a19 8.243750e-010
Ln12a10 TDn12a20 TDn12a21 8.243750e-010
Ln12a11 TDn12a22 TDn12a23 8.243750e-010
Ln12a12 TDn12a24 TDn12a25 8.243750e-010
Ln12a13 TDn12a26 TDn12a27 8.243750e-010
Ln12a14 TDn12a28 TDn12a29 8.243750e-010
Ln12a15 TDn12a30 TDn12a31 8.243750e-010
Ln12a16 TDn12a32 TDn12a33 8.243750e-010
Ln13a1 TDn13a2 TDn13a3 8.243750e-010
Ln13a2 TDn13a4 TDn13a5 8.243750e-010
Ln13a3 TDn13a6 TDn13a7 8.243750e-010
Ln13a4 TDn13a8 TDn13a9 8.243750e-010
Ln13a5 TDn13a10 TDn13a11 8.243750e-010
Ln13a6 TDn13a12 TDn13a13 8.243750e-010
Ln13a7 TDn13a14 TDn13a15 8.243750e-010
Ln13a8 TDn13a16 TDn13a17 8.243750e-010
Ln13a9 TDn13a18 TDn13a19 8.243750e-010
Ln13a10 TDn13a20 TDn13a21 8.243750e-010
Ln13a11 TDn13a22 TDn13a23 8.243750e-010
Ln13a12 TDn13a24 TDn13a25 8.243750e-010
Ln13a13 TDn13a26 TDn13a27 8.243750e-010
Ln13a14 TDn13a28 TDn13a29 8.243750e-010
Ln13a15 TDn13a30 TDn13a31 8.243750e-010
Ln13a16 TDn13a32 TDn13a33 8.243750e-010
Ln14a1 TDn14a2 TDn14a3 8.243750e-010
Ln14a2 TDn14a4 TDn14a5 8.243750e-010
Ln14a3 TDn14a6 TDn14a7 8.243750e-010
Ln14a4 TDn14a8 TDn14a9 8.243750e-010
Ln14a5 TDn14a10 TDn14a11 8.243750e-010
Ln14a6 TDn14a12 TDn14a13 8.243750e-010
Ln14a7 TDn14a14 TDn14a15 8.243750e-010
Ln14a8 TDn14a16 TDn14a17 8.243750e-010
Ln14a9 TDn14a18 TDn14a19 8.243750e-010
Ln14a10 TDn14a20 TDn14a21 8.243750e-010
Ln14a11 TDn14a22 TDn14a23 8.243750e-010
Ln14a12 TDn14a24 TDn14a25 8.243750e-010
Ln14a13 TDn14a26 TDn14a27 8.243750e-010
Ln14a14 TDn14a28 TDn14a29 8.243750e-010
Ln14a15 TDn14a30 TDn14a31 8.243750e-010
Ln14a16 TDn14a32 TDn14a33 8.243750e-010
Ln15a1 TDn15a2 TDn15a3 8.243750e-010
Ln15a2 TDn15a4 TDn15a5 8.243750e-010
Ln15a3 TDn15a6 TDn15a7 8.243750e-010
Ln15a4 TDn15a8 TDn15a9 8.243750e-010
Ln15a5 TDn15a10 TDn15a11 8.243750e-010
Ln15a6 TDn15a12 TDn15a13 8.243750e-010
Ln15a7 TDn15a14 TDn15a15 8.243750e-010
Ln15a8 TDn15a16 TDn15a17 8.243750e-010
Ln15a9 TDn15a18 TDn15a19 8.243750e-010
Ln15a10 TDn15a20 TDn15a21 8.243750e-010
Ln15a11 TDn15a22 TDn15a23 8.243750e-010
Ln15a12 TDn15a24 TDn15a25 8.243750e-010
Ln15a13 TDn15a26 TDn15a27 8.243750e-010
Ln15a14 TDn15a28 TDn15a29 8.243750e-010
Ln15a15 TDn15a30 TDn15a31 8.243750e-010
Ln15a16 TDn15a32 TDn15a33 8.243750e-010
Ln16a1 TDn16a2 TDn16a3 8.243750e-010
Ln16a2 TDn16a4 TDn16a5 8.243750e-010
Ln16a3 TDn16a6 TDn16a7 8.243750e-010
Ln16a4 TDn16a8 TDn16a9 8.243750e-010
Ln16a5 TDn16a10 TDn16a11 8.243750e-010
Ln16a6 TDn16a12 TDn16a13 8.243750e-010
Ln16a7 TDn16a14 TDn16a15 8.243750e-010
Ln16a8 TDn16a16 TDn16a17 8.243750e-010
Ln16a9 TDn16a18 TDn16a19 8.243750e-010
Ln16a10 TDn16a20 TDn16a21 8.243750e-010
Ln16a11 TDn16a22 TDn16a23 8.243750e-010
Ln16a12 TDn16a24 TDn16a25 8.243750e-010
Ln16a13 TDn16a26 TDn16a27 8.243750e-010
Ln16a14 TDn16a28 TDn16a29 8.243750e-010
Ln16a15 TDn16a30 TDn16a31 8.243750e-010
Ln16a16 TDn16a32 TDn16a33 8.243750e-010
Ln17a1 TDn17a2 TDn17a3 8.243750e-010
Ln17a2 TDn17a4 TDn17a5 8.243750e-010
Ln17a3 TDn17a6 TDn17a7 8.243750e-010
Ln17a4 TDn17a8 TDn17a9 8.243750e-010
Ln17a5 TDn17a10 TDn17a11 8.243750e-010
Ln17a6 TDn17a12 TDn17a13 8.243750e-010
Ln17a7 TDn17a14 TDn17a15 8.243750e-010
Ln17a8 TDn17a16 TDn17a17 8.243750e-010
Ln17a9 TDn17a18 TDn17a19 8.243750e-010
Ln17a10 TDn17a20 TDn17a21 8.243750e-010
Ln17a11 TDn17a22 TDn17a23 8.243750e-010
Ln17a12 TDn17a24 TDn17a25 8.243750e-010
Ln17a13 TDn17a26 TDn17a27 8.243750e-010
Ln17a14 TDn17a28 TDn17a29 8.243750e-010
Ln17a15 TDn17a30 TDn17a31 8.243750e-010
Ln17a16 TDn17a32 TDn17a33 8.243750e-010
Ln18a1 TDn18a2 TDn18a3 8.243750e-010
Ln18a2 TDn18a4 TDn18a5 8.243750e-010
Ln18a3 TDn18a6 TDn18a7 8.243750e-010
Ln18a4 TDn18a8 TDn18a9 8.243750e-010
Ln18a5 TDn18a10 TDn18a11 8.243750e-010
Ln18a6 TDn18a12 TDn18a13 8.243750e-010
Ln18a7 TDn18a14 TDn18a15 8.243750e-010
Ln18a8 TDn18a16 TDn18a17 8.243750e-010
Ln18a9 TDn18a18 TDn18a19 8.243750e-010
Ln18a10 TDn18a20 TDn18a21 8.243750e-010
Ln18a11 TDn18a22 TDn18a23 8.243750e-010
Ln18a12 TDn18a24 TDn18a25 8.243750e-010
Ln18a13 TDn18a26 TDn18a27 8.243750e-010
Ln18a14 TDn18a28 TDn18a29 8.243750e-010
Ln18a15 TDn18a30 TDn18a31 8.243750e-010
Ln18a16 TDn18a32 TDn18a33 8.243750e-010
Ln19a1 TDn19a2 TDn19a3 8.243750e-010
Ln19a2 TDn19a4 TDn19a5 8.243750e-010
Ln19a3 TDn19a6 TDn19a7 8.243750e-010
Ln19a4 TDn19a8 TDn19a9 8.243750e-010
Ln19a5 TDn19a10 TDn19a11 8.243750e-010
Ln19a6 TDn19a12 TDn19a13 8.243750e-010
Ln19a7 TDn19a14 TDn19a15 8.243750e-010
Ln19a8 TDn19a16 TDn19a17 8.243750e-010
Ln19a9 TDn19a18 TDn19a19 8.243750e-010
Ln19a10 TDn19a20 TDn19a21 8.243750e-010
Ln19a11 TDn19a22 TDn19a23 8.243750e-010
Ln19a12 TDn19a24 TDn19a25 8.243750e-010
Ln19a13 TDn19a26 TDn19a27 8.243750e-010
Ln19a14 TDn19a28 TDn19a29 8.243750e-010
Ln19a15 TDn19a30 TDn19a31 8.243750e-010
Ln19a16 TDn19a32 TDn19a33 8.243750e-010
Ln20a1 TDn20a2 TDn20a3 8.243750e-010
Ln20a2 TDn20a4 TDn20a5 8.243750e-010
Ln20a3 TDn20a6 TDn20a7 8.243750e-010
Ln20a4 TDn20a8 TDn20a9 8.243750e-010
Ln20a5 TDn20a10 TDn20a11 8.243750e-010
Ln20a6 TDn20a12 TDn20a13 8.243750e-010
Ln20a7 TDn20a14 TDn20a15 8.243750e-010
Ln20a8 TDn20a16 TDn20a17 8.243750e-010
Ln20a9 TDn20a18 TDn20a19 8.243750e-010
Ln20a10 TDn20a20 TDn20a21 8.243750e-010
Ln20a11 TDn20a22 TDn20a23 8.243750e-010
Ln20a12 TDn20a24 TDn20a25 8.243750e-010
Ln20a13 TDn20a26 TDn20a27 8.243750e-010
Ln20a14 TDn20a28 TDn20a29 8.243750e-010
Ln20a15 TDn20a30 TDn20a31 8.243750e-010
Ln20a16 TDn20a32 TDn20a33 8.243750e-010
Ln21a1 TDn21a2 TDn21a3 8.243750e-010
Ln21a2 TDn21a4 TDn21a5 8.243750e-010
Ln21a3 TDn21a6 TDn21a7 8.243750e-010
Ln21a4 TDn21a8 TDn21a9 8.243750e-010
Ln21a5 TDn21a10 TDn21a11 8.243750e-010
Ln21a6 TDn21a12 TDn21a13 8.243750e-010
Ln21a7 TDn21a14 TDn21a15 8.243750e-010
Ln21a8 TDn21a16 TDn21a17 8.243750e-010
Ln21a9 TDn21a18 TDn21a19 8.243750e-010
Ln21a10 TDn21a20 TDn21a21 8.243750e-010
Ln21a11 TDn21a22 TDn21a23 8.243750e-010
Ln21a12 TDn21a24 TDn21a25 8.243750e-010
Ln21a13 TDn21a26 TDn21a27 8.243750e-010
Ln21a14 TDn21a28 TDn21a29 8.243750e-010
Ln21a15 TDn21a30 TDn21a31 8.243750e-010
Ln21a16 TDn21a32 TDn21a33 8.243750e-010
Ln22a1 TDn22a2 TDn22a3 8.243750e-010
Ln22a2 TDn22a4 TDn22a5 8.243750e-010
Ln22a3 TDn22a6 TDn22a7 8.243750e-010
Ln22a4 TDn22a8 TDn22a9 8.243750e-010
Ln22a5 TDn22a10 TDn22a11 8.243750e-010
Ln22a6 TDn22a12 TDn22a13 8.243750e-010
Ln22a7 TDn22a14 TDn22a15 8.243750e-010
Ln22a8 TDn22a16 TDn22a17 8.243750e-010
Ln22a9 TDn22a18 TDn22a19 8.243750e-010
Ln22a10 TDn22a20 TDn22a21 8.243750e-010
Ln22a11 TDn22a22 TDn22a23 8.243750e-010
Ln22a12 TDn22a24 TDn22a25 8.243750e-010
Ln22a13 TDn22a26 TDn22a27 8.243750e-010
Ln22a14 TDn22a28 TDn22a29 8.243750e-010
Ln22a15 TDn22a30 TDn22a31 8.243750e-010
Ln22a16 TDn22a32 TDn22a33 8.243750e-010
Ln23a1 TDn23a2 TDn23a3 8.243750e-010
Ln23a2 TDn23a4 TDn23a5 8.243750e-010
Ln23a3 TDn23a6 TDn23a7 8.243750e-010
Ln23a4 TDn23a8 TDn23a9 8.243750e-010
Ln23a5 TDn23a10 TDn23a11 8.243750e-010
Ln23a6 TDn23a12 TDn23a13 8.243750e-010
Ln23a7 TDn23a14 TDn23a15 8.243750e-010
Ln23a8 TDn23a16 TDn23a17 8.243750e-010
Ln23a9 TDn23a18 TDn23a19 8.243750e-010
Ln23a10 TDn23a20 TDn23a21 8.243750e-010
Ln23a11 TDn23a22 TDn23a23 8.243750e-010
Ln23a12 TDn23a24 TDn23a25 8.243750e-010
Ln23a13 TDn23a26 TDn23a27 8.243750e-010
Ln23a14 TDn23a28 TDn23a29 8.243750e-010
Ln23a15 TDn23a30 TDn23a31 8.243750e-010
Ln23a16 TDn23a32 TDn23a33 8.243750e-010
Ln24a1 TDn24a2 TDn24a3 8.243750e-010
Ln24a2 TDn24a4 TDn24a5 8.243750e-010
Ln24a3 TDn24a6 TDn24a7 8.243750e-010
Ln24a4 TDn24a8 TDn24a9 8.243750e-010
Ln24a5 TDn24a10 TDn24a11 8.243750e-010
Ln24a6 TDn24a12 TDn24a13 8.243750e-010
Ln24a7 TDn24a14 TDn24a15 8.243750e-010
Ln24a8 TDn24a16 TDn24a17 8.243750e-010
Ln24a9 TDn24a18 TDn24a19 8.243750e-010
Ln24a10 TDn24a20 TDn24a21 8.243750e-010
Ln24a11 TDn24a22 TDn24a23 8.243750e-010
Ln24a12 TDn24a24 TDn24a25 8.243750e-010
Ln24a13 TDn24a26 TDn24a27 8.243750e-010
Ln24a14 TDn24a28 TDn24a29 8.243750e-010
Ln24a15 TDn24a30 TDn24a31 8.243750e-010
Ln24a16 TDn24a32 TDn24a33 8.243750e-010
Ln25a1 TDn25a2 TDn25a3 8.243750e-010
Ln25a2 TDn25a4 TDn25a5 8.243750e-010
Ln25a3 TDn25a6 TDn25a7 8.243750e-010
Ln25a4 TDn25a8 TDn25a9 8.243750e-010
Ln25a5 TDn25a10 TDn25a11 8.243750e-010
Ln25a6 TDn25a12 TDn25a13 8.243750e-010
Ln25a7 TDn25a14 TDn25a15 8.243750e-010
Ln25a8 TDn25a16 TDn25a17 8.243750e-010
Ln25a9 TDn25a18 TDn25a19 8.243750e-010
Ln25a10 TDn25a20 TDn25a21 8.243750e-010
Ln25a11 TDn25a22 TDn25a23 8.243750e-010
Ln25a12 TDn25a24 TDn25a25 8.243750e-010
Ln25a13 TDn25a26 TDn25a27 8.243750e-010
Ln25a14 TDn25a28 TDn25a29 8.243750e-010
Ln25a15 TDn25a30 TDn25a31 8.243750e-010
Ln25a16 TDn25a32 TDn25a33 8.243750e-010
Ln26a1 TDn26a2 TDn26a3 8.243750e-010
Ln26a2 TDn26a4 TDn26a5 8.243750e-010
Ln26a3 TDn26a6 TDn26a7 8.243750e-010
Ln26a4 TDn26a8 TDn26a9 8.243750e-010
Ln26a5 TDn26a10 TDn26a11 8.243750e-010
Ln26a6 TDn26a12 TDn26a13 8.243750e-010
Ln26a7 TDn26a14 TDn26a15 8.243750e-010
Ln26a8 TDn26a16 TDn26a17 8.243750e-010
Ln26a9 TDn26a18 TDn26a19 8.243750e-010
Ln26a10 TDn26a20 TDn26a21 8.243750e-010
Ln26a11 TDn26a22 TDn26a23 8.243750e-010
Ln26a12 TDn26a24 TDn26a25 8.243750e-010
Ln26a13 TDn26a26 TDn26a27 8.243750e-010
Ln26a14 TDn26a28 TDn26a29 8.243750e-010
Ln26a15 TDn26a30 TDn26a31 8.243750e-010
Ln26a16 TDn26a32 TDn26a33 8.243750e-010
Ln27a1 TDn27a2 TDn27a3 8.243750e-010
Ln27a2 TDn27a4 TDn27a5 8.243750e-010
Ln27a3 TDn27a6 TDn27a7 8.243750e-010
Ln27a4 TDn27a8 TDn27a9 8.243750e-010
Ln27a5 TDn27a10 TDn27a11 8.243750e-010
Ln27a6 TDn27a12 TDn27a13 8.243750e-010
Ln27a7 TDn27a14 TDn27a15 8.243750e-010
Ln27a8 TDn27a16 TDn27a17 8.243750e-010
Ln27a9 TDn27a18 TDn27a19 8.243750e-010
Ln27a10 TDn27a20 TDn27a21 8.243750e-010
Ln27a11 TDn27a22 TDn27a23 8.243750e-010
Ln27a12 TDn27a24 TDn27a25 8.243750e-010
Ln27a13 TDn27a26 TDn27a27 8.243750e-010
Ln27a14 TDn27a28 TDn27a29 8.243750e-010
Ln27a15 TDn27a30 TDn27a31 8.243750e-010
Ln27a16 TDn27a32 TDn27a33 8.243750e-010
Ln28a1 TDn28a2 TDn28a3 8.243750e-010
Ln28a2 TDn28a4 TDn28a5 8.243750e-010
Ln28a3 TDn28a6 TDn28a7 8.243750e-010
Ln28a4 TDn28a8 TDn28a9 8.243750e-010
Ln28a5 TDn28a10 TDn28a11 8.243750e-010
Ln28a6 TDn28a12 TDn28a13 8.243750e-010
Ln28a7 TDn28a14 TDn28a15 8.243750e-010
Ln28a8 TDn28a16 TDn28a17 8.243750e-010
Ln28a9 TDn28a18 TDn28a19 8.243750e-010
Ln28a10 TDn28a20 TDn28a21 8.243750e-010
Ln28a11 TDn28a22 TDn28a23 8.243750e-010
Ln28a12 TDn28a24 TDn28a25 8.243750e-010
Ln28a13 TDn28a26 TDn28a27 8.243750e-010
Ln28a14 TDn28a28 TDn28a29 8.243750e-010
Ln28a15 TDn28a30 TDn28a31 8.243750e-010
Ln28a16 TDn28a32 TDn28a33 8.243750e-010
Ln29a1 TDn29a2 TDn29a3 8.243750e-010
Ln29a2 TDn29a4 TDn29a5 8.243750e-010
Ln29a3 TDn29a6 TDn29a7 8.243750e-010
Ln29a4 TDn29a8 TDn29a9 8.243750e-010
Ln29a5 TDn29a10 TDn29a11 8.243750e-010
Ln29a6 TDn29a12 TDn29a13 8.243750e-010
Ln29a7 TDn29a14 TDn29a15 8.243750e-010
Ln29a8 TDn29a16 TDn29a17 8.243750e-010
Ln29a9 TDn29a18 TDn29a19 8.243750e-010
Ln29a10 TDn29a20 TDn29a21 8.243750e-010
Ln29a11 TDn29a22 TDn29a23 8.243750e-010
Ln29a12 TDn29a24 TDn29a25 8.243750e-010
Ln29a13 TDn29a26 TDn29a27 8.243750e-010
Ln29a14 TDn29a28 TDn29a29 8.243750e-010
Ln29a15 TDn29a30 TDn29a31 8.243750e-010
Ln29a16 TDn29a32 TDn29a33 8.243750e-010
Ln30a1 TDn30a2 TDn30a3 8.243750e-010
Ln30a2 TDn30a4 TDn30a5 8.243750e-010
Ln30a3 TDn30a6 TDn30a7 8.243750e-010
Ln30a4 TDn30a8 TDn30a9 8.243750e-010
Ln30a5 TDn30a10 TDn30a11 8.243750e-010
Ln30a6 TDn30a12 TDn30a13 8.243750e-010
Ln30a7 TDn30a14 TDn30a15 8.243750e-010
Ln30a8 TDn30a16 TDn30a17 8.243750e-010
Ln30a9 TDn30a18 TDn30a19 8.243750e-010
Ln30a10 TDn30a20 TDn30a21 8.243750e-010
Ln30a11 TDn30a22 TDn30a23 8.243750e-010
Ln30a12 TDn30a24 TDn30a25 8.243750e-010
Ln30a13 TDn30a26 TDn30a27 8.243750e-010
Ln30a14 TDn30a28 TDn30a29 8.243750e-010
Ln30a15 TDn30a30 TDn30a31 8.243750e-010
Ln30a16 TDn30a32 TDn30a33 8.243750e-010
Ln31a1 TDn31a2 TDn31a3 8.243750e-010
Ln31a2 TDn31a4 TDn31a5 8.243750e-010
Ln31a3 TDn31a6 TDn31a7 8.243750e-010
Ln31a4 TDn31a8 TDn31a9 8.243750e-010
Ln31a5 TDn31a10 TDn31a11 8.243750e-010
Ln31a6 TDn31a12 TDn31a13 8.243750e-010
Ln31a7 TDn31a14 TDn31a15 8.243750e-010
Ln31a8 TDn31a16 TDn31a17 8.243750e-010
Ln31a9 TDn31a18 TDn31a19 8.243750e-010
Ln31a10 TDn31a20 TDn31a21 8.243750e-010
Ln31a11 TDn31a22 TDn31a23 8.243750e-010
Ln31a12 TDn31a24 TDn31a25 8.243750e-010
Ln31a13 TDn31a26 TDn31a27 8.243750e-010
Ln31a14 TDn31a28 TDn31a29 8.243750e-010
Ln31a15 TDn31a30 TDn31a31 8.243750e-010
Ln31a16 TDn31a32 TDn31a33 8.243750e-010
Ln32a1 TDn32a2 TDn32a3 8.243750e-010
Ln32a2 TDn32a4 TDn32a5 8.243750e-010
Ln32a3 TDn32a6 TDn32a7 8.243750e-010
Ln32a4 TDn32a8 TDn32a9 8.243750e-010
Ln32a5 TDn32a10 TDn32a11 8.243750e-010
Ln32a6 TDn32a12 TDn32a13 8.243750e-010
Ln32a7 TDn32a14 TDn32a15 8.243750e-010
Ln32a8 TDn32a16 TDn32a17 8.243750e-010
Ln32a9 TDn32a18 TDn32a19 8.243750e-010
Ln32a10 TDn32a20 TDn32a21 8.243750e-010
Ln32a11 TDn32a22 TDn32a23 8.243750e-010
Ln32a12 TDn32a24 TDn32a25 8.243750e-010
Ln32a13 TDn32a26 TDn32a27 8.243750e-010
Ln32a14 TDn32a28 TDn32a29 8.243750e-010
Ln32a15 TDn32a30 TDn32a31 8.243750e-010
Ln32a16 TDn32a32 TDn32a33 8.243750e-010
Lnva1 TDnva2 TDnva3 8.243750e-010
Lnva2 TDnva4 TDnva5 8.243750e-010
Lnva3 TDnva6 TDnva7 8.243750e-010
Lnva4 TDnva8 TDnva9 8.243750e-010
Lnva5 TDnva10 TDnva11 8.243750e-010
Lnva6 TDnva12 TDnva13 8.243750e-010
Lnva7 TDnva14 TDnva15 8.243750e-010
Lnva8 TDnva16 TDnva17 8.243750e-010
Lnva9 TDnva18 TDnva19 8.243750e-010
Lnva10 TDnva20 TDnva21 8.243750e-010
Lnva11 TDnva22 TDnva23 8.243750e-010
Lnva12 TDnva24 TDnva25 8.243750e-010
Lnva13 TDnva26 TDnva27 8.243750e-010
Lnva14 TDnva28 TDnva29 8.243750e-010
Lnva15 TDnva30 TDnva31 8.243750e-010
Lnva16 TDnva32 TDnva33 8.243750e-010
Kngan1a1 Lnga1 Ln1a1 0.805155
Kngan1a2 Lnga2 Ln1a2 0.805155
Kngan1a3 Lnga3 Ln1a3 0.805155
Kngan1a4 Lnga4 Ln1a4 0.805155
Kngan1a5 Lnga5 Ln1a5 0.805155
Kngan1a6 Lnga6 Ln1a6 0.805155
Kngan1a7 Lnga7 Ln1a7 0.805155
Kngan1a8 Lnga8 Ln1a8 0.805155
Kngan1a9 Lnga9 Ln1a9 0.805155
Kngan1a10 Lnga10 Ln1a10 0.805155
Kngan1a11 Lnga11 Ln1a11 0.805155
Kngan1a12 Lnga12 Ln1a12 0.805155
Kngan1a13 Lnga13 Ln1a13 0.805155
Kngan1a14 Lnga14 Ln1a14 0.805155
Kngan1a15 Lnga15 Ln1a15 0.805155
Kngan1a16 Lnga16 Ln1a16 0.805155
Kngan2a1 Lnga1 Ln2a1 0.723730
Kngan2a2 Lnga2 Ln2a2 0.723730
Kngan2a3 Lnga3 Ln2a3 0.723730
Kngan2a4 Lnga4 Ln2a4 0.723730
Kngan2a5 Lnga5 Ln2a5 0.723730
Kngan2a6 Lnga6 Ln2a6 0.723730
Kngan2a7 Lnga7 Ln2a7 0.723730
Kngan2a8 Lnga8 Ln2a8 0.723730
Kngan2a9 Lnga9 Ln2a9 0.723730
Kngan2a10 Lnga10 Ln2a10 0.723730
Kngan2a11 Lnga11 Ln2a11 0.723730
Kngan2a12 Lnga12 Ln2a12 0.723730
Kngan2a13 Lnga13 Ln2a13 0.723730
Kngan2a14 Lnga14 Ln2a14 0.723730
Kngan2a15 Lnga15 Ln2a15 0.723730
Kngan2a16 Lnga16 Ln2a16 0.723730
Kngan3a1 Lnga1 Ln3a1 0.675208
Kngan3a2 Lnga2 Ln3a2 0.675208
Kngan3a3 Lnga3 Ln3a3 0.675208
Kngan3a4 Lnga4 Ln3a4 0.675208
Kngan3a5 Lnga5 Ln3a5 0.675208
Kngan3a6 Lnga6 Ln3a6 0.675208
Kngan3a7 Lnga7 Ln3a7 0.675208
Kngan3a8 Lnga8 Ln3a8 0.675208
Kngan3a9 Lnga9 Ln3a9 0.675208
Kngan3a10 Lnga10 Ln3a10 0.675208
Kngan3a11 Lnga11 Ln3a11 0.675208
Kngan3a12 Lnga12 Ln3a12 0.675208
Kngan3a13 Lnga13 Ln3a13 0.675208
Kngan3a14 Lnga14 Ln3a14 0.675208
Kngan3a15 Lnga15 Ln3a15 0.675208
Kngan3a16 Lnga16 Ln3a16 0.675208
Kngan4a1 Lnga1 Ln4a1 0.640637
Kngan4a2 Lnga2 Ln4a2 0.640637
Kngan4a3 Lnga3 Ln4a3 0.640637
Kngan4a4 Lnga4 Ln4a4 0.640637
Kngan4a5 Lnga5 Ln4a5 0.640637
Kngan4a6 Lnga6 Ln4a6 0.640637
Kngan4a7 Lnga7 Ln4a7 0.640637
Kngan4a8 Lnga8 Ln4a8 0.640637
Kngan4a9 Lnga9 Ln4a9 0.640637
Kngan4a10 Lnga10 Ln4a10 0.640637
Kngan4a11 Lnga11 Ln4a11 0.640637
Kngan4a12 Lnga12 Ln4a12 0.640637
Kngan4a13 Lnga13 Ln4a13 0.640637
Kngan4a14 Lnga14 Ln4a14 0.640637
Kngan4a15 Lnga15 Ln4a15 0.640637
Kngan4a16 Lnga16 Ln4a16 0.640637
Kngan5a1 Lnga1 Ln5a1 0.613723
Kngan5a2 Lnga2 Ln5a2 0.613723
Kngan5a3 Lnga3 Ln5a3 0.613723
Kngan5a4 Lnga4 Ln5a4 0.613723
Kngan5a5 Lnga5 Ln5a5 0.613723
Kngan5a6 Lnga6 Ln5a6 0.613723
Kngan5a7 Lnga7 Ln5a7 0.613723
Kngan5a8 Lnga8 Ln5a8 0.613723
Kngan5a9 Lnga9 Ln5a9 0.613723
Kngan5a10 Lnga10 Ln5a10 0.613723
Kngan5a11 Lnga11 Ln5a11 0.613723
Kngan5a12 Lnga12 Ln5a12 0.613723
Kngan5a13 Lnga13 Ln5a13 0.613723
Kngan5a14 Lnga14 Ln5a14 0.613723
Kngan5a15 Lnga15 Ln5a15 0.613723
Kngan5a16 Lnga16 Ln5a16 0.613723
Kngan6a1 Lnga1 Ln6a1 0.591812
Kngan6a2 Lnga2 Ln6a2 0.591812
Kngan6a3 Lnga3 Ln6a3 0.591812
Kngan6a4 Lnga4 Ln6a4 0.591812
Kngan6a5 Lnga5 Ln6a5 0.591812
Kngan6a6 Lnga6 Ln6a6 0.591812
Kngan6a7 Lnga7 Ln6a7 0.591812
Kngan6a8 Lnga8 Ln6a8 0.591812
Kngan6a9 Lnga9 Ln6a9 0.591812
Kngan6a10 Lnga10 Ln6a10 0.591812
Kngan6a11 Lnga11 Ln6a11 0.591812
Kngan6a12 Lnga12 Ln6a12 0.591812
Kngan6a13 Lnga13 Ln6a13 0.591812
Kngan6a14 Lnga14 Ln6a14 0.591812
Kngan6a15 Lnga15 Ln6a15 0.591812
Kngan6a16 Lnga16 Ln6a16 0.591812
Kngan7a1 Lnga1 Ln7a1 0.573237
Kngan7a2 Lnga2 Ln7a2 0.573237
Kngan7a3 Lnga3 Ln7a3 0.573237
Kngan7a4 Lnga4 Ln7a4 0.573237
Kngan7a5 Lnga5 Ln7a5 0.573237
Kngan7a6 Lnga6 Ln7a6 0.573237
Kngan7a7 Lnga7 Ln7a7 0.573237
Kngan7a8 Lnga8 Ln7a8 0.573237
Kngan7a9 Lnga9 Ln7a9 0.573237
Kngan7a10 Lnga10 Ln7a10 0.573237
Kngan7a11 Lnga11 Ln7a11 0.573237
Kngan7a12 Lnga12 Ln7a12 0.573237
Kngan7a13 Lnga13 Ln7a13 0.573237
Kngan7a14 Lnga14 Ln7a14 0.573237
Kngan7a15 Lnga15 Ln7a15 0.573237
Kngan7a16 Lnga16 Ln7a16 0.573237
Kngan8a1 Lnga1 Ln8a1 0.557165
Kngan8a2 Lnga2 Ln8a2 0.557165
Kngan8a3 Lnga3 Ln8a3 0.557165
Kngan8a4 Lnga4 Ln8a4 0.557165
Kngan8a5 Lnga5 Ln8a5 0.557165
Kngan8a6 Lnga6 Ln8a6 0.557165
Kngan8a7 Lnga7 Ln8a7 0.557165
Kngan8a8 Lnga8 Ln8a8 0.557165
Kngan8a9 Lnga9 Ln8a9 0.557165
Kngan8a10 Lnga10 Ln8a10 0.557165
Kngan8a11 Lnga11 Ln8a11 0.557165
Kngan8a12 Lnga12 Ln8a12 0.557165
Kngan8a13 Lnga13 Ln8a13 0.557165
Kngan8a14 Lnga14 Ln8a14 0.557165
Kngan8a15 Lnga15 Ln8a15 0.557165
Kngan8a16 Lnga16 Ln8a16 0.557165
Kngan9a1 Lnga1 Ln9a1 0.542987
Kngan9a2 Lnga2 Ln9a2 0.542987
Kngan9a3 Lnga3 Ln9a3 0.542987
Kngan9a4 Lnga4 Ln9a4 0.542987
Kngan9a5 Lnga5 Ln9a5 0.542987
Kngan9a6 Lnga6 Ln9a6 0.542987
Kngan9a7 Lnga7 Ln9a7 0.542987
Kngan9a8 Lnga8 Ln9a8 0.542987
Kngan9a9 Lnga9 Ln9a9 0.542987
Kngan9a10 Lnga10 Ln9a10 0.542987
Kngan9a11 Lnga11 Ln9a11 0.542987
Kngan9a12 Lnga12 Ln9a12 0.542987
Kngan9a13 Lnga13 Ln9a13 0.542987
Kngan9a14 Lnga14 Ln9a14 0.542987
Kngan9a15 Lnga15 Ln9a15 0.542987
Kngan9a16 Lnga16 Ln9a16 0.542987
Kngan10a1 Lnga1 Ln10a1 0.529400
Kngan10a2 Lnga2 Ln10a2 0.529400
Kngan10a3 Lnga3 Ln10a3 0.529400
Kngan10a4 Lnga4 Ln10a4 0.529400
Kngan10a5 Lnga5 Ln10a5 0.529400
Kngan10a6 Lnga6 Ln10a6 0.529400
Kngan10a7 Lnga7 Ln10a7 0.529400
Kngan10a8 Lnga8 Ln10a8 0.529400
Kngan10a9 Lnga9 Ln10a9 0.529400
Kngan10a10 Lnga10 Ln10a10 0.529400
Kngan10a11 Lnga11 Ln10a11 0.529400
Kngan10a12 Lnga12 Ln10a12 0.529400
Kngan10a13 Lnga13 Ln10a13 0.529400
Kngan10a14 Lnga14 Ln10a14 0.529400
Kngan10a15 Lnga15 Ln10a15 0.529400
Kngan10a16 Lnga16 Ln10a16 0.529400
Kngan11a1 Lnga1 Ln11a1 0.516943
Kngan11a2 Lnga2 Ln11a2 0.516943
Kngan11a3 Lnga3 Ln11a3 0.516943
Kngan11a4 Lnga4 Ln11a4 0.516943
Kngan11a5 Lnga5 Ln11a5 0.516943
Kngan11a6 Lnga6 Ln11a6 0.516943
Kngan11a7 Lnga7 Ln11a7 0.516943
Kngan11a8 Lnga8 Ln11a8 0.516943
Kngan11a9 Lnga9 Ln11a9 0.516943
Kngan11a10 Lnga10 Ln11a10 0.516943
Kngan11a11 Lnga11 Ln11a11 0.516943
Kngan11a12 Lnga12 Ln11a12 0.516943
Kngan11a13 Lnga13 Ln11a13 0.516943
Kngan11a14 Lnga14 Ln11a14 0.516943
Kngan11a15 Lnga15 Ln11a15 0.516943
Kngan11a16 Lnga16 Ln11a16 0.516943
Kngan12a1 Lnga1 Ln12a1 0.505455
Kngan12a2 Lnga2 Ln12a2 0.505455
Kngan12a3 Lnga3 Ln12a3 0.505455
Kngan12a4 Lnga4 Ln12a4 0.505455
Kngan12a5 Lnga5 Ln12a5 0.505455
Kngan12a6 Lnga6 Ln12a6 0.505455
Kngan12a7 Lnga7 Ln12a7 0.505455
Kngan12a8 Lnga8 Ln12a8 0.505455
Kngan12a9 Lnga9 Ln12a9 0.505455
Kngan12a10 Lnga10 Ln12a10 0.505455
Kngan12a11 Lnga11 Ln12a11 0.505455
Kngan12a12 Lnga12 Ln12a12 0.505455
Kngan12a13 Lnga13 Ln12a13 0.505455
Kngan12a14 Lnga14 Ln12a14 0.505455
Kngan12a15 Lnga15 Ln12a15 0.505455
Kngan12a16 Lnga16 Ln12a16 0.505455
Kngan13a1 Lnga1 Ln13a1 0.494887
Kngan13a2 Lnga2 Ln13a2 0.494887
Kngan13a3 Lnga3 Ln13a3 0.494887
Kngan13a4 Lnga4 Ln13a4 0.494887
Kngan13a5 Lnga5 Ln13a5 0.494887
Kngan13a6 Lnga6 Ln13a6 0.494887
Kngan13a7 Lnga7 Ln13a7 0.494887
Kngan13a8 Lnga8 Ln13a8 0.494887
Kngan13a9 Lnga9 Ln13a9 0.494887
Kngan13a10 Lnga10 Ln13a10 0.494887
Kngan13a11 Lnga11 Ln13a11 0.494887
Kngan13a12 Lnga12 Ln13a12 0.494887
Kngan13a13 Lnga13 Ln13a13 0.494887
Kngan13a14 Lnga14 Ln13a14 0.494887
Kngan13a15 Lnga15 Ln13a15 0.494887
Kngan13a16 Lnga16 Ln13a16 0.494887
Kngan14a1 Lnga1 Ln14a1 0.485771
Kngan14a2 Lnga2 Ln14a2 0.485771
Kngan14a3 Lnga3 Ln14a3 0.485771
Kngan14a4 Lnga4 Ln14a4 0.485771
Kngan14a5 Lnga5 Ln14a5 0.485771
Kngan14a6 Lnga6 Ln14a6 0.485771
Kngan14a7 Lnga7 Ln14a7 0.485771
Kngan14a8 Lnga8 Ln14a8 0.485771
Kngan14a9 Lnga9 Ln14a9 0.485771
Kngan14a10 Lnga10 Ln14a10 0.485771
Kngan14a11 Lnga11 Ln14a11 0.485771
Kngan14a12 Lnga12 Ln14a12 0.485771
Kngan14a13 Lnga13 Ln14a13 0.485771
Kngan14a14 Lnga14 Ln14a14 0.485771
Kngan14a15 Lnga15 Ln14a15 0.485771
Kngan14a16 Lnga16 Ln14a16 0.485771
Kngan15a1 Lnga1 Ln15a1 0.477226
Kngan15a2 Lnga2 Ln15a2 0.477226
Kngan15a3 Lnga3 Ln15a3 0.477226
Kngan15a4 Lnga4 Ln15a4 0.477226
Kngan15a5 Lnga5 Ln15a5 0.477226
Kngan15a6 Lnga6 Ln15a6 0.477226
Kngan15a7 Lnga7 Ln15a7 0.477226
Kngan15a8 Lnga8 Ln15a8 0.477226
Kngan15a9 Lnga9 Ln15a9 0.477226
Kngan15a10 Lnga10 Ln15a10 0.477226
Kngan15a11 Lnga11 Ln15a11 0.477226
Kngan15a12 Lnga12 Ln15a12 0.477226
Kngan15a13 Lnga13 Ln15a13 0.477226
Kngan15a14 Lnga14 Ln15a14 0.477226
Kngan15a15 Lnga15 Ln15a15 0.477226
Kngan15a16 Lnga16 Ln15a16 0.477226
Kngan16a1 Lnga1 Ln16a1 0.469680
Kngan16a2 Lnga2 Ln16a2 0.469680
Kngan16a3 Lnga3 Ln16a3 0.469680
Kngan16a4 Lnga4 Ln16a4 0.469680
Kngan16a5 Lnga5 Ln16a5 0.469680
Kngan16a6 Lnga6 Ln16a6 0.469680
Kngan16a7 Lnga7 Ln16a7 0.469680
Kngan16a8 Lnga8 Ln16a8 0.469680
Kngan16a9 Lnga9 Ln16a9 0.469680
Kngan16a10 Lnga10 Ln16a10 0.469680
Kngan16a11 Lnga11 Ln16a11 0.469680
Kngan16a12 Lnga12 Ln16a12 0.469680
Kngan16a13 Lnga13 Ln16a13 0.469680
Kngan16a14 Lnga14 Ln16a14 0.469680
Kngan16a15 Lnga15 Ln16a15 0.469680
Kngan16a16 Lnga16 Ln16a16 0.469680
Kngan17a1 Lnga1 Ln17a1 0.463523
Kngan17a2 Lnga2 Ln17a2 0.463523
Kngan17a3 Lnga3 Ln17a3 0.463523
Kngan17a4 Lnga4 Ln17a4 0.463523
Kngan17a5 Lnga5 Ln17a5 0.463523
Kngan17a6 Lnga6 Ln17a6 0.463523
Kngan17a7 Lnga7 Ln17a7 0.463523
Kngan17a8 Lnga8 Ln17a8 0.463523
Kngan17a9 Lnga9 Ln17a9 0.463523
Kngan17a10 Lnga10 Ln17a10 0.463523
Kngan17a11 Lnga11 Ln17a11 0.463523
Kngan17a12 Lnga12 Ln17a12 0.463523
Kngan17a13 Lnga13 Ln17a13 0.463523
Kngan17a14 Lnga14 Ln17a14 0.463523
Kngan17a15 Lnga15 Ln17a15 0.463523
Kngan17a16 Lnga16 Ln17a16 0.463523
Kngan18a1 Lnga1 Ln18a1 0.458074
Kngan18a2 Lnga2 Ln18a2 0.458074
Kngan18a3 Lnga3 Ln18a3 0.458074
Kngan18a4 Lnga4 Ln18a4 0.458074
Kngan18a5 Lnga5 Ln18a5 0.458074
Kngan18a6 Lnga6 Ln18a6 0.458074
Kngan18a7 Lnga7 Ln18a7 0.458074
Kngan18a8 Lnga8 Ln18a8 0.458074
Kngan18a9 Lnga9 Ln18a9 0.458074
Kngan18a10 Lnga10 Ln18a10 0.458074
Kngan18a11 Lnga11 Ln18a11 0.458074
Kngan18a12 Lnga12 Ln18a12 0.458074
Kngan18a13 Lnga13 Ln18a13 0.458074
Kngan18a14 Lnga14 Ln18a14 0.458074
Kngan18a15 Lnga15 Ln18a15 0.458074
Kngan18a16 Lnga16 Ln18a16 0.458074
Kngan19a1 Lnga1 Ln19a1 0.453889
Kngan19a2 Lnga2 Ln19a2 0.453889
Kngan19a3 Lnga3 Ln19a3 0.453889
Kngan19a4 Lnga4 Ln19a4 0.453889
Kngan19a5 Lnga5 Ln19a5 0.453889
Kngan19a6 Lnga6 Ln19a6 0.453889
Kngan19a7 Lnga7 Ln19a7 0.453889
Kngan19a8 Lnga8 Ln19a8 0.453889
Kngan19a9 Lnga9 Ln19a9 0.453889
Kngan19a10 Lnga10 Ln19a10 0.453889
Kngan19a11 Lnga11 Ln19a11 0.453889
Kngan19a12 Lnga12 Ln19a12 0.453889
Kngan19a13 Lnga13 Ln19a13 0.453889
Kngan19a14 Lnga14 Ln19a14 0.453889
Kngan19a15 Lnga15 Ln19a15 0.453889
Kngan19a16 Lnga16 Ln19a16 0.453889
Kngan20a1 Lnga1 Ln20a1 0.450243
Kngan20a2 Lnga2 Ln20a2 0.450243
Kngan20a3 Lnga3 Ln20a3 0.450243
Kngan20a4 Lnga4 Ln20a4 0.450243
Kngan20a5 Lnga5 Ln20a5 0.450243
Kngan20a6 Lnga6 Ln20a6 0.450243
Kngan20a7 Lnga7 Ln20a7 0.450243
Kngan20a8 Lnga8 Ln20a8 0.450243
Kngan20a9 Lnga9 Ln20a9 0.450243
Kngan20a10 Lnga10 Ln20a10 0.450243
Kngan20a11 Lnga11 Ln20a11 0.450243
Kngan20a12 Lnga12 Ln20a12 0.450243
Kngan20a13 Lnga13 Ln20a13 0.450243
Kngan20a14 Lnga14 Ln20a14 0.450243
Kngan20a15 Lnga15 Ln20a15 0.450243
Kngan20a16 Lnga16 Ln20a16 0.450243
Kngan21a1 Lnga1 Ln21a1 0.447456
Kngan21a2 Lnga2 Ln21a2 0.447456
Kngan21a3 Lnga3 Ln21a3 0.447456
Kngan21a4 Lnga4 Ln21a4 0.447456
Kngan21a5 Lnga5 Ln21a5 0.447456
Kngan21a6 Lnga6 Ln21a6 0.447456
Kngan21a7 Lnga7 Ln21a7 0.447456
Kngan21a8 Lnga8 Ln21a8 0.447456
Kngan21a9 Lnga9 Ln21a9 0.447456
Kngan21a10 Lnga10 Ln21a10 0.447456
Kngan21a11 Lnga11 Ln21a11 0.447456
Kngan21a12 Lnga12 Ln21a12 0.447456
Kngan21a13 Lnga13 Ln21a13 0.447456
Kngan21a14 Lnga14 Ln21a14 0.447456
Kngan21a15 Lnga15 Ln21a15 0.447456
Kngan21a16 Lnga16 Ln21a16 0.447456
Kngan22a1 Lnga1 Ln22a1 0.445700
Kngan22a2 Lnga2 Ln22a2 0.445700
Kngan22a3 Lnga3 Ln22a3 0.445700
Kngan22a4 Lnga4 Ln22a4 0.445700
Kngan22a5 Lnga5 Ln22a5 0.445700
Kngan22a6 Lnga6 Ln22a6 0.445700
Kngan22a7 Lnga7 Ln22a7 0.445700
Kngan22a8 Lnga8 Ln22a8 0.445700
Kngan22a9 Lnga9 Ln22a9 0.445700
Kngan22a10 Lnga10 Ln22a10 0.445700
Kngan22a11 Lnga11 Ln22a11 0.445700
Kngan22a12 Lnga12 Ln22a12 0.445700
Kngan22a13 Lnga13 Ln22a13 0.445700
Kngan22a14 Lnga14 Ln22a14 0.445700
Kngan22a15 Lnga15 Ln22a15 0.445700
Kngan22a16 Lnga16 Ln22a16 0.445700
Kngan23a1 Lnga1 Ln23a1 0.444759
Kngan23a2 Lnga2 Ln23a2 0.444759
Kngan23a3 Lnga3 Ln23a3 0.444759
Kngan23a4 Lnga4 Ln23a4 0.444759
Kngan23a5 Lnga5 Ln23a5 0.444759
Kngan23a6 Lnga6 Ln23a6 0.444759
Kngan23a7 Lnga7 Ln23a7 0.444759
Kngan23a8 Lnga8 Ln23a8 0.444759
Kngan23a9 Lnga9 Ln23a9 0.444759
Kngan23a10 Lnga10 Ln23a10 0.444759
Kngan23a11 Lnga11 Ln23a11 0.444759
Kngan23a12 Lnga12 Ln23a12 0.444759
Kngan23a13 Lnga13 Ln23a13 0.444759
Kngan23a14 Lnga14 Ln23a14 0.444759
Kngan23a15 Lnga15 Ln23a15 0.444759
Kngan23a16 Lnga16 Ln23a16 0.444759
Kngan24a1 Lnga1 Ln24a1 0.443914
Kngan24a2 Lnga2 Ln24a2 0.443914
Kngan24a3 Lnga3 Ln24a3 0.443914
Kngan24a4 Lnga4 Ln24a4 0.443914
Kngan24a5 Lnga5 Ln24a5 0.443914
Kngan24a6 Lnga6 Ln24a6 0.443914
Kngan24a7 Lnga7 Ln24a7 0.443914
Kngan24a8 Lnga8 Ln24a8 0.443914
Kngan24a9 Lnga9 Ln24a9 0.443914
Kngan24a10 Lnga10 Ln24a10 0.443914
Kngan24a11 Lnga11 Ln24a11 0.443914
Kngan24a12 Lnga12 Ln24a12 0.443914
Kngan24a13 Lnga13 Ln24a13 0.443914
Kngan24a14 Lnga14 Ln24a14 0.443914
Kngan24a15 Lnga15 Ln24a15 0.443914
Kngan24a16 Lnga16 Ln24a16 0.443914
Kngan25a1 Lnga1 Ln25a1 0.443172
Kngan25a2 Lnga2 Ln25a2 0.443172
Kngan25a3 Lnga3 Ln25a3 0.443172
Kngan25a4 Lnga4 Ln25a4 0.443172
Kngan25a5 Lnga5 Ln25a5 0.443172
Kngan25a6 Lnga6 Ln25a6 0.443172
Kngan25a7 Lnga7 Ln25a7 0.443172
Kngan25a8 Lnga8 Ln25a8 0.443172
Kngan25a9 Lnga9 Ln25a9 0.443172
Kngan25a10 Lnga10 Ln25a10 0.443172
Kngan25a11 Lnga11 Ln25a11 0.443172
Kngan25a12 Lnga12 Ln25a12 0.443172
Kngan25a13 Lnga13 Ln25a13 0.443172
Kngan25a14 Lnga14 Ln25a14 0.443172
Kngan25a15 Lnga15 Ln25a15 0.443172
Kngan25a16 Lnga16 Ln25a16 0.443172
Kngan26a1 Lnga1 Ln26a1 0.442527
Kngan26a2 Lnga2 Ln26a2 0.442527
Kngan26a3 Lnga3 Ln26a3 0.442527
Kngan26a4 Lnga4 Ln26a4 0.442527
Kngan26a5 Lnga5 Ln26a5 0.442527
Kngan26a6 Lnga6 Ln26a6 0.442527
Kngan26a7 Lnga7 Ln26a7 0.442527
Kngan26a8 Lnga8 Ln26a8 0.442527
Kngan26a9 Lnga9 Ln26a9 0.442527
Kngan26a10 Lnga10 Ln26a10 0.442527
Kngan26a11 Lnga11 Ln26a11 0.442527
Kngan26a12 Lnga12 Ln26a12 0.442527
Kngan26a13 Lnga13 Ln26a13 0.442527
Kngan26a14 Lnga14 Ln26a14 0.442527
Kngan26a15 Lnga15 Ln26a15 0.442527
Kngan26a16 Lnga16 Ln26a16 0.442527
Kngan27a1 Lnga1 Ln27a1 0.442011
Kngan27a2 Lnga2 Ln27a2 0.442011
Kngan27a3 Lnga3 Ln27a3 0.442011
Kngan27a4 Lnga4 Ln27a4 0.442011
Kngan27a5 Lnga5 Ln27a5 0.442011
Kngan27a6 Lnga6 Ln27a6 0.442011
Kngan27a7 Lnga7 Ln27a7 0.442011
Kngan27a8 Lnga8 Ln27a8 0.442011
Kngan27a9 Lnga9 Ln27a9 0.442011
Kngan27a10 Lnga10 Ln27a10 0.442011
Kngan27a11 Lnga11 Ln27a11 0.442011
Kngan27a12 Lnga12 Ln27a12 0.442011
Kngan27a13 Lnga13 Ln27a13 0.442011
Kngan27a14 Lnga14 Ln27a14 0.442011
Kngan27a15 Lnga15 Ln27a15 0.442011
Kngan27a16 Lnga16 Ln27a16 0.442011
Kngan28a1 Lnga1 Ln28a1 0.441523
Kngan28a2 Lnga2 Ln28a2 0.441523
Kngan28a3 Lnga3 Ln28a3 0.441523
Kngan28a4 Lnga4 Ln28a4 0.441523
Kngan28a5 Lnga5 Ln28a5 0.441523
Kngan28a6 Lnga6 Ln28a6 0.441523
Kngan28a7 Lnga7 Ln28a7 0.441523
Kngan28a8 Lnga8 Ln28a8 0.441523
Kngan28a9 Lnga9 Ln28a9 0.441523
Kngan28a10 Lnga10 Ln28a10 0.441523
Kngan28a11 Lnga11 Ln28a11 0.441523
Kngan28a12 Lnga12 Ln28a12 0.441523
Kngan28a13 Lnga13 Ln28a13 0.441523
Kngan28a14 Lnga14 Ln28a14 0.441523
Kngan28a15 Lnga15 Ln28a15 0.441523
Kngan28a16 Lnga16 Ln28a16 0.441523
Kngan29a1 Lnga1 Ln29a1 0.441177
Kngan29a2 Lnga2 Ln29a2 0.441177
Kngan29a3 Lnga3 Ln29a3 0.441177
Kngan29a4 Lnga4 Ln29a4 0.441177
Kngan29a5 Lnga5 Ln29a5 0.441177
Kngan29a6 Lnga6 Ln29a6 0.441177
Kngan29a7 Lnga7 Ln29a7 0.441177
Kngan29a8 Lnga8 Ln29a8 0.441177
Kngan29a9 Lnga9 Ln29a9 0.441177
Kngan29a10 Lnga10 Ln29a10 0.441177
Kngan29a11 Lnga11 Ln29a11 0.441177
Kngan29a12 Lnga12 Ln29a12 0.441177
Kngan29a13 Lnga13 Ln29a13 0.441177
Kngan29a14 Lnga14 Ln29a14 0.441177
Kngan29a15 Lnga15 Ln29a15 0.441177
Kngan29a16 Lnga16 Ln29a16 0.441177
Kngan30a1 Lnga1 Ln30a1 0.440889
Kngan30a2 Lnga2 Ln30a2 0.440889
Kngan30a3 Lnga3 Ln30a3 0.440889
Kngan30a4 Lnga4 Ln30a4 0.440889
Kngan30a5 Lnga5 Ln30a5 0.440889
Kngan30a6 Lnga6 Ln30a6 0.440889
Kngan30a7 Lnga7 Ln30a7 0.440889
Kngan30a8 Lnga8 Ln30a8 0.440889
Kngan30a9 Lnga9 Ln30a9 0.440889
Kngan30a10 Lnga10 Ln30a10 0.440889
Kngan30a11 Lnga11 Ln30a11 0.440889
Kngan30a12 Lnga12 Ln30a12 0.440889
Kngan30a13 Lnga13 Ln30a13 0.440889
Kngan30a14 Lnga14 Ln30a14 0.440889
Kngan30a15 Lnga15 Ln30a15 0.440889
Kngan30a16 Lnga16 Ln30a16 0.440889
Kngan31a1 Lnga1 Ln31a1 0.440743
Kngan31a2 Lnga2 Ln31a2 0.440743
Kngan31a3 Lnga3 Ln31a3 0.440743
Kngan31a4 Lnga4 Ln31a4 0.440743
Kngan31a5 Lnga5 Ln31a5 0.440743
Kngan31a6 Lnga6 Ln31a6 0.440743
Kngan31a7 Lnga7 Ln31a7 0.440743
Kngan31a8 Lnga8 Ln31a8 0.440743
Kngan31a9 Lnga9 Ln31a9 0.440743
Kngan31a10 Lnga10 Ln31a10 0.440743
Kngan31a11 Lnga11 Ln31a11 0.440743
Kngan31a12 Lnga12 Ln31a12 0.440743
Kngan31a13 Lnga13 Ln31a13 0.440743
Kngan31a14 Lnga14 Ln31a14 0.440743
Kngan31a15 Lnga15 Ln31a15 0.440743
Kngan31a16 Lnga16 Ln31a16 0.440743
Kngan32a1 Lnga1 Ln32a1 0.440648
Kngan32a2 Lnga2 Ln32a2 0.440648
Kngan32a3 Lnga3 Ln32a3 0.440648
Kngan32a4 Lnga4 Ln32a4 0.440648
Kngan32a5 Lnga5 Ln32a5 0.440648
Kngan32a6 Lnga6 Ln32a6 0.440648
Kngan32a7 Lnga7 Ln32a7 0.440648
Kngan32a8 Lnga8 Ln32a8 0.440648
Kngan32a9 Lnga9 Ln32a9 0.440648
Kngan32a10 Lnga10 Ln32a10 0.440648
Kngan32a11 Lnga11 Ln32a11 0.440648
Kngan32a12 Lnga12 Ln32a12 0.440648
Kngan32a13 Lnga13 Ln32a13 0.440648
Kngan32a14 Lnga14 Ln32a14 0.440648
Kngan32a15 Lnga15 Ln32a15 0.440648
Kngan32a16 Lnga16 Ln32a16 0.440648
Knganva1 Lnga1 Lnva1 0.440563
Knganva2 Lnga2 Lnva2 0.440563
Knganva3 Lnga3 Lnva3 0.440563
Knganva4 Lnga4 Lnva4 0.440563
Knganva5 Lnga5 Lnva5 0.440563
Knganva6 Lnga6 Lnva6 0.440563
Knganva7 Lnga7 Lnva7 0.440563
Knganva8 Lnga8 Lnva8 0.440563
Knganva9 Lnga9 Lnva9 0.440563
Knganva10 Lnga10 Lnva10 0.440563
Knganva11 Lnga11 Lnva11 0.440563
Knganva12 Lnga12 Lnva12 0.440563
Knganva13 Lnga13 Lnva13 0.440563
Knganva14 Lnga14 Lnva14 0.440563
Knganva15 Lnga15 Lnva15 0.440563
Knganva16 Lnga16 Lnva16 0.440563
Kn1an2a1 Ln1a1 Ln2a1 0.805155
Kn1an2a2 Ln1a2 Ln2a2 0.805155
Kn1an2a3 Ln1a3 Ln2a3 0.805155
Kn1an2a4 Ln1a4 Ln2a4 0.805155
Kn1an2a5 Ln1a5 Ln2a5 0.805155
Kn1an2a6 Ln1a6 Ln2a6 0.805155
Kn1an2a7 Ln1a7 Ln2a7 0.805155
Kn1an2a8 Ln1a8 Ln2a8 0.805155
Kn1an2a9 Ln1a9 Ln2a9 0.805155
Kn1an2a10 Ln1a10 Ln2a10 0.805155
Kn1an2a11 Ln1a11 Ln2a11 0.805155
Kn1an2a12 Ln1a12 Ln2a12 0.805155
Kn1an2a13 Ln1a13 Ln2a13 0.805155
Kn1an2a14 Ln1a14 Ln2a14 0.805155
Kn1an2a15 Ln1a15 Ln2a15 0.805155
Kn1an2a16 Ln1a16 Ln2a16 0.805155
Kn1an3a1 Ln1a1 Ln3a1 0.723730
Kn1an3a2 Ln1a2 Ln3a2 0.723730
Kn1an3a3 Ln1a3 Ln3a3 0.723730
Kn1an3a4 Ln1a4 Ln3a4 0.723730
Kn1an3a5 Ln1a5 Ln3a5 0.723730
Kn1an3a6 Ln1a6 Ln3a6 0.723730
Kn1an3a7 Ln1a7 Ln3a7 0.723730
Kn1an3a8 Ln1a8 Ln3a8 0.723730
Kn1an3a9 Ln1a9 Ln3a9 0.723730
Kn1an3a10 Ln1a10 Ln3a10 0.723730
Kn1an3a11 Ln1a11 Ln3a11 0.723730
Kn1an3a12 Ln1a12 Ln3a12 0.723730
Kn1an3a13 Ln1a13 Ln3a13 0.723730
Kn1an3a14 Ln1a14 Ln3a14 0.723730
Kn1an3a15 Ln1a15 Ln3a15 0.723730
Kn1an3a16 Ln1a16 Ln3a16 0.723730
Kn1an4a1 Ln1a1 Ln4a1 0.675208
Kn1an4a2 Ln1a2 Ln4a2 0.675208
Kn1an4a3 Ln1a3 Ln4a3 0.675208
Kn1an4a4 Ln1a4 Ln4a4 0.675208
Kn1an4a5 Ln1a5 Ln4a5 0.675208
Kn1an4a6 Ln1a6 Ln4a6 0.675208
Kn1an4a7 Ln1a7 Ln4a7 0.675208
Kn1an4a8 Ln1a8 Ln4a8 0.675208
Kn1an4a9 Ln1a9 Ln4a9 0.675208
Kn1an4a10 Ln1a10 Ln4a10 0.675208
Kn1an4a11 Ln1a11 Ln4a11 0.675208
Kn1an4a12 Ln1a12 Ln4a12 0.675208
Kn1an4a13 Ln1a13 Ln4a13 0.675208
Kn1an4a14 Ln1a14 Ln4a14 0.675208
Kn1an4a15 Ln1a15 Ln4a15 0.675208
Kn1an4a16 Ln1a16 Ln4a16 0.675208
Kn1an5a1 Ln1a1 Ln5a1 0.640637
Kn1an5a2 Ln1a2 Ln5a2 0.640637
Kn1an5a3 Ln1a3 Ln5a3 0.640637
Kn1an5a4 Ln1a4 Ln5a4 0.640637
Kn1an5a5 Ln1a5 Ln5a5 0.640637
Kn1an5a6 Ln1a6 Ln5a6 0.640637
Kn1an5a7 Ln1a7 Ln5a7 0.640637
Kn1an5a8 Ln1a8 Ln5a8 0.640637
Kn1an5a9 Ln1a9 Ln5a9 0.640637
Kn1an5a10 Ln1a10 Ln5a10 0.640637
Kn1an5a11 Ln1a11 Ln5a11 0.640637
Kn1an5a12 Ln1a12 Ln5a12 0.640637
Kn1an5a13 Ln1a13 Ln5a13 0.640637
Kn1an5a14 Ln1a14 Ln5a14 0.640637
Kn1an5a15 Ln1a15 Ln5a15 0.640637
Kn1an5a16 Ln1a16 Ln5a16 0.640637
Kn1an6a1 Ln1a1 Ln6a1 0.613723
Kn1an6a2 Ln1a2 Ln6a2 0.613723
Kn1an6a3 Ln1a3 Ln6a3 0.613723
Kn1an6a4 Ln1a4 Ln6a4 0.613723
Kn1an6a5 Ln1a5 Ln6a5 0.613723
Kn1an6a6 Ln1a6 Ln6a6 0.613723
Kn1an6a7 Ln1a7 Ln6a7 0.613723
Kn1an6a8 Ln1a8 Ln6a8 0.613723
Kn1an6a9 Ln1a9 Ln6a9 0.613723
Kn1an6a10 Ln1a10 Ln6a10 0.613723
Kn1an6a11 Ln1a11 Ln6a11 0.613723
Kn1an6a12 Ln1a12 Ln6a12 0.613723
Kn1an6a13 Ln1a13 Ln6a13 0.613723
Kn1an6a14 Ln1a14 Ln6a14 0.613723
Kn1an6a15 Ln1a15 Ln6a15 0.613723
Kn1an6a16 Ln1a16 Ln6a16 0.613723
Kn1an7a1 Ln1a1 Ln7a1 0.591812
Kn1an7a2 Ln1a2 Ln7a2 0.591812
Kn1an7a3 Ln1a3 Ln7a3 0.591812
Kn1an7a4 Ln1a4 Ln7a4 0.591812
Kn1an7a5 Ln1a5 Ln7a5 0.591812
Kn1an7a6 Ln1a6 Ln7a6 0.591812
Kn1an7a7 Ln1a7 Ln7a7 0.591812
Kn1an7a8 Ln1a8 Ln7a8 0.591812
Kn1an7a9 Ln1a9 Ln7a9 0.591812
Kn1an7a10 Ln1a10 Ln7a10 0.591812
Kn1an7a11 Ln1a11 Ln7a11 0.591812
Kn1an7a12 Ln1a12 Ln7a12 0.591812
Kn1an7a13 Ln1a13 Ln7a13 0.591812
Kn1an7a14 Ln1a14 Ln7a14 0.591812
Kn1an7a15 Ln1a15 Ln7a15 0.591812
Kn1an7a16 Ln1a16 Ln7a16 0.591812
Kn1an8a1 Ln1a1 Ln8a1 0.573237
Kn1an8a2 Ln1a2 Ln8a2 0.573237
Kn1an8a3 Ln1a3 Ln8a3 0.573237
Kn1an8a4 Ln1a4 Ln8a4 0.573237
Kn1an8a5 Ln1a5 Ln8a5 0.573237
Kn1an8a6 Ln1a6 Ln8a6 0.573237
Kn1an8a7 Ln1a7 Ln8a7 0.573237
Kn1an8a8 Ln1a8 Ln8a8 0.573237
Kn1an8a9 Ln1a9 Ln8a9 0.573237
Kn1an8a10 Ln1a10 Ln8a10 0.573237
Kn1an8a11 Ln1a11 Ln8a11 0.573237
Kn1an8a12 Ln1a12 Ln8a12 0.573237
Kn1an8a13 Ln1a13 Ln8a13 0.573237
Kn1an8a14 Ln1a14 Ln8a14 0.573237
Kn1an8a15 Ln1a15 Ln8a15 0.573237
Kn1an8a16 Ln1a16 Ln8a16 0.573237
Kn1an9a1 Ln1a1 Ln9a1 0.557165
Kn1an9a2 Ln1a2 Ln9a2 0.557165
Kn1an9a3 Ln1a3 Ln9a3 0.557165
Kn1an9a4 Ln1a4 Ln9a4 0.557165
Kn1an9a5 Ln1a5 Ln9a5 0.557165
Kn1an9a6 Ln1a6 Ln9a6 0.557165
Kn1an9a7 Ln1a7 Ln9a7 0.557165
Kn1an9a8 Ln1a8 Ln9a8 0.557165
Kn1an9a9 Ln1a9 Ln9a9 0.557165
Kn1an9a10 Ln1a10 Ln9a10 0.557165
Kn1an9a11 Ln1a11 Ln9a11 0.557165
Kn1an9a12 Ln1a12 Ln9a12 0.557165
Kn1an9a13 Ln1a13 Ln9a13 0.557165
Kn1an9a14 Ln1a14 Ln9a14 0.557165
Kn1an9a15 Ln1a15 Ln9a15 0.557165
Kn1an9a16 Ln1a16 Ln9a16 0.557165
Kn1an10a1 Ln1a1 Ln10a1 0.542987
Kn1an10a2 Ln1a2 Ln10a2 0.542987
Kn1an10a3 Ln1a3 Ln10a3 0.542987
Kn1an10a4 Ln1a4 Ln10a4 0.542987
Kn1an10a5 Ln1a5 Ln10a5 0.542987
Kn1an10a6 Ln1a6 Ln10a6 0.542987
Kn1an10a7 Ln1a7 Ln10a7 0.542987
Kn1an10a8 Ln1a8 Ln10a8 0.542987
Kn1an10a9 Ln1a9 Ln10a9 0.542987
Kn1an10a10 Ln1a10 Ln10a10 0.542987
Kn1an10a11 Ln1a11 Ln10a11 0.542987
Kn1an10a12 Ln1a12 Ln10a12 0.542987
Kn1an10a13 Ln1a13 Ln10a13 0.542987
Kn1an10a14 Ln1a14 Ln10a14 0.542987
Kn1an10a15 Ln1a15 Ln10a15 0.542987
Kn1an10a16 Ln1a16 Ln10a16 0.542987
Kn1an11a1 Ln1a1 Ln11a1 0.529400
Kn1an11a2 Ln1a2 Ln11a2 0.529400
Kn1an11a3 Ln1a3 Ln11a3 0.529400
Kn1an11a4 Ln1a4 Ln11a4 0.529400
Kn1an11a5 Ln1a5 Ln11a5 0.529400
Kn1an11a6 Ln1a6 Ln11a6 0.529400
Kn1an11a7 Ln1a7 Ln11a7 0.529400
Kn1an11a8 Ln1a8 Ln11a8 0.529400
Kn1an11a9 Ln1a9 Ln11a9 0.529400
Kn1an11a10 Ln1a10 Ln11a10 0.529400
Kn1an11a11 Ln1a11 Ln11a11 0.529400
Kn1an11a12 Ln1a12 Ln11a12 0.529400
Kn1an11a13 Ln1a13 Ln11a13 0.529400
Kn1an11a14 Ln1a14 Ln11a14 0.529400
Kn1an11a15 Ln1a15 Ln11a15 0.529400
Kn1an11a16 Ln1a16 Ln11a16 0.529400
Kn1an12a1 Ln1a1 Ln12a1 0.516943
Kn1an12a2 Ln1a2 Ln12a2 0.516943
Kn1an12a3 Ln1a3 Ln12a3 0.516943
Kn1an12a4 Ln1a4 Ln12a4 0.516943
Kn1an12a5 Ln1a5 Ln12a5 0.516943
Kn1an12a6 Ln1a6 Ln12a6 0.516943
Kn1an12a7 Ln1a7 Ln12a7 0.516943
Kn1an12a8 Ln1a8 Ln12a8 0.516943
Kn1an12a9 Ln1a9 Ln12a9 0.516943
Kn1an12a10 Ln1a10 Ln12a10 0.516943
Kn1an12a11 Ln1a11 Ln12a11 0.516943
Kn1an12a12 Ln1a12 Ln12a12 0.516943
Kn1an12a13 Ln1a13 Ln12a13 0.516943
Kn1an12a14 Ln1a14 Ln12a14 0.516943
Kn1an12a15 Ln1a15 Ln12a15 0.516943
Kn1an12a16 Ln1a16 Ln12a16 0.516943
Kn1an13a1 Ln1a1 Ln13a1 0.505455
Kn1an13a2 Ln1a2 Ln13a2 0.505455
Kn1an13a3 Ln1a3 Ln13a3 0.505455
Kn1an13a4 Ln1a4 Ln13a4 0.505455
Kn1an13a5 Ln1a5 Ln13a5 0.505455
Kn1an13a6 Ln1a6 Ln13a6 0.505455
Kn1an13a7 Ln1a7 Ln13a7 0.505455
Kn1an13a8 Ln1a8 Ln13a8 0.505455
Kn1an13a9 Ln1a9 Ln13a9 0.505455
Kn1an13a10 Ln1a10 Ln13a10 0.505455
Kn1an13a11 Ln1a11 Ln13a11 0.505455
Kn1an13a12 Ln1a12 Ln13a12 0.505455
Kn1an13a13 Ln1a13 Ln13a13 0.505455
Kn1an13a14 Ln1a14 Ln13a14 0.505455
Kn1an13a15 Ln1a15 Ln13a15 0.505455
Kn1an13a16 Ln1a16 Ln13a16 0.505455
Kn1an14a1 Ln1a1 Ln14a1 0.494887
Kn1an14a2 Ln1a2 Ln14a2 0.494887
Kn1an14a3 Ln1a3 Ln14a3 0.494887
Kn1an14a4 Ln1a4 Ln14a4 0.494887
Kn1an14a5 Ln1a5 Ln14a5 0.494887
Kn1an14a6 Ln1a6 Ln14a6 0.494887
Kn1an14a7 Ln1a7 Ln14a7 0.494887
Kn1an14a8 Ln1a8 Ln14a8 0.494887
Kn1an14a9 Ln1a9 Ln14a9 0.494887
Kn1an14a10 Ln1a10 Ln14a10 0.494887
Kn1an14a11 Ln1a11 Ln14a11 0.494887
Kn1an14a12 Ln1a12 Ln14a12 0.494887
Kn1an14a13 Ln1a13 Ln14a13 0.494887
Kn1an14a14 Ln1a14 Ln14a14 0.494887
Kn1an14a15 Ln1a15 Ln14a15 0.494887
Kn1an14a16 Ln1a16 Ln14a16 0.494887
Kn1an15a1 Ln1a1 Ln15a1 0.485771
Kn1an15a2 Ln1a2 Ln15a2 0.485771
Kn1an15a3 Ln1a3 Ln15a3 0.485771
Kn1an15a4 Ln1a4 Ln15a4 0.485771
Kn1an15a5 Ln1a5 Ln15a5 0.485771
Kn1an15a6 Ln1a6 Ln15a6 0.485771
Kn1an15a7 Ln1a7 Ln15a7 0.485771
Kn1an15a8 Ln1a8 Ln15a8 0.485771
Kn1an15a9 Ln1a9 Ln15a9 0.485771
Kn1an15a10 Ln1a10 Ln15a10 0.485771
Kn1an15a11 Ln1a11 Ln15a11 0.485771
Kn1an15a12 Ln1a12 Ln15a12 0.485771
Kn1an15a13 Ln1a13 Ln15a13 0.485771
Kn1an15a14 Ln1a14 Ln15a14 0.485771
Kn1an15a15 Ln1a15 Ln15a15 0.485771
Kn1an15a16 Ln1a16 Ln15a16 0.485771
Kn1an16a1 Ln1a1 Ln16a1 0.477226
Kn1an16a2 Ln1a2 Ln16a2 0.477226
Kn1an16a3 Ln1a3 Ln16a3 0.477226
Kn1an16a4 Ln1a4 Ln16a4 0.477226
Kn1an16a5 Ln1a5 Ln16a5 0.477226
Kn1an16a6 Ln1a6 Ln16a6 0.477226
Kn1an16a7 Ln1a7 Ln16a7 0.477226
Kn1an16a8 Ln1a8 Ln16a8 0.477226
Kn1an16a9 Ln1a9 Ln16a9 0.477226
Kn1an16a10 Ln1a10 Ln16a10 0.477226
Kn1an16a11 Ln1a11 Ln16a11 0.477226
Kn1an16a12 Ln1a12 Ln16a12 0.477226
Kn1an16a13 Ln1a13 Ln16a13 0.477226
Kn1an16a14 Ln1a14 Ln16a14 0.477226
Kn1an16a15 Ln1a15 Ln16a15 0.477226
Kn1an16a16 Ln1a16 Ln16a16 0.477226
Kn1an17a1 Ln1a1 Ln17a1 0.469680
Kn1an17a2 Ln1a2 Ln17a2 0.469680
Kn1an17a3 Ln1a3 Ln17a3 0.469680
Kn1an17a4 Ln1a4 Ln17a4 0.469680
Kn1an17a5 Ln1a5 Ln17a5 0.469680
Kn1an17a6 Ln1a6 Ln17a6 0.469680
Kn1an17a7 Ln1a7 Ln17a7 0.469680
Kn1an17a8 Ln1a8 Ln17a8 0.469680
Kn1an17a9 Ln1a9 Ln17a9 0.469680
Kn1an17a10 Ln1a10 Ln17a10 0.469680
Kn1an17a11 Ln1a11 Ln17a11 0.469680
Kn1an17a12 Ln1a12 Ln17a12 0.469680
Kn1an17a13 Ln1a13 Ln17a13 0.469680
Kn1an17a14 Ln1a14 Ln17a14 0.469680
Kn1an17a15 Ln1a15 Ln17a15 0.469680
Kn1an17a16 Ln1a16 Ln17a16 0.469680
Kn1an18a1 Ln1a1 Ln18a1 0.463523
Kn1an18a2 Ln1a2 Ln18a2 0.463523
Kn1an18a3 Ln1a3 Ln18a3 0.463523
Kn1an18a4 Ln1a4 Ln18a4 0.463523
Kn1an18a5 Ln1a5 Ln18a5 0.463523
Kn1an18a6 Ln1a6 Ln18a6 0.463523
Kn1an18a7 Ln1a7 Ln18a7 0.463523
Kn1an18a8 Ln1a8 Ln18a8 0.463523
Kn1an18a9 Ln1a9 Ln18a9 0.463523
Kn1an18a10 Ln1a10 Ln18a10 0.463523
Kn1an18a11 Ln1a11 Ln18a11 0.463523
Kn1an18a12 Ln1a12 Ln18a12 0.463523
Kn1an18a13 Ln1a13 Ln18a13 0.463523
Kn1an18a14 Ln1a14 Ln18a14 0.463523
Kn1an18a15 Ln1a15 Ln18a15 0.463523
Kn1an18a16 Ln1a16 Ln18a16 0.463523
Kn1an19a1 Ln1a1 Ln19a1 0.458074
Kn1an19a2 Ln1a2 Ln19a2 0.458074
Kn1an19a3 Ln1a3 Ln19a3 0.458074
Kn1an19a4 Ln1a4 Ln19a4 0.458074
Kn1an19a5 Ln1a5 Ln19a5 0.458074
Kn1an19a6 Ln1a6 Ln19a6 0.458074
Kn1an19a7 Ln1a7 Ln19a7 0.458074
Kn1an19a8 Ln1a8 Ln19a8 0.458074
Kn1an19a9 Ln1a9 Ln19a9 0.458074
Kn1an19a10 Ln1a10 Ln19a10 0.458074
Kn1an19a11 Ln1a11 Ln19a11 0.458074
Kn1an19a12 Ln1a12 Ln19a12 0.458074
Kn1an19a13 Ln1a13 Ln19a13 0.458074
Kn1an19a14 Ln1a14 Ln19a14 0.458074
Kn1an19a15 Ln1a15 Ln19a15 0.458074
Kn1an19a16 Ln1a16 Ln19a16 0.458074
Kn1an20a1 Ln1a1 Ln20a1 0.453889
Kn1an20a2 Ln1a2 Ln20a2 0.453889
Kn1an20a3 Ln1a3 Ln20a3 0.453889
Kn1an20a4 Ln1a4 Ln20a4 0.453889
Kn1an20a5 Ln1a5 Ln20a5 0.453889
Kn1an20a6 Ln1a6 Ln20a6 0.453889
Kn1an20a7 Ln1a7 Ln20a7 0.453889
Kn1an20a8 Ln1a8 Ln20a8 0.453889
Kn1an20a9 Ln1a9 Ln20a9 0.453889
Kn1an20a10 Ln1a10 Ln20a10 0.453889
Kn1an20a11 Ln1a11 Ln20a11 0.453889
Kn1an20a12 Ln1a12 Ln20a12 0.453889
Kn1an20a13 Ln1a13 Ln20a13 0.453889
Kn1an20a14 Ln1a14 Ln20a14 0.453889
Kn1an20a15 Ln1a15 Ln20a15 0.453889
Kn1an20a16 Ln1a16 Ln20a16 0.453889
Kn1an21a1 Ln1a1 Ln21a1 0.450243
Kn1an21a2 Ln1a2 Ln21a2 0.450243
Kn1an21a3 Ln1a3 Ln21a3 0.450243
Kn1an21a4 Ln1a4 Ln21a4 0.450243
Kn1an21a5 Ln1a5 Ln21a5 0.450243
Kn1an21a6 Ln1a6 Ln21a6 0.450243
Kn1an21a7 Ln1a7 Ln21a7 0.450243
Kn1an21a8 Ln1a8 Ln21a8 0.450243
Kn1an21a9 Ln1a9 Ln21a9 0.450243
Kn1an21a10 Ln1a10 Ln21a10 0.450243
Kn1an21a11 Ln1a11 Ln21a11 0.450243
Kn1an21a12 Ln1a12 Ln21a12 0.450243
Kn1an21a13 Ln1a13 Ln21a13 0.450243
Kn1an21a14 Ln1a14 Ln21a14 0.450243
Kn1an21a15 Ln1a15 Ln21a15 0.450243
Kn1an21a16 Ln1a16 Ln21a16 0.450243
Kn1an22a1 Ln1a1 Ln22a1 0.447456
Kn1an22a2 Ln1a2 Ln22a2 0.447456
Kn1an22a3 Ln1a3 Ln22a3 0.447456
Kn1an22a4 Ln1a4 Ln22a4 0.447456
Kn1an22a5 Ln1a5 Ln22a5 0.447456
Kn1an22a6 Ln1a6 Ln22a6 0.447456
Kn1an22a7 Ln1a7 Ln22a7 0.447456
Kn1an22a8 Ln1a8 Ln22a8 0.447456
Kn1an22a9 Ln1a9 Ln22a9 0.447456
Kn1an22a10 Ln1a10 Ln22a10 0.447456
Kn1an22a11 Ln1a11 Ln22a11 0.447456
Kn1an22a12 Ln1a12 Ln22a12 0.447456
Kn1an22a13 Ln1a13 Ln22a13 0.447456
Kn1an22a14 Ln1a14 Ln22a14 0.447456
Kn1an22a15 Ln1a15 Ln22a15 0.447456
Kn1an22a16 Ln1a16 Ln22a16 0.447456
Kn1an23a1 Ln1a1 Ln23a1 0.445700
Kn1an23a2 Ln1a2 Ln23a2 0.445700
Kn1an23a3 Ln1a3 Ln23a3 0.445700
Kn1an23a4 Ln1a4 Ln23a4 0.445700
Kn1an23a5 Ln1a5 Ln23a5 0.445700
Kn1an23a6 Ln1a6 Ln23a6 0.445700
Kn1an23a7 Ln1a7 Ln23a7 0.445700
Kn1an23a8 Ln1a8 Ln23a8 0.445700
Kn1an23a9 Ln1a9 Ln23a9 0.445700
Kn1an23a10 Ln1a10 Ln23a10 0.445700
Kn1an23a11 Ln1a11 Ln23a11 0.445700
Kn1an23a12 Ln1a12 Ln23a12 0.445700
Kn1an23a13 Ln1a13 Ln23a13 0.445700
Kn1an23a14 Ln1a14 Ln23a14 0.445700
Kn1an23a15 Ln1a15 Ln23a15 0.445700
Kn1an23a16 Ln1a16 Ln23a16 0.445700
Kn1an24a1 Ln1a1 Ln24a1 0.444759
Kn1an24a2 Ln1a2 Ln24a2 0.444759
Kn1an24a3 Ln1a3 Ln24a3 0.444759
Kn1an24a4 Ln1a4 Ln24a4 0.444759
Kn1an24a5 Ln1a5 Ln24a5 0.444759
Kn1an24a6 Ln1a6 Ln24a6 0.444759
Kn1an24a7 Ln1a7 Ln24a7 0.444759
Kn1an24a8 Ln1a8 Ln24a8 0.444759
Kn1an24a9 Ln1a9 Ln24a9 0.444759
Kn1an24a10 Ln1a10 Ln24a10 0.444759
Kn1an24a11 Ln1a11 Ln24a11 0.444759
Kn1an24a12 Ln1a12 Ln24a12 0.444759
Kn1an24a13 Ln1a13 Ln24a13 0.444759
Kn1an24a14 Ln1a14 Ln24a14 0.444759
Kn1an24a15 Ln1a15 Ln24a15 0.444759
Kn1an24a16 Ln1a16 Ln24a16 0.444759
Kn1an25a1 Ln1a1 Ln25a1 0.443914
Kn1an25a2 Ln1a2 Ln25a2 0.443914
Kn1an25a3 Ln1a3 Ln25a3 0.443914
Kn1an25a4 Ln1a4 Ln25a4 0.443914
Kn1an25a5 Ln1a5 Ln25a5 0.443914
Kn1an25a6 Ln1a6 Ln25a6 0.443914
Kn1an25a7 Ln1a7 Ln25a7 0.443914
Kn1an25a8 Ln1a8 Ln25a8 0.443914
Kn1an25a9 Ln1a9 Ln25a9 0.443914
Kn1an25a10 Ln1a10 Ln25a10 0.443914
Kn1an25a11 Ln1a11 Ln25a11 0.443914
Kn1an25a12 Ln1a12 Ln25a12 0.443914
Kn1an25a13 Ln1a13 Ln25a13 0.443914
Kn1an25a14 Ln1a14 Ln25a14 0.443914
Kn1an25a15 Ln1a15 Ln25a15 0.443914
Kn1an25a16 Ln1a16 Ln25a16 0.443914
Kn1an26a1 Ln1a1 Ln26a1 0.443172
Kn1an26a2 Ln1a2 Ln26a2 0.443172
Kn1an26a3 Ln1a3 Ln26a3 0.443172
Kn1an26a4 Ln1a4 Ln26a4 0.443172
Kn1an26a5 Ln1a5 Ln26a5 0.443172
Kn1an26a6 Ln1a6 Ln26a6 0.443172
Kn1an26a7 Ln1a7 Ln26a7 0.443172
Kn1an26a8 Ln1a8 Ln26a8 0.443172
Kn1an26a9 Ln1a9 Ln26a9 0.443172
Kn1an26a10 Ln1a10 Ln26a10 0.443172
Kn1an26a11 Ln1a11 Ln26a11 0.443172
Kn1an26a12 Ln1a12 Ln26a12 0.443172
Kn1an26a13 Ln1a13 Ln26a13 0.443172
Kn1an26a14 Ln1a14 Ln26a14 0.443172
Kn1an26a15 Ln1a15 Ln26a15 0.443172
Kn1an26a16 Ln1a16 Ln26a16 0.443172
Kn1an27a1 Ln1a1 Ln27a1 0.442527
Kn1an27a2 Ln1a2 Ln27a2 0.442527
Kn1an27a3 Ln1a3 Ln27a3 0.442527
Kn1an27a4 Ln1a4 Ln27a4 0.442527
Kn1an27a5 Ln1a5 Ln27a5 0.442527
Kn1an27a6 Ln1a6 Ln27a6 0.442527
Kn1an27a7 Ln1a7 Ln27a7 0.442527
Kn1an27a8 Ln1a8 Ln27a8 0.442527
Kn1an27a9 Ln1a9 Ln27a9 0.442527
Kn1an27a10 Ln1a10 Ln27a10 0.442527
Kn1an27a11 Ln1a11 Ln27a11 0.442527
Kn1an27a12 Ln1a12 Ln27a12 0.442527
Kn1an27a13 Ln1a13 Ln27a13 0.442527
Kn1an27a14 Ln1a14 Ln27a14 0.442527
Kn1an27a15 Ln1a15 Ln27a15 0.442527
Kn1an27a16 Ln1a16 Ln27a16 0.442527
Kn1an28a1 Ln1a1 Ln28a1 0.442011
Kn1an28a2 Ln1a2 Ln28a2 0.442011
Kn1an28a3 Ln1a3 Ln28a3 0.442011
Kn1an28a4 Ln1a4 Ln28a4 0.442011
Kn1an28a5 Ln1a5 Ln28a5 0.442011
Kn1an28a6 Ln1a6 Ln28a6 0.442011
Kn1an28a7 Ln1a7 Ln28a7 0.442011
Kn1an28a8 Ln1a8 Ln28a8 0.442011
Kn1an28a9 Ln1a9 Ln28a9 0.442011
Kn1an28a10 Ln1a10 Ln28a10 0.442011
Kn1an28a11 Ln1a11 Ln28a11 0.442011
Kn1an28a12 Ln1a12 Ln28a12 0.442011
Kn1an28a13 Ln1a13 Ln28a13 0.442011
Kn1an28a14 Ln1a14 Ln28a14 0.442011
Kn1an28a15 Ln1a15 Ln28a15 0.442011
Kn1an28a16 Ln1a16 Ln28a16 0.442011
Kn1an29a1 Ln1a1 Ln29a1 0.441523
Kn1an29a2 Ln1a2 Ln29a2 0.441523
Kn1an29a3 Ln1a3 Ln29a3 0.441523
Kn1an29a4 Ln1a4 Ln29a4 0.441523
Kn1an29a5 Ln1a5 Ln29a5 0.441523
Kn1an29a6 Ln1a6 Ln29a6 0.441523
Kn1an29a7 Ln1a7 Ln29a7 0.441523
Kn1an29a8 Ln1a8 Ln29a8 0.441523
Kn1an29a9 Ln1a9 Ln29a9 0.441523
Kn1an29a10 Ln1a10 Ln29a10 0.441523
Kn1an29a11 Ln1a11 Ln29a11 0.441523
Kn1an29a12 Ln1a12 Ln29a12 0.441523
Kn1an29a13 Ln1a13 Ln29a13 0.441523
Kn1an29a14 Ln1a14 Ln29a14 0.441523
Kn1an29a15 Ln1a15 Ln29a15 0.441523
Kn1an29a16 Ln1a16 Ln29a16 0.441523
Kn1an30a1 Ln1a1 Ln30a1 0.441177
Kn1an30a2 Ln1a2 Ln30a2 0.441177
Kn1an30a3 Ln1a3 Ln30a3 0.441177
Kn1an30a4 Ln1a4 Ln30a4 0.441177
Kn1an30a5 Ln1a5 Ln30a5 0.441177
Kn1an30a6 Ln1a6 Ln30a6 0.441177
Kn1an30a7 Ln1a7 Ln30a7 0.441177
Kn1an30a8 Ln1a8 Ln30a8 0.441177
Kn1an30a9 Ln1a9 Ln30a9 0.441177
Kn1an30a10 Ln1a10 Ln30a10 0.441177
Kn1an30a11 Ln1a11 Ln30a11 0.441177
Kn1an30a12 Ln1a12 Ln30a12 0.441177
Kn1an30a13 Ln1a13 Ln30a13 0.441177
Kn1an30a14 Ln1a14 Ln30a14 0.441177
Kn1an30a15 Ln1a15 Ln30a15 0.441177
Kn1an30a16 Ln1a16 Ln30a16 0.441177
Kn1an31a1 Ln1a1 Ln31a1 0.440889
Kn1an31a2 Ln1a2 Ln31a2 0.440889
Kn1an31a3 Ln1a3 Ln31a3 0.440889
Kn1an31a4 Ln1a4 Ln31a4 0.440889
Kn1an31a5 Ln1a5 Ln31a5 0.440889
Kn1an31a6 Ln1a6 Ln31a6 0.440889
Kn1an31a7 Ln1a7 Ln31a7 0.440889
Kn1an31a8 Ln1a8 Ln31a8 0.440889
Kn1an31a9 Ln1a9 Ln31a9 0.440889
Kn1an31a10 Ln1a10 Ln31a10 0.440889
Kn1an31a11 Ln1a11 Ln31a11 0.440889
Kn1an31a12 Ln1a12 Ln31a12 0.440889
Kn1an31a13 Ln1a13 Ln31a13 0.440889
Kn1an31a14 Ln1a14 Ln31a14 0.440889
Kn1an31a15 Ln1a15 Ln31a15 0.440889
Kn1an31a16 Ln1a16 Ln31a16 0.440889
Kn1an32a1 Ln1a1 Ln32a1 0.440743
Kn1an32a2 Ln1a2 Ln32a2 0.440743
Kn1an32a3 Ln1a3 Ln32a3 0.440743
Kn1an32a4 Ln1a4 Ln32a4 0.440743
Kn1an32a5 Ln1a5 Ln32a5 0.440743
Kn1an32a6 Ln1a6 Ln32a6 0.440743
Kn1an32a7 Ln1a7 Ln32a7 0.440743
Kn1an32a8 Ln1a8 Ln32a8 0.440743
Kn1an32a9 Ln1a9 Ln32a9 0.440743
Kn1an32a10 Ln1a10 Ln32a10 0.440743
Kn1an32a11 Ln1a11 Ln32a11 0.440743
Kn1an32a12 Ln1a12 Ln32a12 0.440743
Kn1an32a13 Ln1a13 Ln32a13 0.440743
Kn1an32a14 Ln1a14 Ln32a14 0.440743
Kn1an32a15 Ln1a15 Ln32a15 0.440743
Kn1an32a16 Ln1a16 Ln32a16 0.440743
Kn1anva1 Ln1a1 Lnva1 0.440648
Kn1anva2 Ln1a2 Lnva2 0.440648
Kn1anva3 Ln1a3 Lnva3 0.440648
Kn1anva4 Ln1a4 Lnva4 0.440648
Kn1anva5 Ln1a5 Lnva5 0.440648
Kn1anva6 Ln1a6 Lnva6 0.440648
Kn1anva7 Ln1a7 Lnva7 0.440648
Kn1anva8 Ln1a8 Lnva8 0.440648
Kn1anva9 Ln1a9 Lnva9 0.440648
Kn1anva10 Ln1a10 Lnva10 0.440648
Kn1anva11 Ln1a11 Lnva11 0.440648
Kn1anva12 Ln1a12 Lnva12 0.440648
Kn1anva13 Ln1a13 Lnva13 0.440648
Kn1anva14 Ln1a14 Lnva14 0.440648
Kn1anva15 Ln1a15 Lnva15 0.440648
Kn1anva16 Ln1a16 Lnva16 0.440648
Kn2an3a1 Ln2a1 Ln3a1 0.805155
Kn2an3a2 Ln2a2 Ln3a2 0.805155
Kn2an3a3 Ln2a3 Ln3a3 0.805155
Kn2an3a4 Ln2a4 Ln3a4 0.805155
Kn2an3a5 Ln2a5 Ln3a5 0.805155
Kn2an3a6 Ln2a6 Ln3a6 0.805155
Kn2an3a7 Ln2a7 Ln3a7 0.805155
Kn2an3a8 Ln2a8 Ln3a8 0.805155
Kn2an3a9 Ln2a9 Ln3a9 0.805155
Kn2an3a10 Ln2a10 Ln3a10 0.805155
Kn2an3a11 Ln2a11 Ln3a11 0.805155
Kn2an3a12 Ln2a12 Ln3a12 0.805155
Kn2an3a13 Ln2a13 Ln3a13 0.805155
Kn2an3a14 Ln2a14 Ln3a14 0.805155
Kn2an3a15 Ln2a15 Ln3a15 0.805155
Kn2an3a16 Ln2a16 Ln3a16 0.805155
Kn2an4a1 Ln2a1 Ln4a1 0.723730
Kn2an4a2 Ln2a2 Ln4a2 0.723730
Kn2an4a3 Ln2a3 Ln4a3 0.723730
Kn2an4a4 Ln2a4 Ln4a4 0.723730
Kn2an4a5 Ln2a5 Ln4a5 0.723730
Kn2an4a6 Ln2a6 Ln4a6 0.723730
Kn2an4a7 Ln2a7 Ln4a7 0.723730
Kn2an4a8 Ln2a8 Ln4a8 0.723730
Kn2an4a9 Ln2a9 Ln4a9 0.723730
Kn2an4a10 Ln2a10 Ln4a10 0.723730
Kn2an4a11 Ln2a11 Ln4a11 0.723730
Kn2an4a12 Ln2a12 Ln4a12 0.723730
Kn2an4a13 Ln2a13 Ln4a13 0.723730
Kn2an4a14 Ln2a14 Ln4a14 0.723730
Kn2an4a15 Ln2a15 Ln4a15 0.723730
Kn2an4a16 Ln2a16 Ln4a16 0.723730
Kn2an5a1 Ln2a1 Ln5a1 0.675208
Kn2an5a2 Ln2a2 Ln5a2 0.675208
Kn2an5a3 Ln2a3 Ln5a3 0.675208
Kn2an5a4 Ln2a4 Ln5a4 0.675208
Kn2an5a5 Ln2a5 Ln5a5 0.675208
Kn2an5a6 Ln2a6 Ln5a6 0.675208
Kn2an5a7 Ln2a7 Ln5a7 0.675208
Kn2an5a8 Ln2a8 Ln5a8 0.675208
Kn2an5a9 Ln2a9 Ln5a9 0.675208
Kn2an5a10 Ln2a10 Ln5a10 0.675208
Kn2an5a11 Ln2a11 Ln5a11 0.675208
Kn2an5a12 Ln2a12 Ln5a12 0.675208
Kn2an5a13 Ln2a13 Ln5a13 0.675208
Kn2an5a14 Ln2a14 Ln5a14 0.675208
Kn2an5a15 Ln2a15 Ln5a15 0.675208
Kn2an5a16 Ln2a16 Ln5a16 0.675208
Kn2an6a1 Ln2a1 Ln6a1 0.640637
Kn2an6a2 Ln2a2 Ln6a2 0.640637
Kn2an6a3 Ln2a3 Ln6a3 0.640637
Kn2an6a4 Ln2a4 Ln6a4 0.640637
Kn2an6a5 Ln2a5 Ln6a5 0.640637
Kn2an6a6 Ln2a6 Ln6a6 0.640637
Kn2an6a7 Ln2a7 Ln6a7 0.640637
Kn2an6a8 Ln2a8 Ln6a8 0.640637
Kn2an6a9 Ln2a9 Ln6a9 0.640637
Kn2an6a10 Ln2a10 Ln6a10 0.640637
Kn2an6a11 Ln2a11 Ln6a11 0.640637
Kn2an6a12 Ln2a12 Ln6a12 0.640637
Kn2an6a13 Ln2a13 Ln6a13 0.640637
Kn2an6a14 Ln2a14 Ln6a14 0.640637
Kn2an6a15 Ln2a15 Ln6a15 0.640637
Kn2an6a16 Ln2a16 Ln6a16 0.640637
Kn2an7a1 Ln2a1 Ln7a1 0.613723
Kn2an7a2 Ln2a2 Ln7a2 0.613723
Kn2an7a3 Ln2a3 Ln7a3 0.613723
Kn2an7a4 Ln2a4 Ln7a4 0.613723
Kn2an7a5 Ln2a5 Ln7a5 0.613723
Kn2an7a6 Ln2a6 Ln7a6 0.613723
Kn2an7a7 Ln2a7 Ln7a7 0.613723
Kn2an7a8 Ln2a8 Ln7a8 0.613723
Kn2an7a9 Ln2a9 Ln7a9 0.613723
Kn2an7a10 Ln2a10 Ln7a10 0.613723
Kn2an7a11 Ln2a11 Ln7a11 0.613723
Kn2an7a12 Ln2a12 Ln7a12 0.613723
Kn2an7a13 Ln2a13 Ln7a13 0.613723
Kn2an7a14 Ln2a14 Ln7a14 0.613723
Kn2an7a15 Ln2a15 Ln7a15 0.613723
Kn2an7a16 Ln2a16 Ln7a16 0.613723
Kn2an8a1 Ln2a1 Ln8a1 0.591812
Kn2an8a2 Ln2a2 Ln8a2 0.591812
Kn2an8a3 Ln2a3 Ln8a3 0.591812
Kn2an8a4 Ln2a4 Ln8a4 0.591812
Kn2an8a5 Ln2a5 Ln8a5 0.591812
Kn2an8a6 Ln2a6 Ln8a6 0.591812
Kn2an8a7 Ln2a7 Ln8a7 0.591812
Kn2an8a8 Ln2a8 Ln8a8 0.591812
Kn2an8a9 Ln2a9 Ln8a9 0.591812
Kn2an8a10 Ln2a10 Ln8a10 0.591812
Kn2an8a11 Ln2a11 Ln8a11 0.591812
Kn2an8a12 Ln2a12 Ln8a12 0.591812
Kn2an8a13 Ln2a13 Ln8a13 0.591812
Kn2an8a14 Ln2a14 Ln8a14 0.591812
Kn2an8a15 Ln2a15 Ln8a15 0.591812
Kn2an8a16 Ln2a16 Ln8a16 0.591812
Kn2an9a1 Ln2a1 Ln9a1 0.573237
Kn2an9a2 Ln2a2 Ln9a2 0.573237
Kn2an9a3 Ln2a3 Ln9a3 0.573237
Kn2an9a4 Ln2a4 Ln9a4 0.573237
Kn2an9a5 Ln2a5 Ln9a5 0.573237
Kn2an9a6 Ln2a6 Ln9a6 0.573237
Kn2an9a7 Ln2a7 Ln9a7 0.573237
Kn2an9a8 Ln2a8 Ln9a8 0.573237
Kn2an9a9 Ln2a9 Ln9a9 0.573237
Kn2an9a10 Ln2a10 Ln9a10 0.573237
Kn2an9a11 Ln2a11 Ln9a11 0.573237
Kn2an9a12 Ln2a12 Ln9a12 0.573237
Kn2an9a13 Ln2a13 Ln9a13 0.573237
Kn2an9a14 Ln2a14 Ln9a14 0.573237
Kn2an9a15 Ln2a15 Ln9a15 0.573237
Kn2an9a16 Ln2a16 Ln9a16 0.573237
Kn2an10a1 Ln2a1 Ln10a1 0.557165
Kn2an10a2 Ln2a2 Ln10a2 0.557165
Kn2an10a3 Ln2a3 Ln10a3 0.557165
Kn2an10a4 Ln2a4 Ln10a4 0.557165
Kn2an10a5 Ln2a5 Ln10a5 0.557165
Kn2an10a6 Ln2a6 Ln10a6 0.557165
Kn2an10a7 Ln2a7 Ln10a7 0.557165
Kn2an10a8 Ln2a8 Ln10a8 0.557165
Kn2an10a9 Ln2a9 Ln10a9 0.557165
Kn2an10a10 Ln2a10 Ln10a10 0.557165
Kn2an10a11 Ln2a11 Ln10a11 0.557165
Kn2an10a12 Ln2a12 Ln10a12 0.557165
Kn2an10a13 Ln2a13 Ln10a13 0.557165
Kn2an10a14 Ln2a14 Ln10a14 0.557165
Kn2an10a15 Ln2a15 Ln10a15 0.557165
Kn2an10a16 Ln2a16 Ln10a16 0.557165
Kn2an11a1 Ln2a1 Ln11a1 0.542987
Kn2an11a2 Ln2a2 Ln11a2 0.542987
Kn2an11a3 Ln2a3 Ln11a3 0.542987
Kn2an11a4 Ln2a4 Ln11a4 0.542987
Kn2an11a5 Ln2a5 Ln11a5 0.542987
Kn2an11a6 Ln2a6 Ln11a6 0.542987
Kn2an11a7 Ln2a7 Ln11a7 0.542987
Kn2an11a8 Ln2a8 Ln11a8 0.542987
Kn2an11a9 Ln2a9 Ln11a9 0.542987
Kn2an11a10 Ln2a10 Ln11a10 0.542987
Kn2an11a11 Ln2a11 Ln11a11 0.542987
Kn2an11a12 Ln2a12 Ln11a12 0.542987
Kn2an11a13 Ln2a13 Ln11a13 0.542987
Kn2an11a14 Ln2a14 Ln11a14 0.542987
Kn2an11a15 Ln2a15 Ln11a15 0.542987
Kn2an11a16 Ln2a16 Ln11a16 0.542987
Kn2an12a1 Ln2a1 Ln12a1 0.529400
Kn2an12a2 Ln2a2 Ln12a2 0.529400
Kn2an12a3 Ln2a3 Ln12a3 0.529400
Kn2an12a4 Ln2a4 Ln12a4 0.529400
Kn2an12a5 Ln2a5 Ln12a5 0.529400
Kn2an12a6 Ln2a6 Ln12a6 0.529400
Kn2an12a7 Ln2a7 Ln12a7 0.529400
Kn2an12a8 Ln2a8 Ln12a8 0.529400
Kn2an12a9 Ln2a9 Ln12a9 0.529400
Kn2an12a10 Ln2a10 Ln12a10 0.529400
Kn2an12a11 Ln2a11 Ln12a11 0.529400
Kn2an12a12 Ln2a12 Ln12a12 0.529400
Kn2an12a13 Ln2a13 Ln12a13 0.529400
Kn2an12a14 Ln2a14 Ln12a14 0.529400
Kn2an12a15 Ln2a15 Ln12a15 0.529400
Kn2an12a16 Ln2a16 Ln12a16 0.529400
Kn2an13a1 Ln2a1 Ln13a1 0.516943
Kn2an13a2 Ln2a2 Ln13a2 0.516943
Kn2an13a3 Ln2a3 Ln13a3 0.516943
Kn2an13a4 Ln2a4 Ln13a4 0.516943
Kn2an13a5 Ln2a5 Ln13a5 0.516943
Kn2an13a6 Ln2a6 Ln13a6 0.516943
Kn2an13a7 Ln2a7 Ln13a7 0.516943
Kn2an13a8 Ln2a8 Ln13a8 0.516943
Kn2an13a9 Ln2a9 Ln13a9 0.516943
Kn2an13a10 Ln2a10 Ln13a10 0.516943
Kn2an13a11 Ln2a11 Ln13a11 0.516943
Kn2an13a12 Ln2a12 Ln13a12 0.516943
Kn2an13a13 Ln2a13 Ln13a13 0.516943
Kn2an13a14 Ln2a14 Ln13a14 0.516943
Kn2an13a15 Ln2a15 Ln13a15 0.516943
Kn2an13a16 Ln2a16 Ln13a16 0.516943
Kn2an14a1 Ln2a1 Ln14a1 0.505455
Kn2an14a2 Ln2a2 Ln14a2 0.505455
Kn2an14a3 Ln2a3 Ln14a3 0.505455
Kn2an14a4 Ln2a4 Ln14a4 0.505455
Kn2an14a5 Ln2a5 Ln14a5 0.505455
Kn2an14a6 Ln2a6 Ln14a6 0.505455
Kn2an14a7 Ln2a7 Ln14a7 0.505455
Kn2an14a8 Ln2a8 Ln14a8 0.505455
Kn2an14a9 Ln2a9 Ln14a9 0.505455
Kn2an14a10 Ln2a10 Ln14a10 0.505455
Kn2an14a11 Ln2a11 Ln14a11 0.505455
Kn2an14a12 Ln2a12 Ln14a12 0.505455
Kn2an14a13 Ln2a13 Ln14a13 0.505455
Kn2an14a14 Ln2a14 Ln14a14 0.505455
Kn2an14a15 Ln2a15 Ln14a15 0.505455
Kn2an14a16 Ln2a16 Ln14a16 0.505455
Kn2an15a1 Ln2a1 Ln15a1 0.494887
Kn2an15a2 Ln2a2 Ln15a2 0.494887
Kn2an15a3 Ln2a3 Ln15a3 0.494887
Kn2an15a4 Ln2a4 Ln15a4 0.494887
Kn2an15a5 Ln2a5 Ln15a5 0.494887
Kn2an15a6 Ln2a6 Ln15a6 0.494887
Kn2an15a7 Ln2a7 Ln15a7 0.494887
Kn2an15a8 Ln2a8 Ln15a8 0.494887
Kn2an15a9 Ln2a9 Ln15a9 0.494887
Kn2an15a10 Ln2a10 Ln15a10 0.494887
Kn2an15a11 Ln2a11 Ln15a11 0.494887
Kn2an15a12 Ln2a12 Ln15a12 0.494887
Kn2an15a13 Ln2a13 Ln15a13 0.494887
Kn2an15a14 Ln2a14 Ln15a14 0.494887
Kn2an15a15 Ln2a15 Ln15a15 0.494887
Kn2an15a16 Ln2a16 Ln15a16 0.494887
Kn2an16a1 Ln2a1 Ln16a1 0.485771
Kn2an16a2 Ln2a2 Ln16a2 0.485771
Kn2an16a3 Ln2a3 Ln16a3 0.485771
Kn2an16a4 Ln2a4 Ln16a4 0.485771
Kn2an16a5 Ln2a5 Ln16a5 0.485771
Kn2an16a6 Ln2a6 Ln16a6 0.485771
Kn2an16a7 Ln2a7 Ln16a7 0.485771
Kn2an16a8 Ln2a8 Ln16a8 0.485771
Kn2an16a9 Ln2a9 Ln16a9 0.485771
Kn2an16a10 Ln2a10 Ln16a10 0.485771
Kn2an16a11 Ln2a11 Ln16a11 0.485771
Kn2an16a12 Ln2a12 Ln16a12 0.485771
Kn2an16a13 Ln2a13 Ln16a13 0.485771
Kn2an16a14 Ln2a14 Ln16a14 0.485771
Kn2an16a15 Ln2a15 Ln16a15 0.485771
Kn2an16a16 Ln2a16 Ln16a16 0.485771
Kn2an17a1 Ln2a1 Ln17a1 0.477226
Kn2an17a2 Ln2a2 Ln17a2 0.477226
Kn2an17a3 Ln2a3 Ln17a3 0.477226
Kn2an17a4 Ln2a4 Ln17a4 0.477226
Kn2an17a5 Ln2a5 Ln17a5 0.477226
Kn2an17a6 Ln2a6 Ln17a6 0.477226
Kn2an17a7 Ln2a7 Ln17a7 0.477226
Kn2an17a8 Ln2a8 Ln17a8 0.477226
Kn2an17a9 Ln2a9 Ln17a9 0.477226
Kn2an17a10 Ln2a10 Ln17a10 0.477226
Kn2an17a11 Ln2a11 Ln17a11 0.477226
Kn2an17a12 Ln2a12 Ln17a12 0.477226
Kn2an17a13 Ln2a13 Ln17a13 0.477226
Kn2an17a14 Ln2a14 Ln17a14 0.477226
Kn2an17a15 Ln2a15 Ln17a15 0.477226
Kn2an17a16 Ln2a16 Ln17a16 0.477226
Kn2an18a1 Ln2a1 Ln18a1 0.469680
Kn2an18a2 Ln2a2 Ln18a2 0.469680
Kn2an18a3 Ln2a3 Ln18a3 0.469680
Kn2an18a4 Ln2a4 Ln18a4 0.469680
Kn2an18a5 Ln2a5 Ln18a5 0.469680
Kn2an18a6 Ln2a6 Ln18a6 0.469680
Kn2an18a7 Ln2a7 Ln18a7 0.469680
Kn2an18a8 Ln2a8 Ln18a8 0.469680
Kn2an18a9 Ln2a9 Ln18a9 0.469680
Kn2an18a10 Ln2a10 Ln18a10 0.469680
Kn2an18a11 Ln2a11 Ln18a11 0.469680
Kn2an18a12 Ln2a12 Ln18a12 0.469680
Kn2an18a13 Ln2a13 Ln18a13 0.469680
Kn2an18a14 Ln2a14 Ln18a14 0.469680
Kn2an18a15 Ln2a15 Ln18a15 0.469680
Kn2an18a16 Ln2a16 Ln18a16 0.469680
Kn2an19a1 Ln2a1 Ln19a1 0.463523
Kn2an19a2 Ln2a2 Ln19a2 0.463523
Kn2an19a3 Ln2a3 Ln19a3 0.463523
Kn2an19a4 Ln2a4 Ln19a4 0.463523
Kn2an19a5 Ln2a5 Ln19a5 0.463523
Kn2an19a6 Ln2a6 Ln19a6 0.463523
Kn2an19a7 Ln2a7 Ln19a7 0.463523
Kn2an19a8 Ln2a8 Ln19a8 0.463523
Kn2an19a9 Ln2a9 Ln19a9 0.463523
Kn2an19a10 Ln2a10 Ln19a10 0.463523
Kn2an19a11 Ln2a11 Ln19a11 0.463523
Kn2an19a12 Ln2a12 Ln19a12 0.463523
Kn2an19a13 Ln2a13 Ln19a13 0.463523
Kn2an19a14 Ln2a14 Ln19a14 0.463523
Kn2an19a15 Ln2a15 Ln19a15 0.463523
Kn2an19a16 Ln2a16 Ln19a16 0.463523
Kn2an20a1 Ln2a1 Ln20a1 0.458074
Kn2an20a2 Ln2a2 Ln20a2 0.458074
Kn2an20a3 Ln2a3 Ln20a3 0.458074
Kn2an20a4 Ln2a4 Ln20a4 0.458074
Kn2an20a5 Ln2a5 Ln20a5 0.458074
Kn2an20a6 Ln2a6 Ln20a6 0.458074
Kn2an20a7 Ln2a7 Ln20a7 0.458074
Kn2an20a8 Ln2a8 Ln20a8 0.458074
Kn2an20a9 Ln2a9 Ln20a9 0.458074
Kn2an20a10 Ln2a10 Ln20a10 0.458074
Kn2an20a11 Ln2a11 Ln20a11 0.458074
Kn2an20a12 Ln2a12 Ln20a12 0.458074
Kn2an20a13 Ln2a13 Ln20a13 0.458074
Kn2an20a14 Ln2a14 Ln20a14 0.458074
Kn2an20a15 Ln2a15 Ln20a15 0.458074
Kn2an20a16 Ln2a16 Ln20a16 0.458074
Kn2an21a1 Ln2a1 Ln21a1 0.453889
Kn2an21a2 Ln2a2 Ln21a2 0.453889
Kn2an21a3 Ln2a3 Ln21a3 0.453889
Kn2an21a4 Ln2a4 Ln21a4 0.453889
Kn2an21a5 Ln2a5 Ln21a5 0.453889
Kn2an21a6 Ln2a6 Ln21a6 0.453889
Kn2an21a7 Ln2a7 Ln21a7 0.453889
Kn2an21a8 Ln2a8 Ln21a8 0.453889
Kn2an21a9 Ln2a9 Ln21a9 0.453889
Kn2an21a10 Ln2a10 Ln21a10 0.453889
Kn2an21a11 Ln2a11 Ln21a11 0.453889
Kn2an21a12 Ln2a12 Ln21a12 0.453889
Kn2an21a13 Ln2a13 Ln21a13 0.453889
Kn2an21a14 Ln2a14 Ln21a14 0.453889
Kn2an21a15 Ln2a15 Ln21a15 0.453889
Kn2an21a16 Ln2a16 Ln21a16 0.453889
Kn2an22a1 Ln2a1 Ln22a1 0.450243
Kn2an22a2 Ln2a2 Ln22a2 0.450243
Kn2an22a3 Ln2a3 Ln22a3 0.450243
Kn2an22a4 Ln2a4 Ln22a4 0.450243
Kn2an22a5 Ln2a5 Ln22a5 0.450243
Kn2an22a6 Ln2a6 Ln22a6 0.450243
Kn2an22a7 Ln2a7 Ln22a7 0.450243
Kn2an22a8 Ln2a8 Ln22a8 0.450243
Kn2an22a9 Ln2a9 Ln22a9 0.450243
Kn2an22a10 Ln2a10 Ln22a10 0.450243
Kn2an22a11 Ln2a11 Ln22a11 0.450243
Kn2an22a12 Ln2a12 Ln22a12 0.450243
Kn2an22a13 Ln2a13 Ln22a13 0.450243
Kn2an22a14 Ln2a14 Ln22a14 0.450243
Kn2an22a15 Ln2a15 Ln22a15 0.450243
Kn2an22a16 Ln2a16 Ln22a16 0.450243
Kn2an23a1 Ln2a1 Ln23a1 0.447456
Kn2an23a2 Ln2a2 Ln23a2 0.447456
Kn2an23a3 Ln2a3 Ln23a3 0.447456
Kn2an23a4 Ln2a4 Ln23a4 0.447456
Kn2an23a5 Ln2a5 Ln23a5 0.447456
Kn2an23a6 Ln2a6 Ln23a6 0.447456
Kn2an23a7 Ln2a7 Ln23a7 0.447456
Kn2an23a8 Ln2a8 Ln23a8 0.447456
Kn2an23a9 Ln2a9 Ln23a9 0.447456
Kn2an23a10 Ln2a10 Ln23a10 0.447456
Kn2an23a11 Ln2a11 Ln23a11 0.447456
Kn2an23a12 Ln2a12 Ln23a12 0.447456
Kn2an23a13 Ln2a13 Ln23a13 0.447456
Kn2an23a14 Ln2a14 Ln23a14 0.447456
Kn2an23a15 Ln2a15 Ln23a15 0.447456
Kn2an23a16 Ln2a16 Ln23a16 0.447456
Kn2an24a1 Ln2a1 Ln24a1 0.445700
Kn2an24a2 Ln2a2 Ln24a2 0.445700
Kn2an24a3 Ln2a3 Ln24a3 0.445700
Kn2an24a4 Ln2a4 Ln24a4 0.445700
Kn2an24a5 Ln2a5 Ln24a5 0.445700
Kn2an24a6 Ln2a6 Ln24a6 0.445700
Kn2an24a7 Ln2a7 Ln24a7 0.445700
Kn2an24a8 Ln2a8 Ln24a8 0.445700
Kn2an24a9 Ln2a9 Ln24a9 0.445700
Kn2an24a10 Ln2a10 Ln24a10 0.445700
Kn2an24a11 Ln2a11 Ln24a11 0.445700
Kn2an24a12 Ln2a12 Ln24a12 0.445700
Kn2an24a13 Ln2a13 Ln24a13 0.445700
Kn2an24a14 Ln2a14 Ln24a14 0.445700
Kn2an24a15 Ln2a15 Ln24a15 0.445700
Kn2an24a16 Ln2a16 Ln24a16 0.445700
Kn2an25a1 Ln2a1 Ln25a1 0.444759
Kn2an25a2 Ln2a2 Ln25a2 0.444759
Kn2an25a3 Ln2a3 Ln25a3 0.444759
Kn2an25a4 Ln2a4 Ln25a4 0.444759
Kn2an25a5 Ln2a5 Ln25a5 0.444759
Kn2an25a6 Ln2a6 Ln25a6 0.444759
Kn2an25a7 Ln2a7 Ln25a7 0.444759
Kn2an25a8 Ln2a8 Ln25a8 0.444759
Kn2an25a9 Ln2a9 Ln25a9 0.444759
Kn2an25a10 Ln2a10 Ln25a10 0.444759
Kn2an25a11 Ln2a11 Ln25a11 0.444759
Kn2an25a12 Ln2a12 Ln25a12 0.444759
Kn2an25a13 Ln2a13 Ln25a13 0.444759
Kn2an25a14 Ln2a14 Ln25a14 0.444759
Kn2an25a15 Ln2a15 Ln25a15 0.444759
Kn2an25a16 Ln2a16 Ln25a16 0.444759
Kn2an26a1 Ln2a1 Ln26a1 0.443914
Kn2an26a2 Ln2a2 Ln26a2 0.443914
Kn2an26a3 Ln2a3 Ln26a3 0.443914
Kn2an26a4 Ln2a4 Ln26a4 0.443914
Kn2an26a5 Ln2a5 Ln26a5 0.443914
Kn2an26a6 Ln2a6 Ln26a6 0.443914
Kn2an26a7 Ln2a7 Ln26a7 0.443914
Kn2an26a8 Ln2a8 Ln26a8 0.443914
Kn2an26a9 Ln2a9 Ln26a9 0.443914
Kn2an26a10 Ln2a10 Ln26a10 0.443914
Kn2an26a11 Ln2a11 Ln26a11 0.443914
Kn2an26a12 Ln2a12 Ln26a12 0.443914
Kn2an26a13 Ln2a13 Ln26a13 0.443914
Kn2an26a14 Ln2a14 Ln26a14 0.443914
Kn2an26a15 Ln2a15 Ln26a15 0.443914
Kn2an26a16 Ln2a16 Ln26a16 0.443914
Kn2an27a1 Ln2a1 Ln27a1 0.443172
Kn2an27a2 Ln2a2 Ln27a2 0.443172
Kn2an27a3 Ln2a3 Ln27a3 0.443172
Kn2an27a4 Ln2a4 Ln27a4 0.443172
Kn2an27a5 Ln2a5 Ln27a5 0.443172
Kn2an27a6 Ln2a6 Ln27a6 0.443172
Kn2an27a7 Ln2a7 Ln27a7 0.443172
Kn2an27a8 Ln2a8 Ln27a8 0.443172
Kn2an27a9 Ln2a9 Ln27a9 0.443172
Kn2an27a10 Ln2a10 Ln27a10 0.443172
Kn2an27a11 Ln2a11 Ln27a11 0.443172
Kn2an27a12 Ln2a12 Ln27a12 0.443172
Kn2an27a13 Ln2a13 Ln27a13 0.443172
Kn2an27a14 Ln2a14 Ln27a14 0.443172
Kn2an27a15 Ln2a15 Ln27a15 0.443172
Kn2an27a16 Ln2a16 Ln27a16 0.443172
Kn2an28a1 Ln2a1 Ln28a1 0.442527
Kn2an28a2 Ln2a2 Ln28a2 0.442527
Kn2an28a3 Ln2a3 Ln28a3 0.442527
Kn2an28a4 Ln2a4 Ln28a4 0.442527
Kn2an28a5 Ln2a5 Ln28a5 0.442527
Kn2an28a6 Ln2a6 Ln28a6 0.442527
Kn2an28a7 Ln2a7 Ln28a7 0.442527
Kn2an28a8 Ln2a8 Ln28a8 0.442527
Kn2an28a9 Ln2a9 Ln28a9 0.442527
Kn2an28a10 Ln2a10 Ln28a10 0.442527
Kn2an28a11 Ln2a11 Ln28a11 0.442527
Kn2an28a12 Ln2a12 Ln28a12 0.442527
Kn2an28a13 Ln2a13 Ln28a13 0.442527
Kn2an28a14 Ln2a14 Ln28a14 0.442527
Kn2an28a15 Ln2a15 Ln28a15 0.442527
Kn2an28a16 Ln2a16 Ln28a16 0.442527
Kn2an29a1 Ln2a1 Ln29a1 0.442011
Kn2an29a2 Ln2a2 Ln29a2 0.442011
Kn2an29a3 Ln2a3 Ln29a3 0.442011
Kn2an29a4 Ln2a4 Ln29a4 0.442011
Kn2an29a5 Ln2a5 Ln29a5 0.442011
Kn2an29a6 Ln2a6 Ln29a6 0.442011
Kn2an29a7 Ln2a7 Ln29a7 0.442011
Kn2an29a8 Ln2a8 Ln29a8 0.442011
Kn2an29a9 Ln2a9 Ln29a9 0.442011
Kn2an29a10 Ln2a10 Ln29a10 0.442011
Kn2an29a11 Ln2a11 Ln29a11 0.442011
Kn2an29a12 Ln2a12 Ln29a12 0.442011
Kn2an29a13 Ln2a13 Ln29a13 0.442011
Kn2an29a14 Ln2a14 Ln29a14 0.442011
Kn2an29a15 Ln2a15 Ln29a15 0.442011
Kn2an29a16 Ln2a16 Ln29a16 0.442011
Kn2an30a1 Ln2a1 Ln30a1 0.441523
Kn2an30a2 Ln2a2 Ln30a2 0.441523
Kn2an30a3 Ln2a3 Ln30a3 0.441523
Kn2an30a4 Ln2a4 Ln30a4 0.441523
Kn2an30a5 Ln2a5 Ln30a5 0.441523
Kn2an30a6 Ln2a6 Ln30a6 0.441523
Kn2an30a7 Ln2a7 Ln30a7 0.441523
Kn2an30a8 Ln2a8 Ln30a8 0.441523
Kn2an30a9 Ln2a9 Ln30a9 0.441523
Kn2an30a10 Ln2a10 Ln30a10 0.441523
Kn2an30a11 Ln2a11 Ln30a11 0.441523
Kn2an30a12 Ln2a12 Ln30a12 0.441523
Kn2an30a13 Ln2a13 Ln30a13 0.441523
Kn2an30a14 Ln2a14 Ln30a14 0.441523
Kn2an30a15 Ln2a15 Ln30a15 0.441523
Kn2an30a16 Ln2a16 Ln30a16 0.441523
Kn2an31a1 Ln2a1 Ln31a1 0.441177
Kn2an31a2 Ln2a2 Ln31a2 0.441177
Kn2an31a3 Ln2a3 Ln31a3 0.441177
Kn2an31a4 Ln2a4 Ln31a4 0.441177
Kn2an31a5 Ln2a5 Ln31a5 0.441177
Kn2an31a6 Ln2a6 Ln31a6 0.441177
Kn2an31a7 Ln2a7 Ln31a7 0.441177
Kn2an31a8 Ln2a8 Ln31a8 0.441177
Kn2an31a9 Ln2a9 Ln31a9 0.441177
Kn2an31a10 Ln2a10 Ln31a10 0.441177
Kn2an31a11 Ln2a11 Ln31a11 0.441177
Kn2an31a12 Ln2a12 Ln31a12 0.441177
Kn2an31a13 Ln2a13 Ln31a13 0.441177
Kn2an31a14 Ln2a14 Ln31a14 0.441177
Kn2an31a15 Ln2a15 Ln31a15 0.441177
Kn2an31a16 Ln2a16 Ln31a16 0.441177
Kn2an32a1 Ln2a1 Ln32a1 0.440889
Kn2an32a2 Ln2a2 Ln32a2 0.440889
Kn2an32a3 Ln2a3 Ln32a3 0.440889
Kn2an32a4 Ln2a4 Ln32a4 0.440889
Kn2an32a5 Ln2a5 Ln32a5 0.440889
Kn2an32a6 Ln2a6 Ln32a6 0.440889
Kn2an32a7 Ln2a7 Ln32a7 0.440889
Kn2an32a8 Ln2a8 Ln32a8 0.440889
Kn2an32a9 Ln2a9 Ln32a9 0.440889
Kn2an32a10 Ln2a10 Ln32a10 0.440889
Kn2an32a11 Ln2a11 Ln32a11 0.440889
Kn2an32a12 Ln2a12 Ln32a12 0.440889
Kn2an32a13 Ln2a13 Ln32a13 0.440889
Kn2an32a14 Ln2a14 Ln32a14 0.440889
Kn2an32a15 Ln2a15 Ln32a15 0.440889
Kn2an32a16 Ln2a16 Ln32a16 0.440889
Kn2anva1 Ln2a1 Lnva1 0.440743
Kn2anva2 Ln2a2 Lnva2 0.440743
Kn2anva3 Ln2a3 Lnva3 0.440743
Kn2anva4 Ln2a4 Lnva4 0.440743
Kn2anva5 Ln2a5 Lnva5 0.440743
Kn2anva6 Ln2a6 Lnva6 0.440743
Kn2anva7 Ln2a7 Lnva7 0.440743
Kn2anva8 Ln2a8 Lnva8 0.440743
Kn2anva9 Ln2a9 Lnva9 0.440743
Kn2anva10 Ln2a10 Lnva10 0.440743
Kn2anva11 Ln2a11 Lnva11 0.440743
Kn2anva12 Ln2a12 Lnva12 0.440743
Kn2anva13 Ln2a13 Lnva13 0.440743
Kn2anva14 Ln2a14 Lnva14 0.440743
Kn2anva15 Ln2a15 Lnva15 0.440743
Kn2anva16 Ln2a16 Lnva16 0.440743
Kn3an4a1 Ln3a1 Ln4a1 0.805155
Kn3an4a2 Ln3a2 Ln4a2 0.805155
Kn3an4a3 Ln3a3 Ln4a3 0.805155
Kn3an4a4 Ln3a4 Ln4a4 0.805155
Kn3an4a5 Ln3a5 Ln4a5 0.805155
Kn3an4a6 Ln3a6 Ln4a6 0.805155
Kn3an4a7 Ln3a7 Ln4a7 0.805155
Kn3an4a8 Ln3a8 Ln4a8 0.805155
Kn3an4a9 Ln3a9 Ln4a9 0.805155
Kn3an4a10 Ln3a10 Ln4a10 0.805155
Kn3an4a11 Ln3a11 Ln4a11 0.805155
Kn3an4a12 Ln3a12 Ln4a12 0.805155
Kn3an4a13 Ln3a13 Ln4a13 0.805155
Kn3an4a14 Ln3a14 Ln4a14 0.805155
Kn3an4a15 Ln3a15 Ln4a15 0.805155
Kn3an4a16 Ln3a16 Ln4a16 0.805155
Kn3an5a1 Ln3a1 Ln5a1 0.723730
Kn3an5a2 Ln3a2 Ln5a2 0.723730
Kn3an5a3 Ln3a3 Ln5a3 0.723730
Kn3an5a4 Ln3a4 Ln5a4 0.723730
Kn3an5a5 Ln3a5 Ln5a5 0.723730
Kn3an5a6 Ln3a6 Ln5a6 0.723730
Kn3an5a7 Ln3a7 Ln5a7 0.723730
Kn3an5a8 Ln3a8 Ln5a8 0.723730
Kn3an5a9 Ln3a9 Ln5a9 0.723730
Kn3an5a10 Ln3a10 Ln5a10 0.723730
Kn3an5a11 Ln3a11 Ln5a11 0.723730
Kn3an5a12 Ln3a12 Ln5a12 0.723730
Kn3an5a13 Ln3a13 Ln5a13 0.723730
Kn3an5a14 Ln3a14 Ln5a14 0.723730
Kn3an5a15 Ln3a15 Ln5a15 0.723730
Kn3an5a16 Ln3a16 Ln5a16 0.723730
Kn3an6a1 Ln3a1 Ln6a1 0.675208
Kn3an6a2 Ln3a2 Ln6a2 0.675208
Kn3an6a3 Ln3a3 Ln6a3 0.675208
Kn3an6a4 Ln3a4 Ln6a4 0.675208
Kn3an6a5 Ln3a5 Ln6a5 0.675208
Kn3an6a6 Ln3a6 Ln6a6 0.675208
Kn3an6a7 Ln3a7 Ln6a7 0.675208
Kn3an6a8 Ln3a8 Ln6a8 0.675208
Kn3an6a9 Ln3a9 Ln6a9 0.675208
Kn3an6a10 Ln3a10 Ln6a10 0.675208
Kn3an6a11 Ln3a11 Ln6a11 0.675208
Kn3an6a12 Ln3a12 Ln6a12 0.675208
Kn3an6a13 Ln3a13 Ln6a13 0.675208
Kn3an6a14 Ln3a14 Ln6a14 0.675208
Kn3an6a15 Ln3a15 Ln6a15 0.675208
Kn3an6a16 Ln3a16 Ln6a16 0.675208
Kn3an7a1 Ln3a1 Ln7a1 0.640637
Kn3an7a2 Ln3a2 Ln7a2 0.640637
Kn3an7a3 Ln3a3 Ln7a3 0.640637
Kn3an7a4 Ln3a4 Ln7a4 0.640637
Kn3an7a5 Ln3a5 Ln7a5 0.640637
Kn3an7a6 Ln3a6 Ln7a6 0.640637
Kn3an7a7 Ln3a7 Ln7a7 0.640637
Kn3an7a8 Ln3a8 Ln7a8 0.640637
Kn3an7a9 Ln3a9 Ln7a9 0.640637
Kn3an7a10 Ln3a10 Ln7a10 0.640637
Kn3an7a11 Ln3a11 Ln7a11 0.640637
Kn3an7a12 Ln3a12 Ln7a12 0.640637
Kn3an7a13 Ln3a13 Ln7a13 0.640637
Kn3an7a14 Ln3a14 Ln7a14 0.640637
Kn3an7a15 Ln3a15 Ln7a15 0.640637
Kn3an7a16 Ln3a16 Ln7a16 0.640637
Kn3an8a1 Ln3a1 Ln8a1 0.613723
Kn3an8a2 Ln3a2 Ln8a2 0.613723
Kn3an8a3 Ln3a3 Ln8a3 0.613723
Kn3an8a4 Ln3a4 Ln8a4 0.613723
Kn3an8a5 Ln3a5 Ln8a5 0.613723
Kn3an8a6 Ln3a6 Ln8a6 0.613723
Kn3an8a7 Ln3a7 Ln8a7 0.613723
Kn3an8a8 Ln3a8 Ln8a8 0.613723
Kn3an8a9 Ln3a9 Ln8a9 0.613723
Kn3an8a10 Ln3a10 Ln8a10 0.613723
Kn3an8a11 Ln3a11 Ln8a11 0.613723
Kn3an8a12 Ln3a12 Ln8a12 0.613723
Kn3an8a13 Ln3a13 Ln8a13 0.613723
Kn3an8a14 Ln3a14 Ln8a14 0.613723
Kn3an8a15 Ln3a15 Ln8a15 0.613723
Kn3an8a16 Ln3a16 Ln8a16 0.613723
Kn3an9a1 Ln3a1 Ln9a1 0.591812
Kn3an9a2 Ln3a2 Ln9a2 0.591812
Kn3an9a3 Ln3a3 Ln9a3 0.591812
Kn3an9a4 Ln3a4 Ln9a4 0.591812
Kn3an9a5 Ln3a5 Ln9a5 0.591812
Kn3an9a6 Ln3a6 Ln9a6 0.591812
Kn3an9a7 Ln3a7 Ln9a7 0.591812
Kn3an9a8 Ln3a8 Ln9a8 0.591812
Kn3an9a9 Ln3a9 Ln9a9 0.591812
Kn3an9a10 Ln3a10 Ln9a10 0.591812
Kn3an9a11 Ln3a11 Ln9a11 0.591812
Kn3an9a12 Ln3a12 Ln9a12 0.591812
Kn3an9a13 Ln3a13 Ln9a13 0.591812
Kn3an9a14 Ln3a14 Ln9a14 0.591812
Kn3an9a15 Ln3a15 Ln9a15 0.591812
Kn3an9a16 Ln3a16 Ln9a16 0.591812
Kn3an10a1 Ln3a1 Ln10a1 0.573237
Kn3an10a2 Ln3a2 Ln10a2 0.573237
Kn3an10a3 Ln3a3 Ln10a3 0.573237
Kn3an10a4 Ln3a4 Ln10a4 0.573237
Kn3an10a5 Ln3a5 Ln10a5 0.573237
Kn3an10a6 Ln3a6 Ln10a6 0.573237
Kn3an10a7 Ln3a7 Ln10a7 0.573237
Kn3an10a8 Ln3a8 Ln10a8 0.573237
Kn3an10a9 Ln3a9 Ln10a9 0.573237
Kn3an10a10 Ln3a10 Ln10a10 0.573237
Kn3an10a11 Ln3a11 Ln10a11 0.573237
Kn3an10a12 Ln3a12 Ln10a12 0.573237
Kn3an10a13 Ln3a13 Ln10a13 0.573237
Kn3an10a14 Ln3a14 Ln10a14 0.573237
Kn3an10a15 Ln3a15 Ln10a15 0.573237
Kn3an10a16 Ln3a16 Ln10a16 0.573237
Kn3an11a1 Ln3a1 Ln11a1 0.557165
Kn3an11a2 Ln3a2 Ln11a2 0.557165
Kn3an11a3 Ln3a3 Ln11a3 0.557165
Kn3an11a4 Ln3a4 Ln11a4 0.557165
Kn3an11a5 Ln3a5 Ln11a5 0.557165
Kn3an11a6 Ln3a6 Ln11a6 0.557165
Kn3an11a7 Ln3a7 Ln11a7 0.557165
Kn3an11a8 Ln3a8 Ln11a8 0.557165
Kn3an11a9 Ln3a9 Ln11a9 0.557165
Kn3an11a10 Ln3a10 Ln11a10 0.557165
Kn3an11a11 Ln3a11 Ln11a11 0.557165
Kn3an11a12 Ln3a12 Ln11a12 0.557165
Kn3an11a13 Ln3a13 Ln11a13 0.557165
Kn3an11a14 Ln3a14 Ln11a14 0.557165
Kn3an11a15 Ln3a15 Ln11a15 0.557165
Kn3an11a16 Ln3a16 Ln11a16 0.557165
Kn3an12a1 Ln3a1 Ln12a1 0.542987
Kn3an12a2 Ln3a2 Ln12a2 0.542987
Kn3an12a3 Ln3a3 Ln12a3 0.542987
Kn3an12a4 Ln3a4 Ln12a4 0.542987
Kn3an12a5 Ln3a5 Ln12a5 0.542987
Kn3an12a6 Ln3a6 Ln12a6 0.542987
Kn3an12a7 Ln3a7 Ln12a7 0.542987
Kn3an12a8 Ln3a8 Ln12a8 0.542987
Kn3an12a9 Ln3a9 Ln12a9 0.542987
Kn3an12a10 Ln3a10 Ln12a10 0.542987
Kn3an12a11 Ln3a11 Ln12a11 0.542987
Kn3an12a12 Ln3a12 Ln12a12 0.542987
Kn3an12a13 Ln3a13 Ln12a13 0.542987
Kn3an12a14 Ln3a14 Ln12a14 0.542987
Kn3an12a15 Ln3a15 Ln12a15 0.542987
Kn3an12a16 Ln3a16 Ln12a16 0.542987
Kn3an13a1 Ln3a1 Ln13a1 0.529400
Kn3an13a2 Ln3a2 Ln13a2 0.529400
Kn3an13a3 Ln3a3 Ln13a3 0.529400
Kn3an13a4 Ln3a4 Ln13a4 0.529400
Kn3an13a5 Ln3a5 Ln13a5 0.529400
Kn3an13a6 Ln3a6 Ln13a6 0.529400
Kn3an13a7 Ln3a7 Ln13a7 0.529400
Kn3an13a8 Ln3a8 Ln13a8 0.529400
Kn3an13a9 Ln3a9 Ln13a9 0.529400
Kn3an13a10 Ln3a10 Ln13a10 0.529400
Kn3an13a11 Ln3a11 Ln13a11 0.529400
Kn3an13a12 Ln3a12 Ln13a12 0.529400
Kn3an13a13 Ln3a13 Ln13a13 0.529400
Kn3an13a14 Ln3a14 Ln13a14 0.529400
Kn3an13a15 Ln3a15 Ln13a15 0.529400
Kn3an13a16 Ln3a16 Ln13a16 0.529400
Kn3an14a1 Ln3a1 Ln14a1 0.516943
Kn3an14a2 Ln3a2 Ln14a2 0.516943
Kn3an14a3 Ln3a3 Ln14a3 0.516943
Kn3an14a4 Ln3a4 Ln14a4 0.516943
Kn3an14a5 Ln3a5 Ln14a5 0.516943
Kn3an14a6 Ln3a6 Ln14a6 0.516943
Kn3an14a7 Ln3a7 Ln14a7 0.516943
Kn3an14a8 Ln3a8 Ln14a8 0.516943
Kn3an14a9 Ln3a9 Ln14a9 0.516943
Kn3an14a10 Ln3a10 Ln14a10 0.516943
Kn3an14a11 Ln3a11 Ln14a11 0.516943
Kn3an14a12 Ln3a12 Ln14a12 0.516943
Kn3an14a13 Ln3a13 Ln14a13 0.516943
Kn3an14a14 Ln3a14 Ln14a14 0.516943
Kn3an14a15 Ln3a15 Ln14a15 0.516943
Kn3an14a16 Ln3a16 Ln14a16 0.516943
Kn3an15a1 Ln3a1 Ln15a1 0.505455
Kn3an15a2 Ln3a2 Ln15a2 0.505455
Kn3an15a3 Ln3a3 Ln15a3 0.505455
Kn3an15a4 Ln3a4 Ln15a4 0.505455
Kn3an15a5 Ln3a5 Ln15a5 0.505455
Kn3an15a6 Ln3a6 Ln15a6 0.505455
Kn3an15a7 Ln3a7 Ln15a7 0.505455
Kn3an15a8 Ln3a8 Ln15a8 0.505455
Kn3an15a9 Ln3a9 Ln15a9 0.505455
Kn3an15a10 Ln3a10 Ln15a10 0.505455
Kn3an15a11 Ln3a11 Ln15a11 0.505455
Kn3an15a12 Ln3a12 Ln15a12 0.505455
Kn3an15a13 Ln3a13 Ln15a13 0.505455
Kn3an15a14 Ln3a14 Ln15a14 0.505455
Kn3an15a15 Ln3a15 Ln15a15 0.505455
Kn3an15a16 Ln3a16 Ln15a16 0.505455
Kn3an16a1 Ln3a1 Ln16a1 0.494887
Kn3an16a2 Ln3a2 Ln16a2 0.494887
Kn3an16a3 Ln3a3 Ln16a3 0.494887
Kn3an16a4 Ln3a4 Ln16a4 0.494887
Kn3an16a5 Ln3a5 Ln16a5 0.494887
Kn3an16a6 Ln3a6 Ln16a6 0.494887
Kn3an16a7 Ln3a7 Ln16a7 0.494887
Kn3an16a8 Ln3a8 Ln16a8 0.494887
Kn3an16a9 Ln3a9 Ln16a9 0.494887
Kn3an16a10 Ln3a10 Ln16a10 0.494887
Kn3an16a11 Ln3a11 Ln16a11 0.494887
Kn3an16a12 Ln3a12 Ln16a12 0.494887
Kn3an16a13 Ln3a13 Ln16a13 0.494887
Kn3an16a14 Ln3a14 Ln16a14 0.494887
Kn3an16a15 Ln3a15 Ln16a15 0.494887
Kn3an16a16 Ln3a16 Ln16a16 0.494887
Kn3an17a1 Ln3a1 Ln17a1 0.485771
Kn3an17a2 Ln3a2 Ln17a2 0.485771
Kn3an17a3 Ln3a3 Ln17a3 0.485771
Kn3an17a4 Ln3a4 Ln17a4 0.485771
Kn3an17a5 Ln3a5 Ln17a5 0.485771
Kn3an17a6 Ln3a6 Ln17a6 0.485771
Kn3an17a7 Ln3a7 Ln17a7 0.485771
Kn3an17a8 Ln3a8 Ln17a8 0.485771
Kn3an17a9 Ln3a9 Ln17a9 0.485771
Kn3an17a10 Ln3a10 Ln17a10 0.485771
Kn3an17a11 Ln3a11 Ln17a11 0.485771
Kn3an17a12 Ln3a12 Ln17a12 0.485771
Kn3an17a13 Ln3a13 Ln17a13 0.485771
Kn3an17a14 Ln3a14 Ln17a14 0.485771
Kn3an17a15 Ln3a15 Ln17a15 0.485771
Kn3an17a16 Ln3a16 Ln17a16 0.485771
Kn3an18a1 Ln3a1 Ln18a1 0.477226
Kn3an18a2 Ln3a2 Ln18a2 0.477226
Kn3an18a3 Ln3a3 Ln18a3 0.477226
Kn3an18a4 Ln3a4 Ln18a4 0.477226
Kn3an18a5 Ln3a5 Ln18a5 0.477226
Kn3an18a6 Ln3a6 Ln18a6 0.477226
Kn3an18a7 Ln3a7 Ln18a7 0.477226
Kn3an18a8 Ln3a8 Ln18a8 0.477226
Kn3an18a9 Ln3a9 Ln18a9 0.477226
Kn3an18a10 Ln3a10 Ln18a10 0.477226
Kn3an18a11 Ln3a11 Ln18a11 0.477226
Kn3an18a12 Ln3a12 Ln18a12 0.477226
Kn3an18a13 Ln3a13 Ln18a13 0.477226
Kn3an18a14 Ln3a14 Ln18a14 0.477226
Kn3an18a15 Ln3a15 Ln18a15 0.477226
Kn3an18a16 Ln3a16 Ln18a16 0.477226
Kn3an19a1 Ln3a1 Ln19a1 0.469680
Kn3an19a2 Ln3a2 Ln19a2 0.469680
Kn3an19a3 Ln3a3 Ln19a3 0.469680
Kn3an19a4 Ln3a4 Ln19a4 0.469680
Kn3an19a5 Ln3a5 Ln19a5 0.469680
Kn3an19a6 Ln3a6 Ln19a6 0.469680
Kn3an19a7 Ln3a7 Ln19a7 0.469680
Kn3an19a8 Ln3a8 Ln19a8 0.469680
Kn3an19a9 Ln3a9 Ln19a9 0.469680
Kn3an19a10 Ln3a10 Ln19a10 0.469680
Kn3an19a11 Ln3a11 Ln19a11 0.469680
Kn3an19a12 Ln3a12 Ln19a12 0.469680
Kn3an19a13 Ln3a13 Ln19a13 0.469680
Kn3an19a14 Ln3a14 Ln19a14 0.469680
Kn3an19a15 Ln3a15 Ln19a15 0.469680
Kn3an19a16 Ln3a16 Ln19a16 0.469680
Kn3an20a1 Ln3a1 Ln20a1 0.463523
Kn3an20a2 Ln3a2 Ln20a2 0.463523
Kn3an20a3 Ln3a3 Ln20a3 0.463523
Kn3an20a4 Ln3a4 Ln20a4 0.463523
Kn3an20a5 Ln3a5 Ln20a5 0.463523
Kn3an20a6 Ln3a6 Ln20a6 0.463523
Kn3an20a7 Ln3a7 Ln20a7 0.463523
Kn3an20a8 Ln3a8 Ln20a8 0.463523
Kn3an20a9 Ln3a9 Ln20a9 0.463523
Kn3an20a10 Ln3a10 Ln20a10 0.463523
Kn3an20a11 Ln3a11 Ln20a11 0.463523
Kn3an20a12 Ln3a12 Ln20a12 0.463523
Kn3an20a13 Ln3a13 Ln20a13 0.463523
Kn3an20a14 Ln3a14 Ln20a14 0.463523
Kn3an20a15 Ln3a15 Ln20a15 0.463523
Kn3an20a16 Ln3a16 Ln20a16 0.463523
Kn3an21a1 Ln3a1 Ln21a1 0.458074
Kn3an21a2 Ln3a2 Ln21a2 0.458074
Kn3an21a3 Ln3a3 Ln21a3 0.458074
Kn3an21a4 Ln3a4 Ln21a4 0.458074
Kn3an21a5 Ln3a5 Ln21a5 0.458074
Kn3an21a6 Ln3a6 Ln21a6 0.458074
Kn3an21a7 Ln3a7 Ln21a7 0.458074
Kn3an21a8 Ln3a8 Ln21a8 0.458074
Kn3an21a9 Ln3a9 Ln21a9 0.458074
Kn3an21a10 Ln3a10 Ln21a10 0.458074
Kn3an21a11 Ln3a11 Ln21a11 0.458074
Kn3an21a12 Ln3a12 Ln21a12 0.458074
Kn3an21a13 Ln3a13 Ln21a13 0.458074
Kn3an21a14 Ln3a14 Ln21a14 0.458074
Kn3an21a15 Ln3a15 Ln21a15 0.458074
Kn3an21a16 Ln3a16 Ln21a16 0.458074
Kn3an22a1 Ln3a1 Ln22a1 0.453889
Kn3an22a2 Ln3a2 Ln22a2 0.453889
Kn3an22a3 Ln3a3 Ln22a3 0.453889
Kn3an22a4 Ln3a4 Ln22a4 0.453889
Kn3an22a5 Ln3a5 Ln22a5 0.453889
Kn3an22a6 Ln3a6 Ln22a6 0.453889
Kn3an22a7 Ln3a7 Ln22a7 0.453889
Kn3an22a8 Ln3a8 Ln22a8 0.453889
Kn3an22a9 Ln3a9 Ln22a9 0.453889
Kn3an22a10 Ln3a10 Ln22a10 0.453889
Kn3an22a11 Ln3a11 Ln22a11 0.453889
Kn3an22a12 Ln3a12 Ln22a12 0.453889
Kn3an22a13 Ln3a13 Ln22a13 0.453889
Kn3an22a14 Ln3a14 Ln22a14 0.453889
Kn3an22a15 Ln3a15 Ln22a15 0.453889
Kn3an22a16 Ln3a16 Ln22a16 0.453889
Kn3an23a1 Ln3a1 Ln23a1 0.450243
Kn3an23a2 Ln3a2 Ln23a2 0.450243
Kn3an23a3 Ln3a3 Ln23a3 0.450243
Kn3an23a4 Ln3a4 Ln23a4 0.450243
Kn3an23a5 Ln3a5 Ln23a5 0.450243
Kn3an23a6 Ln3a6 Ln23a6 0.450243
Kn3an23a7 Ln3a7 Ln23a7 0.450243
Kn3an23a8 Ln3a8 Ln23a8 0.450243
Kn3an23a9 Ln3a9 Ln23a9 0.450243
Kn3an23a10 Ln3a10 Ln23a10 0.450243
Kn3an23a11 Ln3a11 Ln23a11 0.450243
Kn3an23a12 Ln3a12 Ln23a12 0.450243
Kn3an23a13 Ln3a13 Ln23a13 0.450243
Kn3an23a14 Ln3a14 Ln23a14 0.450243
Kn3an23a15 Ln3a15 Ln23a15 0.450243
Kn3an23a16 Ln3a16 Ln23a16 0.450243
Kn3an24a1 Ln3a1 Ln24a1 0.447456
Kn3an24a2 Ln3a2 Ln24a2 0.447456
Kn3an24a3 Ln3a3 Ln24a3 0.447456
Kn3an24a4 Ln3a4 Ln24a4 0.447456
Kn3an24a5 Ln3a5 Ln24a5 0.447456
Kn3an24a6 Ln3a6 Ln24a6 0.447456
Kn3an24a7 Ln3a7 Ln24a7 0.447456
Kn3an24a8 Ln3a8 Ln24a8 0.447456
Kn3an24a9 Ln3a9 Ln24a9 0.447456
Kn3an24a10 Ln3a10 Ln24a10 0.447456
Kn3an24a11 Ln3a11 Ln24a11 0.447456
Kn3an24a12 Ln3a12 Ln24a12 0.447456
Kn3an24a13 Ln3a13 Ln24a13 0.447456
Kn3an24a14 Ln3a14 Ln24a14 0.447456
Kn3an24a15 Ln3a15 Ln24a15 0.447456
Kn3an24a16 Ln3a16 Ln24a16 0.447456
Kn3an25a1 Ln3a1 Ln25a1 0.445700
Kn3an25a2 Ln3a2 Ln25a2 0.445700
Kn3an25a3 Ln3a3 Ln25a3 0.445700
Kn3an25a4 Ln3a4 Ln25a4 0.445700
Kn3an25a5 Ln3a5 Ln25a5 0.445700
Kn3an25a6 Ln3a6 Ln25a6 0.445700
Kn3an25a7 Ln3a7 Ln25a7 0.445700
Kn3an25a8 Ln3a8 Ln25a8 0.445700
Kn3an25a9 Ln3a9 Ln25a9 0.445700
Kn3an25a10 Ln3a10 Ln25a10 0.445700
Kn3an25a11 Ln3a11 Ln25a11 0.445700
Kn3an25a12 Ln3a12 Ln25a12 0.445700
Kn3an25a13 Ln3a13 Ln25a13 0.445700
Kn3an25a14 Ln3a14 Ln25a14 0.445700
Kn3an25a15 Ln3a15 Ln25a15 0.445700
Kn3an25a16 Ln3a16 Ln25a16 0.445700
Kn3an26a1 Ln3a1 Ln26a1 0.444759
Kn3an26a2 Ln3a2 Ln26a2 0.444759
Kn3an26a3 Ln3a3 Ln26a3 0.444759
Kn3an26a4 Ln3a4 Ln26a4 0.444759
Kn3an26a5 Ln3a5 Ln26a5 0.444759
Kn3an26a6 Ln3a6 Ln26a6 0.444759
Kn3an26a7 Ln3a7 Ln26a7 0.444759
Kn3an26a8 Ln3a8 Ln26a8 0.444759
Kn3an26a9 Ln3a9 Ln26a9 0.444759
Kn3an26a10 Ln3a10 Ln26a10 0.444759
Kn3an26a11 Ln3a11 Ln26a11 0.444759
Kn3an26a12 Ln3a12 Ln26a12 0.444759
Kn3an26a13 Ln3a13 Ln26a13 0.444759
Kn3an26a14 Ln3a14 Ln26a14 0.444759
Kn3an26a15 Ln3a15 Ln26a15 0.444759
Kn3an26a16 Ln3a16 Ln26a16 0.444759
Kn3an27a1 Ln3a1 Ln27a1 0.443914
Kn3an27a2 Ln3a2 Ln27a2 0.443914
Kn3an27a3 Ln3a3 Ln27a3 0.443914
Kn3an27a4 Ln3a4 Ln27a4 0.443914
Kn3an27a5 Ln3a5 Ln27a5 0.443914
Kn3an27a6 Ln3a6 Ln27a6 0.443914
Kn3an27a7 Ln3a7 Ln27a7 0.443914
Kn3an27a8 Ln3a8 Ln27a8 0.443914
Kn3an27a9 Ln3a9 Ln27a9 0.443914
Kn3an27a10 Ln3a10 Ln27a10 0.443914
Kn3an27a11 Ln3a11 Ln27a11 0.443914
Kn3an27a12 Ln3a12 Ln27a12 0.443914
Kn3an27a13 Ln3a13 Ln27a13 0.443914
Kn3an27a14 Ln3a14 Ln27a14 0.443914
Kn3an27a15 Ln3a15 Ln27a15 0.443914
Kn3an27a16 Ln3a16 Ln27a16 0.443914
Kn3an28a1 Ln3a1 Ln28a1 0.443172
Kn3an28a2 Ln3a2 Ln28a2 0.443172
Kn3an28a3 Ln3a3 Ln28a3 0.443172
Kn3an28a4 Ln3a4 Ln28a4 0.443172
Kn3an28a5 Ln3a5 Ln28a5 0.443172
Kn3an28a6 Ln3a6 Ln28a6 0.443172
Kn3an28a7 Ln3a7 Ln28a7 0.443172
Kn3an28a8 Ln3a8 Ln28a8 0.443172
Kn3an28a9 Ln3a9 Ln28a9 0.443172
Kn3an28a10 Ln3a10 Ln28a10 0.443172
Kn3an28a11 Ln3a11 Ln28a11 0.443172
Kn3an28a12 Ln3a12 Ln28a12 0.443172
Kn3an28a13 Ln3a13 Ln28a13 0.443172
Kn3an28a14 Ln3a14 Ln28a14 0.443172
Kn3an28a15 Ln3a15 Ln28a15 0.443172
Kn3an28a16 Ln3a16 Ln28a16 0.443172
Kn3an29a1 Ln3a1 Ln29a1 0.442527
Kn3an29a2 Ln3a2 Ln29a2 0.442527
Kn3an29a3 Ln3a3 Ln29a3 0.442527
Kn3an29a4 Ln3a4 Ln29a4 0.442527
Kn3an29a5 Ln3a5 Ln29a5 0.442527
Kn3an29a6 Ln3a6 Ln29a6 0.442527
Kn3an29a7 Ln3a7 Ln29a7 0.442527
Kn3an29a8 Ln3a8 Ln29a8 0.442527
Kn3an29a9 Ln3a9 Ln29a9 0.442527
Kn3an29a10 Ln3a10 Ln29a10 0.442527
Kn3an29a11 Ln3a11 Ln29a11 0.442527
Kn3an29a12 Ln3a12 Ln29a12 0.442527
Kn3an29a13 Ln3a13 Ln29a13 0.442527
Kn3an29a14 Ln3a14 Ln29a14 0.442527
Kn3an29a15 Ln3a15 Ln29a15 0.442527
Kn3an29a16 Ln3a16 Ln29a16 0.442527
Kn3an30a1 Ln3a1 Ln30a1 0.442011
Kn3an30a2 Ln3a2 Ln30a2 0.442011
Kn3an30a3 Ln3a3 Ln30a3 0.442011
Kn3an30a4 Ln3a4 Ln30a4 0.442011
Kn3an30a5 Ln3a5 Ln30a5 0.442011
Kn3an30a6 Ln3a6 Ln30a6 0.442011
Kn3an30a7 Ln3a7 Ln30a7 0.442011
Kn3an30a8 Ln3a8 Ln30a8 0.442011
Kn3an30a9 Ln3a9 Ln30a9 0.442011
Kn3an30a10 Ln3a10 Ln30a10 0.442011
Kn3an30a11 Ln3a11 Ln30a11 0.442011
Kn3an30a12 Ln3a12 Ln30a12 0.442011
Kn3an30a13 Ln3a13 Ln30a13 0.442011
Kn3an30a14 Ln3a14 Ln30a14 0.442011
Kn3an30a15 Ln3a15 Ln30a15 0.442011
Kn3an30a16 Ln3a16 Ln30a16 0.442011
Kn3an31a1 Ln3a1 Ln31a1 0.441523
Kn3an31a2 Ln3a2 Ln31a2 0.441523
Kn3an31a3 Ln3a3 Ln31a3 0.441523
Kn3an31a4 Ln3a4 Ln31a4 0.441523
Kn3an31a5 Ln3a5 Ln31a5 0.441523
Kn3an31a6 Ln3a6 Ln31a6 0.441523
Kn3an31a7 Ln3a7 Ln31a7 0.441523
Kn3an31a8 Ln3a8 Ln31a8 0.441523
Kn3an31a9 Ln3a9 Ln31a9 0.441523
Kn3an31a10 Ln3a10 Ln31a10 0.441523
Kn3an31a11 Ln3a11 Ln31a11 0.441523
Kn3an31a12 Ln3a12 Ln31a12 0.441523
Kn3an31a13 Ln3a13 Ln31a13 0.441523
Kn3an31a14 Ln3a14 Ln31a14 0.441523
Kn3an31a15 Ln3a15 Ln31a15 0.441523
Kn3an31a16 Ln3a16 Ln31a16 0.441523
Kn3an32a1 Ln3a1 Ln32a1 0.441177
Kn3an32a2 Ln3a2 Ln32a2 0.441177
Kn3an32a3 Ln3a3 Ln32a3 0.441177
Kn3an32a4 Ln3a4 Ln32a4 0.441177
Kn3an32a5 Ln3a5 Ln32a5 0.441177
Kn3an32a6 Ln3a6 Ln32a6 0.441177
Kn3an32a7 Ln3a7 Ln32a7 0.441177
Kn3an32a8 Ln3a8 Ln32a8 0.441177
Kn3an32a9 Ln3a9 Ln32a9 0.441177
Kn3an32a10 Ln3a10 Ln32a10 0.441177
Kn3an32a11 Ln3a11 Ln32a11 0.441177
Kn3an32a12 Ln3a12 Ln32a12 0.441177
Kn3an32a13 Ln3a13 Ln32a13 0.441177
Kn3an32a14 Ln3a14 Ln32a14 0.441177
Kn3an32a15 Ln3a15 Ln32a15 0.441177
Kn3an32a16 Ln3a16 Ln32a16 0.441177
Kn3anva1 Ln3a1 Lnva1 0.440889
Kn3anva2 Ln3a2 Lnva2 0.440889
Kn3anva3 Ln3a3 Lnva3 0.440889
Kn3anva4 Ln3a4 Lnva4 0.440889
Kn3anva5 Ln3a5 Lnva5 0.440889
Kn3anva6 Ln3a6 Lnva6 0.440889
Kn3anva7 Ln3a7 Lnva7 0.440889
Kn3anva8 Ln3a8 Lnva8 0.440889
Kn3anva9 Ln3a9 Lnva9 0.440889
Kn3anva10 Ln3a10 Lnva10 0.440889
Kn3anva11 Ln3a11 Lnva11 0.440889
Kn3anva12 Ln3a12 Lnva12 0.440889
Kn3anva13 Ln3a13 Lnva13 0.440889
Kn3anva14 Ln3a14 Lnva14 0.440889
Kn3anva15 Ln3a15 Lnva15 0.440889
Kn3anva16 Ln3a16 Lnva16 0.440889
Kn4an5a1 Ln4a1 Ln5a1 0.805155
Kn4an5a2 Ln4a2 Ln5a2 0.805155
Kn4an5a3 Ln4a3 Ln5a3 0.805155
Kn4an5a4 Ln4a4 Ln5a4 0.805155
Kn4an5a5 Ln4a5 Ln5a5 0.805155
Kn4an5a6 Ln4a6 Ln5a6 0.805155
Kn4an5a7 Ln4a7 Ln5a7 0.805155
Kn4an5a8 Ln4a8 Ln5a8 0.805155
Kn4an5a9 Ln4a9 Ln5a9 0.805155
Kn4an5a10 Ln4a10 Ln5a10 0.805155
Kn4an5a11 Ln4a11 Ln5a11 0.805155
Kn4an5a12 Ln4a12 Ln5a12 0.805155
Kn4an5a13 Ln4a13 Ln5a13 0.805155
Kn4an5a14 Ln4a14 Ln5a14 0.805155
Kn4an5a15 Ln4a15 Ln5a15 0.805155
Kn4an5a16 Ln4a16 Ln5a16 0.805155
Kn4an6a1 Ln4a1 Ln6a1 0.723730
Kn4an6a2 Ln4a2 Ln6a2 0.723730
Kn4an6a3 Ln4a3 Ln6a3 0.723730
Kn4an6a4 Ln4a4 Ln6a4 0.723730
Kn4an6a5 Ln4a5 Ln6a5 0.723730
Kn4an6a6 Ln4a6 Ln6a6 0.723730
Kn4an6a7 Ln4a7 Ln6a7 0.723730
Kn4an6a8 Ln4a8 Ln6a8 0.723730
Kn4an6a9 Ln4a9 Ln6a9 0.723730
Kn4an6a10 Ln4a10 Ln6a10 0.723730
Kn4an6a11 Ln4a11 Ln6a11 0.723730
Kn4an6a12 Ln4a12 Ln6a12 0.723730
Kn4an6a13 Ln4a13 Ln6a13 0.723730
Kn4an6a14 Ln4a14 Ln6a14 0.723730
Kn4an6a15 Ln4a15 Ln6a15 0.723730
Kn4an6a16 Ln4a16 Ln6a16 0.723730
Kn4an7a1 Ln4a1 Ln7a1 0.675208
Kn4an7a2 Ln4a2 Ln7a2 0.675208
Kn4an7a3 Ln4a3 Ln7a3 0.675208
Kn4an7a4 Ln4a4 Ln7a4 0.675208
Kn4an7a5 Ln4a5 Ln7a5 0.675208
Kn4an7a6 Ln4a6 Ln7a6 0.675208
Kn4an7a7 Ln4a7 Ln7a7 0.675208
Kn4an7a8 Ln4a8 Ln7a8 0.675208
Kn4an7a9 Ln4a9 Ln7a9 0.675208
Kn4an7a10 Ln4a10 Ln7a10 0.675208
Kn4an7a11 Ln4a11 Ln7a11 0.675208
Kn4an7a12 Ln4a12 Ln7a12 0.675208
Kn4an7a13 Ln4a13 Ln7a13 0.675208
Kn4an7a14 Ln4a14 Ln7a14 0.675208
Kn4an7a15 Ln4a15 Ln7a15 0.675208
Kn4an7a16 Ln4a16 Ln7a16 0.675208
Kn4an8a1 Ln4a1 Ln8a1 0.640637
Kn4an8a2 Ln4a2 Ln8a2 0.640637
Kn4an8a3 Ln4a3 Ln8a3 0.640637
Kn4an8a4 Ln4a4 Ln8a4 0.640637
Kn4an8a5 Ln4a5 Ln8a5 0.640637
Kn4an8a6 Ln4a6 Ln8a6 0.640637
Kn4an8a7 Ln4a7 Ln8a7 0.640637
Kn4an8a8 Ln4a8 Ln8a8 0.640637
Kn4an8a9 Ln4a9 Ln8a9 0.640637
Kn4an8a10 Ln4a10 Ln8a10 0.640637
Kn4an8a11 Ln4a11 Ln8a11 0.640637
Kn4an8a12 Ln4a12 Ln8a12 0.640637
Kn4an8a13 Ln4a13 Ln8a13 0.640637
Kn4an8a14 Ln4a14 Ln8a14 0.640637
Kn4an8a15 Ln4a15 Ln8a15 0.640637
Kn4an8a16 Ln4a16 Ln8a16 0.640637
Kn4an9a1 Ln4a1 Ln9a1 0.613723
Kn4an9a2 Ln4a2 Ln9a2 0.613723
Kn4an9a3 Ln4a3 Ln9a3 0.613723
Kn4an9a4 Ln4a4 Ln9a4 0.613723
Kn4an9a5 Ln4a5 Ln9a5 0.613723
Kn4an9a6 Ln4a6 Ln9a6 0.613723
Kn4an9a7 Ln4a7 Ln9a7 0.613723
Kn4an9a8 Ln4a8 Ln9a8 0.613723
Kn4an9a9 Ln4a9 Ln9a9 0.613723
Kn4an9a10 Ln4a10 Ln9a10 0.613723
Kn4an9a11 Ln4a11 Ln9a11 0.613723
Kn4an9a12 Ln4a12 Ln9a12 0.613723
Kn4an9a13 Ln4a13 Ln9a13 0.613723
Kn4an9a14 Ln4a14 Ln9a14 0.613723
Kn4an9a15 Ln4a15 Ln9a15 0.613723
Kn4an9a16 Ln4a16 Ln9a16 0.613723
Kn4an10a1 Ln4a1 Ln10a1 0.591812
Kn4an10a2 Ln4a2 Ln10a2 0.591812
Kn4an10a3 Ln4a3 Ln10a3 0.591812
Kn4an10a4 Ln4a4 Ln10a4 0.591812
Kn4an10a5 Ln4a5 Ln10a5 0.591812
Kn4an10a6 Ln4a6 Ln10a6 0.591812
Kn4an10a7 Ln4a7 Ln10a7 0.591812
Kn4an10a8 Ln4a8 Ln10a8 0.591812
Kn4an10a9 Ln4a9 Ln10a9 0.591812
Kn4an10a10 Ln4a10 Ln10a10 0.591812
Kn4an10a11 Ln4a11 Ln10a11 0.591812
Kn4an10a12 Ln4a12 Ln10a12 0.591812
Kn4an10a13 Ln4a13 Ln10a13 0.591812
Kn4an10a14 Ln4a14 Ln10a14 0.591812
Kn4an10a15 Ln4a15 Ln10a15 0.591812
Kn4an10a16 Ln4a16 Ln10a16 0.591812
Kn4an11a1 Ln4a1 Ln11a1 0.573237
Kn4an11a2 Ln4a2 Ln11a2 0.573237
Kn4an11a3 Ln4a3 Ln11a3 0.573237
Kn4an11a4 Ln4a4 Ln11a4 0.573237
Kn4an11a5 Ln4a5 Ln11a5 0.573237
Kn4an11a6 Ln4a6 Ln11a6 0.573237
Kn4an11a7 Ln4a7 Ln11a7 0.573237
Kn4an11a8 Ln4a8 Ln11a8 0.573237
Kn4an11a9 Ln4a9 Ln11a9 0.573237
Kn4an11a10 Ln4a10 Ln11a10 0.573237
Kn4an11a11 Ln4a11 Ln11a11 0.573237
Kn4an11a12 Ln4a12 Ln11a12 0.573237
Kn4an11a13 Ln4a13 Ln11a13 0.573237
Kn4an11a14 Ln4a14 Ln11a14 0.573237
Kn4an11a15 Ln4a15 Ln11a15 0.573237
Kn4an11a16 Ln4a16 Ln11a16 0.573237
Kn4an12a1 Ln4a1 Ln12a1 0.557165
Kn4an12a2 Ln4a2 Ln12a2 0.557165
Kn4an12a3 Ln4a3 Ln12a3 0.557165
Kn4an12a4 Ln4a4 Ln12a4 0.557165
Kn4an12a5 Ln4a5 Ln12a5 0.557165
Kn4an12a6 Ln4a6 Ln12a6 0.557165
Kn4an12a7 Ln4a7 Ln12a7 0.557165
Kn4an12a8 Ln4a8 Ln12a8 0.557165
Kn4an12a9 Ln4a9 Ln12a9 0.557165
Kn4an12a10 Ln4a10 Ln12a10 0.557165
Kn4an12a11 Ln4a11 Ln12a11 0.557165
Kn4an12a12 Ln4a12 Ln12a12 0.557165
Kn4an12a13 Ln4a13 Ln12a13 0.557165
Kn4an12a14 Ln4a14 Ln12a14 0.557165
Kn4an12a15 Ln4a15 Ln12a15 0.557165
Kn4an12a16 Ln4a16 Ln12a16 0.557165
Kn4an13a1 Ln4a1 Ln13a1 0.542987
Kn4an13a2 Ln4a2 Ln13a2 0.542987
Kn4an13a3 Ln4a3 Ln13a3 0.542987
Kn4an13a4 Ln4a4 Ln13a4 0.542987
Kn4an13a5 Ln4a5 Ln13a5 0.542987
Kn4an13a6 Ln4a6 Ln13a6 0.542987
Kn4an13a7 Ln4a7 Ln13a7 0.542987
Kn4an13a8 Ln4a8 Ln13a8 0.542987
Kn4an13a9 Ln4a9 Ln13a9 0.542987
Kn4an13a10 Ln4a10 Ln13a10 0.542987
Kn4an13a11 Ln4a11 Ln13a11 0.542987
Kn4an13a12 Ln4a12 Ln13a12 0.542987
Kn4an13a13 Ln4a13 Ln13a13 0.542987
Kn4an13a14 Ln4a14 Ln13a14 0.542987
Kn4an13a15 Ln4a15 Ln13a15 0.542987
Kn4an13a16 Ln4a16 Ln13a16 0.542987
Kn4an14a1 Ln4a1 Ln14a1 0.529400
Kn4an14a2 Ln4a2 Ln14a2 0.529400
Kn4an14a3 Ln4a3 Ln14a3 0.529400
Kn4an14a4 Ln4a4 Ln14a4 0.529400
Kn4an14a5 Ln4a5 Ln14a5 0.529400
Kn4an14a6 Ln4a6 Ln14a6 0.529400
Kn4an14a7 Ln4a7 Ln14a7 0.529400
Kn4an14a8 Ln4a8 Ln14a8 0.529400
Kn4an14a9 Ln4a9 Ln14a9 0.529400
Kn4an14a10 Ln4a10 Ln14a10 0.529400
Kn4an14a11 Ln4a11 Ln14a11 0.529400
Kn4an14a12 Ln4a12 Ln14a12 0.529400
Kn4an14a13 Ln4a13 Ln14a13 0.529400
Kn4an14a14 Ln4a14 Ln14a14 0.529400
Kn4an14a15 Ln4a15 Ln14a15 0.529400
Kn4an14a16 Ln4a16 Ln14a16 0.529400
Kn4an15a1 Ln4a1 Ln15a1 0.516943
Kn4an15a2 Ln4a2 Ln15a2 0.516943
Kn4an15a3 Ln4a3 Ln15a3 0.516943
Kn4an15a4 Ln4a4 Ln15a4 0.516943
Kn4an15a5 Ln4a5 Ln15a5 0.516943
Kn4an15a6 Ln4a6 Ln15a6 0.516943
Kn4an15a7 Ln4a7 Ln15a7 0.516943
Kn4an15a8 Ln4a8 Ln15a8 0.516943
Kn4an15a9 Ln4a9 Ln15a9 0.516943
Kn4an15a10 Ln4a10 Ln15a10 0.516943
Kn4an15a11 Ln4a11 Ln15a11 0.516943
Kn4an15a12 Ln4a12 Ln15a12 0.516943
Kn4an15a13 Ln4a13 Ln15a13 0.516943
Kn4an15a14 Ln4a14 Ln15a14 0.516943
Kn4an15a15 Ln4a15 Ln15a15 0.516943
Kn4an15a16 Ln4a16 Ln15a16 0.516943
Kn4an16a1 Ln4a1 Ln16a1 0.505455
Kn4an16a2 Ln4a2 Ln16a2 0.505455
Kn4an16a3 Ln4a3 Ln16a3 0.505455
Kn4an16a4 Ln4a4 Ln16a4 0.505455
Kn4an16a5 Ln4a5 Ln16a5 0.505455
Kn4an16a6 Ln4a6 Ln16a6 0.505455
Kn4an16a7 Ln4a7 Ln16a7 0.505455
Kn4an16a8 Ln4a8 Ln16a8 0.505455
Kn4an16a9 Ln4a9 Ln16a9 0.505455
Kn4an16a10 Ln4a10 Ln16a10 0.505455
Kn4an16a11 Ln4a11 Ln16a11 0.505455
Kn4an16a12 Ln4a12 Ln16a12 0.505455
Kn4an16a13 Ln4a13 Ln16a13 0.505455
Kn4an16a14 Ln4a14 Ln16a14 0.505455
Kn4an16a15 Ln4a15 Ln16a15 0.505455
Kn4an16a16 Ln4a16 Ln16a16 0.505455
Kn4an17a1 Ln4a1 Ln17a1 0.494887
Kn4an17a2 Ln4a2 Ln17a2 0.494887
Kn4an17a3 Ln4a3 Ln17a3 0.494887
Kn4an17a4 Ln4a4 Ln17a4 0.494887
Kn4an17a5 Ln4a5 Ln17a5 0.494887
Kn4an17a6 Ln4a6 Ln17a6 0.494887
Kn4an17a7 Ln4a7 Ln17a7 0.494887
Kn4an17a8 Ln4a8 Ln17a8 0.494887
Kn4an17a9 Ln4a9 Ln17a9 0.494887
Kn4an17a10 Ln4a10 Ln17a10 0.494887
Kn4an17a11 Ln4a11 Ln17a11 0.494887
Kn4an17a12 Ln4a12 Ln17a12 0.494887
Kn4an17a13 Ln4a13 Ln17a13 0.494887
Kn4an17a14 Ln4a14 Ln17a14 0.494887
Kn4an17a15 Ln4a15 Ln17a15 0.494887
Kn4an17a16 Ln4a16 Ln17a16 0.494887
Kn4an18a1 Ln4a1 Ln18a1 0.485771
Kn4an18a2 Ln4a2 Ln18a2 0.485771
Kn4an18a3 Ln4a3 Ln18a3 0.485771
Kn4an18a4 Ln4a4 Ln18a4 0.485771
Kn4an18a5 Ln4a5 Ln18a5 0.485771
Kn4an18a6 Ln4a6 Ln18a6 0.485771
Kn4an18a7 Ln4a7 Ln18a7 0.485771
Kn4an18a8 Ln4a8 Ln18a8 0.485771
Kn4an18a9 Ln4a9 Ln18a9 0.485771
Kn4an18a10 Ln4a10 Ln18a10 0.485771
Kn4an18a11 Ln4a11 Ln18a11 0.485771
Kn4an18a12 Ln4a12 Ln18a12 0.485771
Kn4an18a13 Ln4a13 Ln18a13 0.485771
Kn4an18a14 Ln4a14 Ln18a14 0.485771
Kn4an18a15 Ln4a15 Ln18a15 0.485771
Kn4an18a16 Ln4a16 Ln18a16 0.485771
Kn4an19a1 Ln4a1 Ln19a1 0.477226
Kn4an19a2 Ln4a2 Ln19a2 0.477226
Kn4an19a3 Ln4a3 Ln19a3 0.477226
Kn4an19a4 Ln4a4 Ln19a4 0.477226
Kn4an19a5 Ln4a5 Ln19a5 0.477226
Kn4an19a6 Ln4a6 Ln19a6 0.477226
Kn4an19a7 Ln4a7 Ln19a7 0.477226
Kn4an19a8 Ln4a8 Ln19a8 0.477226
Kn4an19a9 Ln4a9 Ln19a9 0.477226
Kn4an19a10 Ln4a10 Ln19a10 0.477226
Kn4an19a11 Ln4a11 Ln19a11 0.477226
Kn4an19a12 Ln4a12 Ln19a12 0.477226
Kn4an19a13 Ln4a13 Ln19a13 0.477226
Kn4an19a14 Ln4a14 Ln19a14 0.477226
Kn4an19a15 Ln4a15 Ln19a15 0.477226
Kn4an19a16 Ln4a16 Ln19a16 0.477226
Kn4an20a1 Ln4a1 Ln20a1 0.469680
Kn4an20a2 Ln4a2 Ln20a2 0.469680
Kn4an20a3 Ln4a3 Ln20a3 0.469680
Kn4an20a4 Ln4a4 Ln20a4 0.469680
Kn4an20a5 Ln4a5 Ln20a5 0.469680
Kn4an20a6 Ln4a6 Ln20a6 0.469680
Kn4an20a7 Ln4a7 Ln20a7 0.469680
Kn4an20a8 Ln4a8 Ln20a8 0.469680
Kn4an20a9 Ln4a9 Ln20a9 0.469680
Kn4an20a10 Ln4a10 Ln20a10 0.469680
Kn4an20a11 Ln4a11 Ln20a11 0.469680
Kn4an20a12 Ln4a12 Ln20a12 0.469680
Kn4an20a13 Ln4a13 Ln20a13 0.469680
Kn4an20a14 Ln4a14 Ln20a14 0.469680
Kn4an20a15 Ln4a15 Ln20a15 0.469680
Kn4an20a16 Ln4a16 Ln20a16 0.469680
Kn4an21a1 Ln4a1 Ln21a1 0.463523
Kn4an21a2 Ln4a2 Ln21a2 0.463523
Kn4an21a3 Ln4a3 Ln21a3 0.463523
Kn4an21a4 Ln4a4 Ln21a4 0.463523
Kn4an21a5 Ln4a5 Ln21a5 0.463523
Kn4an21a6 Ln4a6 Ln21a6 0.463523
Kn4an21a7 Ln4a7 Ln21a7 0.463523
Kn4an21a8 Ln4a8 Ln21a8 0.463523
Kn4an21a9 Ln4a9 Ln21a9 0.463523
Kn4an21a10 Ln4a10 Ln21a10 0.463523
Kn4an21a11 Ln4a11 Ln21a11 0.463523
Kn4an21a12 Ln4a12 Ln21a12 0.463523
Kn4an21a13 Ln4a13 Ln21a13 0.463523
Kn4an21a14 Ln4a14 Ln21a14 0.463523
Kn4an21a15 Ln4a15 Ln21a15 0.463523
Kn4an21a16 Ln4a16 Ln21a16 0.463523
Kn4an22a1 Ln4a1 Ln22a1 0.458074
Kn4an22a2 Ln4a2 Ln22a2 0.458074
Kn4an22a3 Ln4a3 Ln22a3 0.458074
Kn4an22a4 Ln4a4 Ln22a4 0.458074
Kn4an22a5 Ln4a5 Ln22a5 0.458074
Kn4an22a6 Ln4a6 Ln22a6 0.458074
Kn4an22a7 Ln4a7 Ln22a7 0.458074
Kn4an22a8 Ln4a8 Ln22a8 0.458074
Kn4an22a9 Ln4a9 Ln22a9 0.458074
Kn4an22a10 Ln4a10 Ln22a10 0.458074
Kn4an22a11 Ln4a11 Ln22a11 0.458074
Kn4an22a12 Ln4a12 Ln22a12 0.458074
Kn4an22a13 Ln4a13 Ln22a13 0.458074
Kn4an22a14 Ln4a14 Ln22a14 0.458074
Kn4an22a15 Ln4a15 Ln22a15 0.458074
Kn4an22a16 Ln4a16 Ln22a16 0.458074
Kn4an23a1 Ln4a1 Ln23a1 0.453889
Kn4an23a2 Ln4a2 Ln23a2 0.453889
Kn4an23a3 Ln4a3 Ln23a3 0.453889
Kn4an23a4 Ln4a4 Ln23a4 0.453889
Kn4an23a5 Ln4a5 Ln23a5 0.453889
Kn4an23a6 Ln4a6 Ln23a6 0.453889
Kn4an23a7 Ln4a7 Ln23a7 0.453889
Kn4an23a8 Ln4a8 Ln23a8 0.453889
Kn4an23a9 Ln4a9 Ln23a9 0.453889
Kn4an23a10 Ln4a10 Ln23a10 0.453889
Kn4an23a11 Ln4a11 Ln23a11 0.453889
Kn4an23a12 Ln4a12 Ln23a12 0.453889
Kn4an23a13 Ln4a13 Ln23a13 0.453889
Kn4an23a14 Ln4a14 Ln23a14 0.453889
Kn4an23a15 Ln4a15 Ln23a15 0.453889
Kn4an23a16 Ln4a16 Ln23a16 0.453889
Kn4an24a1 Ln4a1 Ln24a1 0.450243
Kn4an24a2 Ln4a2 Ln24a2 0.450243
Kn4an24a3 Ln4a3 Ln24a3 0.450243
Kn4an24a4 Ln4a4 Ln24a4 0.450243
Kn4an24a5 Ln4a5 Ln24a5 0.450243
Kn4an24a6 Ln4a6 Ln24a6 0.450243
Kn4an24a7 Ln4a7 Ln24a7 0.450243
Kn4an24a8 Ln4a8 Ln24a8 0.450243
Kn4an24a9 Ln4a9 Ln24a9 0.450243
Kn4an24a10 Ln4a10 Ln24a10 0.450243
Kn4an24a11 Ln4a11 Ln24a11 0.450243
Kn4an24a12 Ln4a12 Ln24a12 0.450243
Kn4an24a13 Ln4a13 Ln24a13 0.450243
Kn4an24a14 Ln4a14 Ln24a14 0.450243
Kn4an24a15 Ln4a15 Ln24a15 0.450243
Kn4an24a16 Ln4a16 Ln24a16 0.450243
Kn4an25a1 Ln4a1 Ln25a1 0.447456
Kn4an25a2 Ln4a2 Ln25a2 0.447456
Kn4an25a3 Ln4a3 Ln25a3 0.447456
Kn4an25a4 Ln4a4 Ln25a4 0.447456
Kn4an25a5 Ln4a5 Ln25a5 0.447456
Kn4an25a6 Ln4a6 Ln25a6 0.447456
Kn4an25a7 Ln4a7 Ln25a7 0.447456
Kn4an25a8 Ln4a8 Ln25a8 0.447456
Kn4an25a9 Ln4a9 Ln25a9 0.447456
Kn4an25a10 Ln4a10 Ln25a10 0.447456
Kn4an25a11 Ln4a11 Ln25a11 0.447456
Kn4an25a12 Ln4a12 Ln25a12 0.447456
Kn4an25a13 Ln4a13 Ln25a13 0.447456
Kn4an25a14 Ln4a14 Ln25a14 0.447456
Kn4an25a15 Ln4a15 Ln25a15 0.447456
Kn4an25a16 Ln4a16 Ln25a16 0.447456
Kn4an26a1 Ln4a1 Ln26a1 0.445700
Kn4an26a2 Ln4a2 Ln26a2 0.445700
Kn4an26a3 Ln4a3 Ln26a3 0.445700
Kn4an26a4 Ln4a4 Ln26a4 0.445700
Kn4an26a5 Ln4a5 Ln26a5 0.445700
Kn4an26a6 Ln4a6 Ln26a6 0.445700
Kn4an26a7 Ln4a7 Ln26a7 0.445700
Kn4an26a8 Ln4a8 Ln26a8 0.445700
Kn4an26a9 Ln4a9 Ln26a9 0.445700
Kn4an26a10 Ln4a10 Ln26a10 0.445700
Kn4an26a11 Ln4a11 Ln26a11 0.445700
Kn4an26a12 Ln4a12 Ln26a12 0.445700
Kn4an26a13 Ln4a13 Ln26a13 0.445700
Kn4an26a14 Ln4a14 Ln26a14 0.445700
Kn4an26a15 Ln4a15 Ln26a15 0.445700
Kn4an26a16 Ln4a16 Ln26a16 0.445700
Kn4an27a1 Ln4a1 Ln27a1 0.444759
Kn4an27a2 Ln4a2 Ln27a2 0.444759
Kn4an27a3 Ln4a3 Ln27a3 0.444759
Kn4an27a4 Ln4a4 Ln27a4 0.444759
Kn4an27a5 Ln4a5 Ln27a5 0.444759
Kn4an27a6 Ln4a6 Ln27a6 0.444759
Kn4an27a7 Ln4a7 Ln27a7 0.444759
Kn4an27a8 Ln4a8 Ln27a8 0.444759
Kn4an27a9 Ln4a9 Ln27a9 0.444759
Kn4an27a10 Ln4a10 Ln27a10 0.444759
Kn4an27a11 Ln4a11 Ln27a11 0.444759
Kn4an27a12 Ln4a12 Ln27a12 0.444759
Kn4an27a13 Ln4a13 Ln27a13 0.444759
Kn4an27a14 Ln4a14 Ln27a14 0.444759
Kn4an27a15 Ln4a15 Ln27a15 0.444759
Kn4an27a16 Ln4a16 Ln27a16 0.444759
Kn4an28a1 Ln4a1 Ln28a1 0.443914
Kn4an28a2 Ln4a2 Ln28a2 0.443914
Kn4an28a3 Ln4a3 Ln28a3 0.443914
Kn4an28a4 Ln4a4 Ln28a4 0.443914
Kn4an28a5 Ln4a5 Ln28a5 0.443914
Kn4an28a6 Ln4a6 Ln28a6 0.443914
Kn4an28a7 Ln4a7 Ln28a7 0.443914
Kn4an28a8 Ln4a8 Ln28a8 0.443914
Kn4an28a9 Ln4a9 Ln28a9 0.443914
Kn4an28a10 Ln4a10 Ln28a10 0.443914
Kn4an28a11 Ln4a11 Ln28a11 0.443914
Kn4an28a12 Ln4a12 Ln28a12 0.443914
Kn4an28a13 Ln4a13 Ln28a13 0.443914
Kn4an28a14 Ln4a14 Ln28a14 0.443914
Kn4an28a15 Ln4a15 Ln28a15 0.443914
Kn4an28a16 Ln4a16 Ln28a16 0.443914
Kn4an29a1 Ln4a1 Ln29a1 0.443172
Kn4an29a2 Ln4a2 Ln29a2 0.443172
Kn4an29a3 Ln4a3 Ln29a3 0.443172
Kn4an29a4 Ln4a4 Ln29a4 0.443172
Kn4an29a5 Ln4a5 Ln29a5 0.443172
Kn4an29a6 Ln4a6 Ln29a6 0.443172
Kn4an29a7 Ln4a7 Ln29a7 0.443172
Kn4an29a8 Ln4a8 Ln29a8 0.443172
Kn4an29a9 Ln4a9 Ln29a9 0.443172
Kn4an29a10 Ln4a10 Ln29a10 0.443172
Kn4an29a11 Ln4a11 Ln29a11 0.443172
Kn4an29a12 Ln4a12 Ln29a12 0.443172
Kn4an29a13 Ln4a13 Ln29a13 0.443172
Kn4an29a14 Ln4a14 Ln29a14 0.443172
Kn4an29a15 Ln4a15 Ln29a15 0.443172
Kn4an29a16 Ln4a16 Ln29a16 0.443172
Kn4an30a1 Ln4a1 Ln30a1 0.442527
Kn4an30a2 Ln4a2 Ln30a2 0.442527
Kn4an30a3 Ln4a3 Ln30a3 0.442527
Kn4an30a4 Ln4a4 Ln30a4 0.442527
Kn4an30a5 Ln4a5 Ln30a5 0.442527
Kn4an30a6 Ln4a6 Ln30a6 0.442527
Kn4an30a7 Ln4a7 Ln30a7 0.442527
Kn4an30a8 Ln4a8 Ln30a8 0.442527
Kn4an30a9 Ln4a9 Ln30a9 0.442527
Kn4an30a10 Ln4a10 Ln30a10 0.442527
Kn4an30a11 Ln4a11 Ln30a11 0.442527
Kn4an30a12 Ln4a12 Ln30a12 0.442527
Kn4an30a13 Ln4a13 Ln30a13 0.442527
Kn4an30a14 Ln4a14 Ln30a14 0.442527
Kn4an30a15 Ln4a15 Ln30a15 0.442527
Kn4an30a16 Ln4a16 Ln30a16 0.442527
Kn4an31a1 Ln4a1 Ln31a1 0.442011
Kn4an31a2 Ln4a2 Ln31a2 0.442011
Kn4an31a3 Ln4a3 Ln31a3 0.442011
Kn4an31a4 Ln4a4 Ln31a4 0.442011
Kn4an31a5 Ln4a5 Ln31a5 0.442011
Kn4an31a6 Ln4a6 Ln31a6 0.442011
Kn4an31a7 Ln4a7 Ln31a7 0.442011
Kn4an31a8 Ln4a8 Ln31a8 0.442011
Kn4an31a9 Ln4a9 Ln31a9 0.442011
Kn4an31a10 Ln4a10 Ln31a10 0.442011
Kn4an31a11 Ln4a11 Ln31a11 0.442011
Kn4an31a12 Ln4a12 Ln31a12 0.442011
Kn4an31a13 Ln4a13 Ln31a13 0.442011
Kn4an31a14 Ln4a14 Ln31a14 0.442011
Kn4an31a15 Ln4a15 Ln31a15 0.442011
Kn4an31a16 Ln4a16 Ln31a16 0.442011
Kn4an32a1 Ln4a1 Ln32a1 0.441523
Kn4an32a2 Ln4a2 Ln32a2 0.441523
Kn4an32a3 Ln4a3 Ln32a3 0.441523
Kn4an32a4 Ln4a4 Ln32a4 0.441523
Kn4an32a5 Ln4a5 Ln32a5 0.441523
Kn4an32a6 Ln4a6 Ln32a6 0.441523
Kn4an32a7 Ln4a7 Ln32a7 0.441523
Kn4an32a8 Ln4a8 Ln32a8 0.441523
Kn4an32a9 Ln4a9 Ln32a9 0.441523
Kn4an32a10 Ln4a10 Ln32a10 0.441523
Kn4an32a11 Ln4a11 Ln32a11 0.441523
Kn4an32a12 Ln4a12 Ln32a12 0.441523
Kn4an32a13 Ln4a13 Ln32a13 0.441523
Kn4an32a14 Ln4a14 Ln32a14 0.441523
Kn4an32a15 Ln4a15 Ln32a15 0.441523
Kn4an32a16 Ln4a16 Ln32a16 0.441523
Kn4anva1 Ln4a1 Lnva1 0.441177
Kn4anva2 Ln4a2 Lnva2 0.441177
Kn4anva3 Ln4a3 Lnva3 0.441177
Kn4anva4 Ln4a4 Lnva4 0.441177
Kn4anva5 Ln4a5 Lnva5 0.441177
Kn4anva6 Ln4a6 Lnva6 0.441177
Kn4anva7 Ln4a7 Lnva7 0.441177
Kn4anva8 Ln4a8 Lnva8 0.441177
Kn4anva9 Ln4a9 Lnva9 0.441177
Kn4anva10 Ln4a10 Lnva10 0.441177
Kn4anva11 Ln4a11 Lnva11 0.441177
Kn4anva12 Ln4a12 Lnva12 0.441177
Kn4anva13 Ln4a13 Lnva13 0.441177
Kn4anva14 Ln4a14 Lnva14 0.441177
Kn4anva15 Ln4a15 Lnva15 0.441177
Kn4anva16 Ln4a16 Lnva16 0.441177
Kn5an6a1 Ln5a1 Ln6a1 0.805155
Kn5an6a2 Ln5a2 Ln6a2 0.805155
Kn5an6a3 Ln5a3 Ln6a3 0.805155
Kn5an6a4 Ln5a4 Ln6a4 0.805155
Kn5an6a5 Ln5a5 Ln6a5 0.805155
Kn5an6a6 Ln5a6 Ln6a6 0.805155
Kn5an6a7 Ln5a7 Ln6a7 0.805155
Kn5an6a8 Ln5a8 Ln6a8 0.805155
Kn5an6a9 Ln5a9 Ln6a9 0.805155
Kn5an6a10 Ln5a10 Ln6a10 0.805155
Kn5an6a11 Ln5a11 Ln6a11 0.805155
Kn5an6a12 Ln5a12 Ln6a12 0.805155
Kn5an6a13 Ln5a13 Ln6a13 0.805155
Kn5an6a14 Ln5a14 Ln6a14 0.805155
Kn5an6a15 Ln5a15 Ln6a15 0.805155
Kn5an6a16 Ln5a16 Ln6a16 0.805155
Kn5an7a1 Ln5a1 Ln7a1 0.723730
Kn5an7a2 Ln5a2 Ln7a2 0.723730
Kn5an7a3 Ln5a3 Ln7a3 0.723730
Kn5an7a4 Ln5a4 Ln7a4 0.723730
Kn5an7a5 Ln5a5 Ln7a5 0.723730
Kn5an7a6 Ln5a6 Ln7a6 0.723730
Kn5an7a7 Ln5a7 Ln7a7 0.723730
Kn5an7a8 Ln5a8 Ln7a8 0.723730
Kn5an7a9 Ln5a9 Ln7a9 0.723730
Kn5an7a10 Ln5a10 Ln7a10 0.723730
Kn5an7a11 Ln5a11 Ln7a11 0.723730
Kn5an7a12 Ln5a12 Ln7a12 0.723730
Kn5an7a13 Ln5a13 Ln7a13 0.723730
Kn5an7a14 Ln5a14 Ln7a14 0.723730
Kn5an7a15 Ln5a15 Ln7a15 0.723730
Kn5an7a16 Ln5a16 Ln7a16 0.723730
Kn5an8a1 Ln5a1 Ln8a1 0.675208
Kn5an8a2 Ln5a2 Ln8a2 0.675208
Kn5an8a3 Ln5a3 Ln8a3 0.675208
Kn5an8a4 Ln5a4 Ln8a4 0.675208
Kn5an8a5 Ln5a5 Ln8a5 0.675208
Kn5an8a6 Ln5a6 Ln8a6 0.675208
Kn5an8a7 Ln5a7 Ln8a7 0.675208
Kn5an8a8 Ln5a8 Ln8a8 0.675208
Kn5an8a9 Ln5a9 Ln8a9 0.675208
Kn5an8a10 Ln5a10 Ln8a10 0.675208
Kn5an8a11 Ln5a11 Ln8a11 0.675208
Kn5an8a12 Ln5a12 Ln8a12 0.675208
Kn5an8a13 Ln5a13 Ln8a13 0.675208
Kn5an8a14 Ln5a14 Ln8a14 0.675208
Kn5an8a15 Ln5a15 Ln8a15 0.675208
Kn5an8a16 Ln5a16 Ln8a16 0.675208
Kn5an9a1 Ln5a1 Ln9a1 0.640637
Kn5an9a2 Ln5a2 Ln9a2 0.640637
Kn5an9a3 Ln5a3 Ln9a3 0.640637
Kn5an9a4 Ln5a4 Ln9a4 0.640637
Kn5an9a5 Ln5a5 Ln9a5 0.640637
Kn5an9a6 Ln5a6 Ln9a6 0.640637
Kn5an9a7 Ln5a7 Ln9a7 0.640637
Kn5an9a8 Ln5a8 Ln9a8 0.640637
Kn5an9a9 Ln5a9 Ln9a9 0.640637
Kn5an9a10 Ln5a10 Ln9a10 0.640637
Kn5an9a11 Ln5a11 Ln9a11 0.640637
Kn5an9a12 Ln5a12 Ln9a12 0.640637
Kn5an9a13 Ln5a13 Ln9a13 0.640637
Kn5an9a14 Ln5a14 Ln9a14 0.640637
Kn5an9a15 Ln5a15 Ln9a15 0.640637
Kn5an9a16 Ln5a16 Ln9a16 0.640637
Kn5an10a1 Ln5a1 Ln10a1 0.613723
Kn5an10a2 Ln5a2 Ln10a2 0.613723
Kn5an10a3 Ln5a3 Ln10a3 0.613723
Kn5an10a4 Ln5a4 Ln10a4 0.613723
Kn5an10a5 Ln5a5 Ln10a5 0.613723
Kn5an10a6 Ln5a6 Ln10a6 0.613723
Kn5an10a7 Ln5a7 Ln10a7 0.613723
Kn5an10a8 Ln5a8 Ln10a8 0.613723
Kn5an10a9 Ln5a9 Ln10a9 0.613723
Kn5an10a10 Ln5a10 Ln10a10 0.613723
Kn5an10a11 Ln5a11 Ln10a11 0.613723
Kn5an10a12 Ln5a12 Ln10a12 0.613723
Kn5an10a13 Ln5a13 Ln10a13 0.613723
Kn5an10a14 Ln5a14 Ln10a14 0.613723
Kn5an10a15 Ln5a15 Ln10a15 0.613723
Kn5an10a16 Ln5a16 Ln10a16 0.613723
Kn5an11a1 Ln5a1 Ln11a1 0.591812
Kn5an11a2 Ln5a2 Ln11a2 0.591812
Kn5an11a3 Ln5a3 Ln11a3 0.591812
Kn5an11a4 Ln5a4 Ln11a4 0.591812
Kn5an11a5 Ln5a5 Ln11a5 0.591812
Kn5an11a6 Ln5a6 Ln11a6 0.591812
Kn5an11a7 Ln5a7 Ln11a7 0.591812
Kn5an11a8 Ln5a8 Ln11a8 0.591812
Kn5an11a9 Ln5a9 Ln11a9 0.591812
Kn5an11a10 Ln5a10 Ln11a10 0.591812
Kn5an11a11 Ln5a11 Ln11a11 0.591812
Kn5an11a12 Ln5a12 Ln11a12 0.591812
Kn5an11a13 Ln5a13 Ln11a13 0.591812
Kn5an11a14 Ln5a14 Ln11a14 0.591812
Kn5an11a15 Ln5a15 Ln11a15 0.591812
Kn5an11a16 Ln5a16 Ln11a16 0.591812
Kn5an12a1 Ln5a1 Ln12a1 0.573237
Kn5an12a2 Ln5a2 Ln12a2 0.573237
Kn5an12a3 Ln5a3 Ln12a3 0.573237
Kn5an12a4 Ln5a4 Ln12a4 0.573237
Kn5an12a5 Ln5a5 Ln12a5 0.573237
Kn5an12a6 Ln5a6 Ln12a6 0.573237
Kn5an12a7 Ln5a7 Ln12a7 0.573237
Kn5an12a8 Ln5a8 Ln12a8 0.573237
Kn5an12a9 Ln5a9 Ln12a9 0.573237
Kn5an12a10 Ln5a10 Ln12a10 0.573237
Kn5an12a11 Ln5a11 Ln12a11 0.573237
Kn5an12a12 Ln5a12 Ln12a12 0.573237
Kn5an12a13 Ln5a13 Ln12a13 0.573237
Kn5an12a14 Ln5a14 Ln12a14 0.573237
Kn5an12a15 Ln5a15 Ln12a15 0.573237
Kn5an12a16 Ln5a16 Ln12a16 0.573237
Kn5an13a1 Ln5a1 Ln13a1 0.557165
Kn5an13a2 Ln5a2 Ln13a2 0.557165
Kn5an13a3 Ln5a3 Ln13a3 0.557165
Kn5an13a4 Ln5a4 Ln13a4 0.557165
Kn5an13a5 Ln5a5 Ln13a5 0.557165
Kn5an13a6 Ln5a6 Ln13a6 0.557165
Kn5an13a7 Ln5a7 Ln13a7 0.557165
Kn5an13a8 Ln5a8 Ln13a8 0.557165
Kn5an13a9 Ln5a9 Ln13a9 0.557165
Kn5an13a10 Ln5a10 Ln13a10 0.557165
Kn5an13a11 Ln5a11 Ln13a11 0.557165
Kn5an13a12 Ln5a12 Ln13a12 0.557165
Kn5an13a13 Ln5a13 Ln13a13 0.557165
Kn5an13a14 Ln5a14 Ln13a14 0.557165
Kn5an13a15 Ln5a15 Ln13a15 0.557165
Kn5an13a16 Ln5a16 Ln13a16 0.557165
Kn5an14a1 Ln5a1 Ln14a1 0.542987
Kn5an14a2 Ln5a2 Ln14a2 0.542987
Kn5an14a3 Ln5a3 Ln14a3 0.542987
Kn5an14a4 Ln5a4 Ln14a4 0.542987
Kn5an14a5 Ln5a5 Ln14a5 0.542987
Kn5an14a6 Ln5a6 Ln14a6 0.542987
Kn5an14a7 Ln5a7 Ln14a7 0.542987
Kn5an14a8 Ln5a8 Ln14a8 0.542987
Kn5an14a9 Ln5a9 Ln14a9 0.542987
Kn5an14a10 Ln5a10 Ln14a10 0.542987
Kn5an14a11 Ln5a11 Ln14a11 0.542987
Kn5an14a12 Ln5a12 Ln14a12 0.542987
Kn5an14a13 Ln5a13 Ln14a13 0.542987
Kn5an14a14 Ln5a14 Ln14a14 0.542987
Kn5an14a15 Ln5a15 Ln14a15 0.542987
Kn5an14a16 Ln5a16 Ln14a16 0.542987
Kn5an15a1 Ln5a1 Ln15a1 0.529400
Kn5an15a2 Ln5a2 Ln15a2 0.529400
Kn5an15a3 Ln5a3 Ln15a3 0.529400
Kn5an15a4 Ln5a4 Ln15a4 0.529400
Kn5an15a5 Ln5a5 Ln15a5 0.529400
Kn5an15a6 Ln5a6 Ln15a6 0.529400
Kn5an15a7 Ln5a7 Ln15a7 0.529400
Kn5an15a8 Ln5a8 Ln15a8 0.529400
Kn5an15a9 Ln5a9 Ln15a9 0.529400
Kn5an15a10 Ln5a10 Ln15a10 0.529400
Kn5an15a11 Ln5a11 Ln15a11 0.529400
Kn5an15a12 Ln5a12 Ln15a12 0.529400
Kn5an15a13 Ln5a13 Ln15a13 0.529400
Kn5an15a14 Ln5a14 Ln15a14 0.529400
Kn5an15a15 Ln5a15 Ln15a15 0.529400
Kn5an15a16 Ln5a16 Ln15a16 0.529400
Kn5an16a1 Ln5a1 Ln16a1 0.516943
Kn5an16a2 Ln5a2 Ln16a2 0.516943
Kn5an16a3 Ln5a3 Ln16a3 0.516943
Kn5an16a4 Ln5a4 Ln16a4 0.516943
Kn5an16a5 Ln5a5 Ln16a5 0.516943
Kn5an16a6 Ln5a6 Ln16a6 0.516943
Kn5an16a7 Ln5a7 Ln16a7 0.516943
Kn5an16a8 Ln5a8 Ln16a8 0.516943
Kn5an16a9 Ln5a9 Ln16a9 0.516943
Kn5an16a10 Ln5a10 Ln16a10 0.516943
Kn5an16a11 Ln5a11 Ln16a11 0.516943
Kn5an16a12 Ln5a12 Ln16a12 0.516943
Kn5an16a13 Ln5a13 Ln16a13 0.516943
Kn5an16a14 Ln5a14 Ln16a14 0.516943
Kn5an16a15 Ln5a15 Ln16a15 0.516943
Kn5an16a16 Ln5a16 Ln16a16 0.516943
Kn5an17a1 Ln5a1 Ln17a1 0.505455
Kn5an17a2 Ln5a2 Ln17a2 0.505455
Kn5an17a3 Ln5a3 Ln17a3 0.505455
Kn5an17a4 Ln5a4 Ln17a4 0.505455
Kn5an17a5 Ln5a5 Ln17a5 0.505455
Kn5an17a6 Ln5a6 Ln17a6 0.505455
Kn5an17a7 Ln5a7 Ln17a7 0.505455
Kn5an17a8 Ln5a8 Ln17a8 0.505455
Kn5an17a9 Ln5a9 Ln17a9 0.505455
Kn5an17a10 Ln5a10 Ln17a10 0.505455
Kn5an17a11 Ln5a11 Ln17a11 0.505455
Kn5an17a12 Ln5a12 Ln17a12 0.505455
Kn5an17a13 Ln5a13 Ln17a13 0.505455
Kn5an17a14 Ln5a14 Ln17a14 0.505455
Kn5an17a15 Ln5a15 Ln17a15 0.505455
Kn5an17a16 Ln5a16 Ln17a16 0.505455
Kn5an18a1 Ln5a1 Ln18a1 0.494887
Kn5an18a2 Ln5a2 Ln18a2 0.494887
Kn5an18a3 Ln5a3 Ln18a3 0.494887
Kn5an18a4 Ln5a4 Ln18a4 0.494887
Kn5an18a5 Ln5a5 Ln18a5 0.494887
Kn5an18a6 Ln5a6 Ln18a6 0.494887
Kn5an18a7 Ln5a7 Ln18a7 0.494887
Kn5an18a8 Ln5a8 Ln18a8 0.494887
Kn5an18a9 Ln5a9 Ln18a9 0.494887
Kn5an18a10 Ln5a10 Ln18a10 0.494887
Kn5an18a11 Ln5a11 Ln18a11 0.494887
Kn5an18a12 Ln5a12 Ln18a12 0.494887
Kn5an18a13 Ln5a13 Ln18a13 0.494887
Kn5an18a14 Ln5a14 Ln18a14 0.494887
Kn5an18a15 Ln5a15 Ln18a15 0.494887
Kn5an18a16 Ln5a16 Ln18a16 0.494887
Kn5an19a1 Ln5a1 Ln19a1 0.485771
Kn5an19a2 Ln5a2 Ln19a2 0.485771
Kn5an19a3 Ln5a3 Ln19a3 0.485771
Kn5an19a4 Ln5a4 Ln19a4 0.485771
Kn5an19a5 Ln5a5 Ln19a5 0.485771
Kn5an19a6 Ln5a6 Ln19a6 0.485771
Kn5an19a7 Ln5a7 Ln19a7 0.485771
Kn5an19a8 Ln5a8 Ln19a8 0.485771
Kn5an19a9 Ln5a9 Ln19a9 0.485771
Kn5an19a10 Ln5a10 Ln19a10 0.485771
Kn5an19a11 Ln5a11 Ln19a11 0.485771
Kn5an19a12 Ln5a12 Ln19a12 0.485771
Kn5an19a13 Ln5a13 Ln19a13 0.485771
Kn5an19a14 Ln5a14 Ln19a14 0.485771
Kn5an19a15 Ln5a15 Ln19a15 0.485771
Kn5an19a16 Ln5a16 Ln19a16 0.485771
Kn5an20a1 Ln5a1 Ln20a1 0.477226
Kn5an20a2 Ln5a2 Ln20a2 0.477226
Kn5an20a3 Ln5a3 Ln20a3 0.477226
Kn5an20a4 Ln5a4 Ln20a4 0.477226
Kn5an20a5 Ln5a5 Ln20a5 0.477226
Kn5an20a6 Ln5a6 Ln20a6 0.477226
Kn5an20a7 Ln5a7 Ln20a7 0.477226
Kn5an20a8 Ln5a8 Ln20a8 0.477226
Kn5an20a9 Ln5a9 Ln20a9 0.477226
Kn5an20a10 Ln5a10 Ln20a10 0.477226
Kn5an20a11 Ln5a11 Ln20a11 0.477226
Kn5an20a12 Ln5a12 Ln20a12 0.477226
Kn5an20a13 Ln5a13 Ln20a13 0.477226
Kn5an20a14 Ln5a14 Ln20a14 0.477226
Kn5an20a15 Ln5a15 Ln20a15 0.477226
Kn5an20a16 Ln5a16 Ln20a16 0.477226
Kn5an21a1 Ln5a1 Ln21a1 0.469680
Kn5an21a2 Ln5a2 Ln21a2 0.469680
Kn5an21a3 Ln5a3 Ln21a3 0.469680
Kn5an21a4 Ln5a4 Ln21a4 0.469680
Kn5an21a5 Ln5a5 Ln21a5 0.469680
Kn5an21a6 Ln5a6 Ln21a6 0.469680
Kn5an21a7 Ln5a7 Ln21a7 0.469680
Kn5an21a8 Ln5a8 Ln21a8 0.469680
Kn5an21a9 Ln5a9 Ln21a9 0.469680
Kn5an21a10 Ln5a10 Ln21a10 0.469680
Kn5an21a11 Ln5a11 Ln21a11 0.469680
Kn5an21a12 Ln5a12 Ln21a12 0.469680
Kn5an21a13 Ln5a13 Ln21a13 0.469680
Kn5an21a14 Ln5a14 Ln21a14 0.469680
Kn5an21a15 Ln5a15 Ln21a15 0.469680
Kn5an21a16 Ln5a16 Ln21a16 0.469680
Kn5an22a1 Ln5a1 Ln22a1 0.463523
Kn5an22a2 Ln5a2 Ln22a2 0.463523
Kn5an22a3 Ln5a3 Ln22a3 0.463523
Kn5an22a4 Ln5a4 Ln22a4 0.463523
Kn5an22a5 Ln5a5 Ln22a5 0.463523
Kn5an22a6 Ln5a6 Ln22a6 0.463523
Kn5an22a7 Ln5a7 Ln22a7 0.463523
Kn5an22a8 Ln5a8 Ln22a8 0.463523
Kn5an22a9 Ln5a9 Ln22a9 0.463523
Kn5an22a10 Ln5a10 Ln22a10 0.463523
Kn5an22a11 Ln5a11 Ln22a11 0.463523
Kn5an22a12 Ln5a12 Ln22a12 0.463523
Kn5an22a13 Ln5a13 Ln22a13 0.463523
Kn5an22a14 Ln5a14 Ln22a14 0.463523
Kn5an22a15 Ln5a15 Ln22a15 0.463523
Kn5an22a16 Ln5a16 Ln22a16 0.463523
Kn5an23a1 Ln5a1 Ln23a1 0.458074
Kn5an23a2 Ln5a2 Ln23a2 0.458074
Kn5an23a3 Ln5a3 Ln23a3 0.458074
Kn5an23a4 Ln5a4 Ln23a4 0.458074
Kn5an23a5 Ln5a5 Ln23a5 0.458074
Kn5an23a6 Ln5a6 Ln23a6 0.458074
Kn5an23a7 Ln5a7 Ln23a7 0.458074
Kn5an23a8 Ln5a8 Ln23a8 0.458074
Kn5an23a9 Ln5a9 Ln23a9 0.458074
Kn5an23a10 Ln5a10 Ln23a10 0.458074
Kn5an23a11 Ln5a11 Ln23a11 0.458074
Kn5an23a12 Ln5a12 Ln23a12 0.458074
Kn5an23a13 Ln5a13 Ln23a13 0.458074
Kn5an23a14 Ln5a14 Ln23a14 0.458074
Kn5an23a15 Ln5a15 Ln23a15 0.458074
Kn5an23a16 Ln5a16 Ln23a16 0.458074
Kn5an24a1 Ln5a1 Ln24a1 0.453889
Kn5an24a2 Ln5a2 Ln24a2 0.453889
Kn5an24a3 Ln5a3 Ln24a3 0.453889
Kn5an24a4 Ln5a4 Ln24a4 0.453889
Kn5an24a5 Ln5a5 Ln24a5 0.453889
Kn5an24a6 Ln5a6 Ln24a6 0.453889
Kn5an24a7 Ln5a7 Ln24a7 0.453889
Kn5an24a8 Ln5a8 Ln24a8 0.453889
Kn5an24a9 Ln5a9 Ln24a9 0.453889
Kn5an24a10 Ln5a10 Ln24a10 0.453889
Kn5an24a11 Ln5a11 Ln24a11 0.453889
Kn5an24a12 Ln5a12 Ln24a12 0.453889
Kn5an24a13 Ln5a13 Ln24a13 0.453889
Kn5an24a14 Ln5a14 Ln24a14 0.453889
Kn5an24a15 Ln5a15 Ln24a15 0.453889
Kn5an24a16 Ln5a16 Ln24a16 0.453889
Kn5an25a1 Ln5a1 Ln25a1 0.450243
Kn5an25a2 Ln5a2 Ln25a2 0.450243
Kn5an25a3 Ln5a3 Ln25a3 0.450243
Kn5an25a4 Ln5a4 Ln25a4 0.450243
Kn5an25a5 Ln5a5 Ln25a5 0.450243
Kn5an25a6 Ln5a6 Ln25a6 0.450243
Kn5an25a7 Ln5a7 Ln25a7 0.450243
Kn5an25a8 Ln5a8 Ln25a8 0.450243
Kn5an25a9 Ln5a9 Ln25a9 0.450243
Kn5an25a10 Ln5a10 Ln25a10 0.450243
Kn5an25a11 Ln5a11 Ln25a11 0.450243
Kn5an25a12 Ln5a12 Ln25a12 0.450243
Kn5an25a13 Ln5a13 Ln25a13 0.450243
Kn5an25a14 Ln5a14 Ln25a14 0.450243
Kn5an25a15 Ln5a15 Ln25a15 0.450243
Kn5an25a16 Ln5a16 Ln25a16 0.450243
Kn5an26a1 Ln5a1 Ln26a1 0.447456
Kn5an26a2 Ln5a2 Ln26a2 0.447456
Kn5an26a3 Ln5a3 Ln26a3 0.447456
Kn5an26a4 Ln5a4 Ln26a4 0.447456
Kn5an26a5 Ln5a5 Ln26a5 0.447456
Kn5an26a6 Ln5a6 Ln26a6 0.447456
Kn5an26a7 Ln5a7 Ln26a7 0.447456
Kn5an26a8 Ln5a8 Ln26a8 0.447456
Kn5an26a9 Ln5a9 Ln26a9 0.447456
Kn5an26a10 Ln5a10 Ln26a10 0.447456
Kn5an26a11 Ln5a11 Ln26a11 0.447456
Kn5an26a12 Ln5a12 Ln26a12 0.447456
Kn5an26a13 Ln5a13 Ln26a13 0.447456
Kn5an26a14 Ln5a14 Ln26a14 0.447456
Kn5an26a15 Ln5a15 Ln26a15 0.447456
Kn5an26a16 Ln5a16 Ln26a16 0.447456
Kn5an27a1 Ln5a1 Ln27a1 0.445700
Kn5an27a2 Ln5a2 Ln27a2 0.445700
Kn5an27a3 Ln5a3 Ln27a3 0.445700
Kn5an27a4 Ln5a4 Ln27a4 0.445700
Kn5an27a5 Ln5a5 Ln27a5 0.445700
Kn5an27a6 Ln5a6 Ln27a6 0.445700
Kn5an27a7 Ln5a7 Ln27a7 0.445700
Kn5an27a8 Ln5a8 Ln27a8 0.445700
Kn5an27a9 Ln5a9 Ln27a9 0.445700
Kn5an27a10 Ln5a10 Ln27a10 0.445700
Kn5an27a11 Ln5a11 Ln27a11 0.445700
Kn5an27a12 Ln5a12 Ln27a12 0.445700
Kn5an27a13 Ln5a13 Ln27a13 0.445700
Kn5an27a14 Ln5a14 Ln27a14 0.445700
Kn5an27a15 Ln5a15 Ln27a15 0.445700
Kn5an27a16 Ln5a16 Ln27a16 0.445700
Kn5an28a1 Ln5a1 Ln28a1 0.444759
Kn5an28a2 Ln5a2 Ln28a2 0.444759
Kn5an28a3 Ln5a3 Ln28a3 0.444759
Kn5an28a4 Ln5a4 Ln28a4 0.444759
Kn5an28a5 Ln5a5 Ln28a5 0.444759
Kn5an28a6 Ln5a6 Ln28a6 0.444759
Kn5an28a7 Ln5a7 Ln28a7 0.444759
Kn5an28a8 Ln5a8 Ln28a8 0.444759
Kn5an28a9 Ln5a9 Ln28a9 0.444759
Kn5an28a10 Ln5a10 Ln28a10 0.444759
Kn5an28a11 Ln5a11 Ln28a11 0.444759
Kn5an28a12 Ln5a12 Ln28a12 0.444759
Kn5an28a13 Ln5a13 Ln28a13 0.444759
Kn5an28a14 Ln5a14 Ln28a14 0.444759
Kn5an28a15 Ln5a15 Ln28a15 0.444759
Kn5an28a16 Ln5a16 Ln28a16 0.444759
Kn5an29a1 Ln5a1 Ln29a1 0.443914
Kn5an29a2 Ln5a2 Ln29a2 0.443914
Kn5an29a3 Ln5a3 Ln29a3 0.443914
Kn5an29a4 Ln5a4 Ln29a4 0.443914
Kn5an29a5 Ln5a5 Ln29a5 0.443914
Kn5an29a6 Ln5a6 Ln29a6 0.443914
Kn5an29a7 Ln5a7 Ln29a7 0.443914
Kn5an29a8 Ln5a8 Ln29a8 0.443914
Kn5an29a9 Ln5a9 Ln29a9 0.443914
Kn5an29a10 Ln5a10 Ln29a10 0.443914
Kn5an29a11 Ln5a11 Ln29a11 0.443914
Kn5an29a12 Ln5a12 Ln29a12 0.443914
Kn5an29a13 Ln5a13 Ln29a13 0.443914
Kn5an29a14 Ln5a14 Ln29a14 0.443914
Kn5an29a15 Ln5a15 Ln29a15 0.443914
Kn5an29a16 Ln5a16 Ln29a16 0.443914
Kn5an30a1 Ln5a1 Ln30a1 0.443172
Kn5an30a2 Ln5a2 Ln30a2 0.443172
Kn5an30a3 Ln5a3 Ln30a3 0.443172
Kn5an30a4 Ln5a4 Ln30a4 0.443172
Kn5an30a5 Ln5a5 Ln30a5 0.443172
Kn5an30a6 Ln5a6 Ln30a6 0.443172
Kn5an30a7 Ln5a7 Ln30a7 0.443172
Kn5an30a8 Ln5a8 Ln30a8 0.443172
Kn5an30a9 Ln5a9 Ln30a9 0.443172
Kn5an30a10 Ln5a10 Ln30a10 0.443172
Kn5an30a11 Ln5a11 Ln30a11 0.443172
Kn5an30a12 Ln5a12 Ln30a12 0.443172
Kn5an30a13 Ln5a13 Ln30a13 0.443172
Kn5an30a14 Ln5a14 Ln30a14 0.443172
Kn5an30a15 Ln5a15 Ln30a15 0.443172
Kn5an30a16 Ln5a16 Ln30a16 0.443172
Kn5an31a1 Ln5a1 Ln31a1 0.442527
Kn5an31a2 Ln5a2 Ln31a2 0.442527
Kn5an31a3 Ln5a3 Ln31a3 0.442527
Kn5an31a4 Ln5a4 Ln31a4 0.442527
Kn5an31a5 Ln5a5 Ln31a5 0.442527
Kn5an31a6 Ln5a6 Ln31a6 0.442527
Kn5an31a7 Ln5a7 Ln31a7 0.442527
Kn5an31a8 Ln5a8 Ln31a8 0.442527
Kn5an31a9 Ln5a9 Ln31a9 0.442527
Kn5an31a10 Ln5a10 Ln31a10 0.442527
Kn5an31a11 Ln5a11 Ln31a11 0.442527
Kn5an31a12 Ln5a12 Ln31a12 0.442527
Kn5an31a13 Ln5a13 Ln31a13 0.442527
Kn5an31a14 Ln5a14 Ln31a14 0.442527
Kn5an31a15 Ln5a15 Ln31a15 0.442527
Kn5an31a16 Ln5a16 Ln31a16 0.442527
Kn5an32a1 Ln5a1 Ln32a1 0.442011
Kn5an32a2 Ln5a2 Ln32a2 0.442011
Kn5an32a3 Ln5a3 Ln32a3 0.442011
Kn5an32a4 Ln5a4 Ln32a4 0.442011
Kn5an32a5 Ln5a5 Ln32a5 0.442011
Kn5an32a6 Ln5a6 Ln32a6 0.442011
Kn5an32a7 Ln5a7 Ln32a7 0.442011
Kn5an32a8 Ln5a8 Ln32a8 0.442011
Kn5an32a9 Ln5a9 Ln32a9 0.442011
Kn5an32a10 Ln5a10 Ln32a10 0.442011
Kn5an32a11 Ln5a11 Ln32a11 0.442011
Kn5an32a12 Ln5a12 Ln32a12 0.442011
Kn5an32a13 Ln5a13 Ln32a13 0.442011
Kn5an32a14 Ln5a14 Ln32a14 0.442011
Kn5an32a15 Ln5a15 Ln32a15 0.442011
Kn5an32a16 Ln5a16 Ln32a16 0.442011
Kn5anva1 Ln5a1 Lnva1 0.441523
Kn5anva2 Ln5a2 Lnva2 0.441523
Kn5anva3 Ln5a3 Lnva3 0.441523
Kn5anva4 Ln5a4 Lnva4 0.441523
Kn5anva5 Ln5a5 Lnva5 0.441523
Kn5anva6 Ln5a6 Lnva6 0.441523
Kn5anva7 Ln5a7 Lnva7 0.441523
Kn5anva8 Ln5a8 Lnva8 0.441523
Kn5anva9 Ln5a9 Lnva9 0.441523
Kn5anva10 Ln5a10 Lnva10 0.441523
Kn5anva11 Ln5a11 Lnva11 0.441523
Kn5anva12 Ln5a12 Lnva12 0.441523
Kn5anva13 Ln5a13 Lnva13 0.441523
Kn5anva14 Ln5a14 Lnva14 0.441523
Kn5anva15 Ln5a15 Lnva15 0.441523
Kn5anva16 Ln5a16 Lnva16 0.441523
Kn6an7a1 Ln6a1 Ln7a1 0.805155
Kn6an7a2 Ln6a2 Ln7a2 0.805155
Kn6an7a3 Ln6a3 Ln7a3 0.805155
Kn6an7a4 Ln6a4 Ln7a4 0.805155
Kn6an7a5 Ln6a5 Ln7a5 0.805155
Kn6an7a6 Ln6a6 Ln7a6 0.805155
Kn6an7a7 Ln6a7 Ln7a7 0.805155
Kn6an7a8 Ln6a8 Ln7a8 0.805155
Kn6an7a9 Ln6a9 Ln7a9 0.805155
Kn6an7a10 Ln6a10 Ln7a10 0.805155
Kn6an7a11 Ln6a11 Ln7a11 0.805155
Kn6an7a12 Ln6a12 Ln7a12 0.805155
Kn6an7a13 Ln6a13 Ln7a13 0.805155
Kn6an7a14 Ln6a14 Ln7a14 0.805155
Kn6an7a15 Ln6a15 Ln7a15 0.805155
Kn6an7a16 Ln6a16 Ln7a16 0.805155
Kn6an8a1 Ln6a1 Ln8a1 0.723730
Kn6an8a2 Ln6a2 Ln8a2 0.723730
Kn6an8a3 Ln6a3 Ln8a3 0.723730
Kn6an8a4 Ln6a4 Ln8a4 0.723730
Kn6an8a5 Ln6a5 Ln8a5 0.723730
Kn6an8a6 Ln6a6 Ln8a6 0.723730
Kn6an8a7 Ln6a7 Ln8a7 0.723730
Kn6an8a8 Ln6a8 Ln8a8 0.723730
Kn6an8a9 Ln6a9 Ln8a9 0.723730
Kn6an8a10 Ln6a10 Ln8a10 0.723730
Kn6an8a11 Ln6a11 Ln8a11 0.723730
Kn6an8a12 Ln6a12 Ln8a12 0.723730
Kn6an8a13 Ln6a13 Ln8a13 0.723730
Kn6an8a14 Ln6a14 Ln8a14 0.723730
Kn6an8a15 Ln6a15 Ln8a15 0.723730
Kn6an8a16 Ln6a16 Ln8a16 0.723730
Kn6an9a1 Ln6a1 Ln9a1 0.675208
Kn6an9a2 Ln6a2 Ln9a2 0.675208
Kn6an9a3 Ln6a3 Ln9a3 0.675208
Kn6an9a4 Ln6a4 Ln9a4 0.675208
Kn6an9a5 Ln6a5 Ln9a5 0.675208
Kn6an9a6 Ln6a6 Ln9a6 0.675208
Kn6an9a7 Ln6a7 Ln9a7 0.675208
Kn6an9a8 Ln6a8 Ln9a8 0.675208
Kn6an9a9 Ln6a9 Ln9a9 0.675208
Kn6an9a10 Ln6a10 Ln9a10 0.675208
Kn6an9a11 Ln6a11 Ln9a11 0.675208
Kn6an9a12 Ln6a12 Ln9a12 0.675208
Kn6an9a13 Ln6a13 Ln9a13 0.675208
Kn6an9a14 Ln6a14 Ln9a14 0.675208
Kn6an9a15 Ln6a15 Ln9a15 0.675208
Kn6an9a16 Ln6a16 Ln9a16 0.675208
Kn6an10a1 Ln6a1 Ln10a1 0.640637
Kn6an10a2 Ln6a2 Ln10a2 0.640637
Kn6an10a3 Ln6a3 Ln10a3 0.640637
Kn6an10a4 Ln6a4 Ln10a4 0.640637
Kn6an10a5 Ln6a5 Ln10a5 0.640637
Kn6an10a6 Ln6a6 Ln10a6 0.640637
Kn6an10a7 Ln6a7 Ln10a7 0.640637
Kn6an10a8 Ln6a8 Ln10a8 0.640637
Kn6an10a9 Ln6a9 Ln10a9 0.640637
Kn6an10a10 Ln6a10 Ln10a10 0.640637
Kn6an10a11 Ln6a11 Ln10a11 0.640637
Kn6an10a12 Ln6a12 Ln10a12 0.640637
Kn6an10a13 Ln6a13 Ln10a13 0.640637
Kn6an10a14 Ln6a14 Ln10a14 0.640637
Kn6an10a15 Ln6a15 Ln10a15 0.640637
Kn6an10a16 Ln6a16 Ln10a16 0.640637
Kn6an11a1 Ln6a1 Ln11a1 0.613723
Kn6an11a2 Ln6a2 Ln11a2 0.613723
Kn6an11a3 Ln6a3 Ln11a3 0.613723
Kn6an11a4 Ln6a4 Ln11a4 0.613723
Kn6an11a5 Ln6a5 Ln11a5 0.613723
Kn6an11a6 Ln6a6 Ln11a6 0.613723
Kn6an11a7 Ln6a7 Ln11a7 0.613723
Kn6an11a8 Ln6a8 Ln11a8 0.613723
Kn6an11a9 Ln6a9 Ln11a9 0.613723
Kn6an11a10 Ln6a10 Ln11a10 0.613723
Kn6an11a11 Ln6a11 Ln11a11 0.613723
Kn6an11a12 Ln6a12 Ln11a12 0.613723
Kn6an11a13 Ln6a13 Ln11a13 0.613723
Kn6an11a14 Ln6a14 Ln11a14 0.613723
Kn6an11a15 Ln6a15 Ln11a15 0.613723
Kn6an11a16 Ln6a16 Ln11a16 0.613723
Kn6an12a1 Ln6a1 Ln12a1 0.591812
Kn6an12a2 Ln6a2 Ln12a2 0.591812
Kn6an12a3 Ln6a3 Ln12a3 0.591812
Kn6an12a4 Ln6a4 Ln12a4 0.591812
Kn6an12a5 Ln6a5 Ln12a5 0.591812
Kn6an12a6 Ln6a6 Ln12a6 0.591812
Kn6an12a7 Ln6a7 Ln12a7 0.591812
Kn6an12a8 Ln6a8 Ln12a8 0.591812
Kn6an12a9 Ln6a9 Ln12a9 0.591812
Kn6an12a10 Ln6a10 Ln12a10 0.591812
Kn6an12a11 Ln6a11 Ln12a11 0.591812
Kn6an12a12 Ln6a12 Ln12a12 0.591812
Kn6an12a13 Ln6a13 Ln12a13 0.591812
Kn6an12a14 Ln6a14 Ln12a14 0.591812
Kn6an12a15 Ln6a15 Ln12a15 0.591812
Kn6an12a16 Ln6a16 Ln12a16 0.591812
Kn6an13a1 Ln6a1 Ln13a1 0.573237
Kn6an13a2 Ln6a2 Ln13a2 0.573237
Kn6an13a3 Ln6a3 Ln13a3 0.573237
Kn6an13a4 Ln6a4 Ln13a4 0.573237
Kn6an13a5 Ln6a5 Ln13a5 0.573237
Kn6an13a6 Ln6a6 Ln13a6 0.573237
Kn6an13a7 Ln6a7 Ln13a7 0.573237
Kn6an13a8 Ln6a8 Ln13a8 0.573237
Kn6an13a9 Ln6a9 Ln13a9 0.573237
Kn6an13a10 Ln6a10 Ln13a10 0.573237
Kn6an13a11 Ln6a11 Ln13a11 0.573237
Kn6an13a12 Ln6a12 Ln13a12 0.573237
Kn6an13a13 Ln6a13 Ln13a13 0.573237
Kn6an13a14 Ln6a14 Ln13a14 0.573237
Kn6an13a15 Ln6a15 Ln13a15 0.573237
Kn6an13a16 Ln6a16 Ln13a16 0.573237
Kn6an14a1 Ln6a1 Ln14a1 0.557165
Kn6an14a2 Ln6a2 Ln14a2 0.557165
Kn6an14a3 Ln6a3 Ln14a3 0.557165
Kn6an14a4 Ln6a4 Ln14a4 0.557165
Kn6an14a5 Ln6a5 Ln14a5 0.557165
Kn6an14a6 Ln6a6 Ln14a6 0.557165
Kn6an14a7 Ln6a7 Ln14a7 0.557165
Kn6an14a8 Ln6a8 Ln14a8 0.557165
Kn6an14a9 Ln6a9 Ln14a9 0.557165
Kn6an14a10 Ln6a10 Ln14a10 0.557165
Kn6an14a11 Ln6a11 Ln14a11 0.557165
Kn6an14a12 Ln6a12 Ln14a12 0.557165
Kn6an14a13 Ln6a13 Ln14a13 0.557165
Kn6an14a14 Ln6a14 Ln14a14 0.557165
Kn6an14a15 Ln6a15 Ln14a15 0.557165
Kn6an14a16 Ln6a16 Ln14a16 0.557165
Kn6an15a1 Ln6a1 Ln15a1 0.542987
Kn6an15a2 Ln6a2 Ln15a2 0.542987
Kn6an15a3 Ln6a3 Ln15a3 0.542987
Kn6an15a4 Ln6a4 Ln15a4 0.542987
Kn6an15a5 Ln6a5 Ln15a5 0.542987
Kn6an15a6 Ln6a6 Ln15a6 0.542987
Kn6an15a7 Ln6a7 Ln15a7 0.542987
Kn6an15a8 Ln6a8 Ln15a8 0.542987
Kn6an15a9 Ln6a9 Ln15a9 0.542987
Kn6an15a10 Ln6a10 Ln15a10 0.542987
Kn6an15a11 Ln6a11 Ln15a11 0.542987
Kn6an15a12 Ln6a12 Ln15a12 0.542987
Kn6an15a13 Ln6a13 Ln15a13 0.542987
Kn6an15a14 Ln6a14 Ln15a14 0.542987
Kn6an15a15 Ln6a15 Ln15a15 0.542987
Kn6an15a16 Ln6a16 Ln15a16 0.542987
Kn6an16a1 Ln6a1 Ln16a1 0.529400
Kn6an16a2 Ln6a2 Ln16a2 0.529400
Kn6an16a3 Ln6a3 Ln16a3 0.529400
Kn6an16a4 Ln6a4 Ln16a4 0.529400
Kn6an16a5 Ln6a5 Ln16a5 0.529400
Kn6an16a6 Ln6a6 Ln16a6 0.529400
Kn6an16a7 Ln6a7 Ln16a7 0.529400
Kn6an16a8 Ln6a8 Ln16a8 0.529400
Kn6an16a9 Ln6a9 Ln16a9 0.529400
Kn6an16a10 Ln6a10 Ln16a10 0.529400
Kn6an16a11 Ln6a11 Ln16a11 0.529400
Kn6an16a12 Ln6a12 Ln16a12 0.529400
Kn6an16a13 Ln6a13 Ln16a13 0.529400
Kn6an16a14 Ln6a14 Ln16a14 0.529400
Kn6an16a15 Ln6a15 Ln16a15 0.529400
Kn6an16a16 Ln6a16 Ln16a16 0.529400
Kn6an17a1 Ln6a1 Ln17a1 0.516943
Kn6an17a2 Ln6a2 Ln17a2 0.516943
Kn6an17a3 Ln6a3 Ln17a3 0.516943
Kn6an17a4 Ln6a4 Ln17a4 0.516943
Kn6an17a5 Ln6a5 Ln17a5 0.516943
Kn6an17a6 Ln6a6 Ln17a6 0.516943
Kn6an17a7 Ln6a7 Ln17a7 0.516943
Kn6an17a8 Ln6a8 Ln17a8 0.516943
Kn6an17a9 Ln6a9 Ln17a9 0.516943
Kn6an17a10 Ln6a10 Ln17a10 0.516943
Kn6an17a11 Ln6a11 Ln17a11 0.516943
Kn6an17a12 Ln6a12 Ln17a12 0.516943
Kn6an17a13 Ln6a13 Ln17a13 0.516943
Kn6an17a14 Ln6a14 Ln17a14 0.516943
Kn6an17a15 Ln6a15 Ln17a15 0.516943
Kn6an17a16 Ln6a16 Ln17a16 0.516943
Kn6an18a1 Ln6a1 Ln18a1 0.505455
Kn6an18a2 Ln6a2 Ln18a2 0.505455
Kn6an18a3 Ln6a3 Ln18a3 0.505455
Kn6an18a4 Ln6a4 Ln18a4 0.505455
Kn6an18a5 Ln6a5 Ln18a5 0.505455
Kn6an18a6 Ln6a6 Ln18a6 0.505455
Kn6an18a7 Ln6a7 Ln18a7 0.505455
Kn6an18a8 Ln6a8 Ln18a8 0.505455
Kn6an18a9 Ln6a9 Ln18a9 0.505455
Kn6an18a10 Ln6a10 Ln18a10 0.505455
Kn6an18a11 Ln6a11 Ln18a11 0.505455
Kn6an18a12 Ln6a12 Ln18a12 0.505455
Kn6an18a13 Ln6a13 Ln18a13 0.505455
Kn6an18a14 Ln6a14 Ln18a14 0.505455
Kn6an18a15 Ln6a15 Ln18a15 0.505455
Kn6an18a16 Ln6a16 Ln18a16 0.505455
Kn6an19a1 Ln6a1 Ln19a1 0.494887
Kn6an19a2 Ln6a2 Ln19a2 0.494887
Kn6an19a3 Ln6a3 Ln19a3 0.494887
Kn6an19a4 Ln6a4 Ln19a4 0.494887
Kn6an19a5 Ln6a5 Ln19a5 0.494887
Kn6an19a6 Ln6a6 Ln19a6 0.494887
Kn6an19a7 Ln6a7 Ln19a7 0.494887
Kn6an19a8 Ln6a8 Ln19a8 0.494887
Kn6an19a9 Ln6a9 Ln19a9 0.494887
Kn6an19a10 Ln6a10 Ln19a10 0.494887
Kn6an19a11 Ln6a11 Ln19a11 0.494887
Kn6an19a12 Ln6a12 Ln19a12 0.494887
Kn6an19a13 Ln6a13 Ln19a13 0.494887
Kn6an19a14 Ln6a14 Ln19a14 0.494887
Kn6an19a15 Ln6a15 Ln19a15 0.494887
Kn6an19a16 Ln6a16 Ln19a16 0.494887
Kn6an20a1 Ln6a1 Ln20a1 0.485771
Kn6an20a2 Ln6a2 Ln20a2 0.485771
Kn6an20a3 Ln6a3 Ln20a3 0.485771
Kn6an20a4 Ln6a4 Ln20a4 0.485771
Kn6an20a5 Ln6a5 Ln20a5 0.485771
Kn6an20a6 Ln6a6 Ln20a6 0.485771
Kn6an20a7 Ln6a7 Ln20a7 0.485771
Kn6an20a8 Ln6a8 Ln20a8 0.485771
Kn6an20a9 Ln6a9 Ln20a9 0.485771
Kn6an20a10 Ln6a10 Ln20a10 0.485771
Kn6an20a11 Ln6a11 Ln20a11 0.485771
Kn6an20a12 Ln6a12 Ln20a12 0.485771
Kn6an20a13 Ln6a13 Ln20a13 0.485771
Kn6an20a14 Ln6a14 Ln20a14 0.485771
Kn6an20a15 Ln6a15 Ln20a15 0.485771
Kn6an20a16 Ln6a16 Ln20a16 0.485771
Kn6an21a1 Ln6a1 Ln21a1 0.477226
Kn6an21a2 Ln6a2 Ln21a2 0.477226
Kn6an21a3 Ln6a3 Ln21a3 0.477226
Kn6an21a4 Ln6a4 Ln21a4 0.477226
Kn6an21a5 Ln6a5 Ln21a5 0.477226
Kn6an21a6 Ln6a6 Ln21a6 0.477226
Kn6an21a7 Ln6a7 Ln21a7 0.477226
Kn6an21a8 Ln6a8 Ln21a8 0.477226
Kn6an21a9 Ln6a9 Ln21a9 0.477226
Kn6an21a10 Ln6a10 Ln21a10 0.477226
Kn6an21a11 Ln6a11 Ln21a11 0.477226
Kn6an21a12 Ln6a12 Ln21a12 0.477226
Kn6an21a13 Ln6a13 Ln21a13 0.477226
Kn6an21a14 Ln6a14 Ln21a14 0.477226
Kn6an21a15 Ln6a15 Ln21a15 0.477226
Kn6an21a16 Ln6a16 Ln21a16 0.477226
Kn6an22a1 Ln6a1 Ln22a1 0.469680
Kn6an22a2 Ln6a2 Ln22a2 0.469680
Kn6an22a3 Ln6a3 Ln22a3 0.469680
Kn6an22a4 Ln6a4 Ln22a4 0.469680
Kn6an22a5 Ln6a5 Ln22a5 0.469680
Kn6an22a6 Ln6a6 Ln22a6 0.469680
Kn6an22a7 Ln6a7 Ln22a7 0.469680
Kn6an22a8 Ln6a8 Ln22a8 0.469680
Kn6an22a9 Ln6a9 Ln22a9 0.469680
Kn6an22a10 Ln6a10 Ln22a10 0.469680
Kn6an22a11 Ln6a11 Ln22a11 0.469680
Kn6an22a12 Ln6a12 Ln22a12 0.469680
Kn6an22a13 Ln6a13 Ln22a13 0.469680
Kn6an22a14 Ln6a14 Ln22a14 0.469680
Kn6an22a15 Ln6a15 Ln22a15 0.469680
Kn6an22a16 Ln6a16 Ln22a16 0.469680
Kn6an23a1 Ln6a1 Ln23a1 0.463523
Kn6an23a2 Ln6a2 Ln23a2 0.463523
Kn6an23a3 Ln6a3 Ln23a3 0.463523
Kn6an23a4 Ln6a4 Ln23a4 0.463523
Kn6an23a5 Ln6a5 Ln23a5 0.463523
Kn6an23a6 Ln6a6 Ln23a6 0.463523
Kn6an23a7 Ln6a7 Ln23a7 0.463523
Kn6an23a8 Ln6a8 Ln23a8 0.463523
Kn6an23a9 Ln6a9 Ln23a9 0.463523
Kn6an23a10 Ln6a10 Ln23a10 0.463523
Kn6an23a11 Ln6a11 Ln23a11 0.463523
Kn6an23a12 Ln6a12 Ln23a12 0.463523
Kn6an23a13 Ln6a13 Ln23a13 0.463523
Kn6an23a14 Ln6a14 Ln23a14 0.463523
Kn6an23a15 Ln6a15 Ln23a15 0.463523
Kn6an23a16 Ln6a16 Ln23a16 0.463523
Kn6an24a1 Ln6a1 Ln24a1 0.458074
Kn6an24a2 Ln6a2 Ln24a2 0.458074
Kn6an24a3 Ln6a3 Ln24a3 0.458074
Kn6an24a4 Ln6a4 Ln24a4 0.458074
Kn6an24a5 Ln6a5 Ln24a5 0.458074
Kn6an24a6 Ln6a6 Ln24a6 0.458074
Kn6an24a7 Ln6a7 Ln24a7 0.458074
Kn6an24a8 Ln6a8 Ln24a8 0.458074
Kn6an24a9 Ln6a9 Ln24a9 0.458074
Kn6an24a10 Ln6a10 Ln24a10 0.458074
Kn6an24a11 Ln6a11 Ln24a11 0.458074
Kn6an24a12 Ln6a12 Ln24a12 0.458074
Kn6an24a13 Ln6a13 Ln24a13 0.458074
Kn6an24a14 Ln6a14 Ln24a14 0.458074
Kn6an24a15 Ln6a15 Ln24a15 0.458074
Kn6an24a16 Ln6a16 Ln24a16 0.458074
Kn6an25a1 Ln6a1 Ln25a1 0.453889
Kn6an25a2 Ln6a2 Ln25a2 0.453889
Kn6an25a3 Ln6a3 Ln25a3 0.453889
Kn6an25a4 Ln6a4 Ln25a4 0.453889
Kn6an25a5 Ln6a5 Ln25a5 0.453889
Kn6an25a6 Ln6a6 Ln25a6 0.453889
Kn6an25a7 Ln6a7 Ln25a7 0.453889
Kn6an25a8 Ln6a8 Ln25a8 0.453889
Kn6an25a9 Ln6a9 Ln25a9 0.453889
Kn6an25a10 Ln6a10 Ln25a10 0.453889
Kn6an25a11 Ln6a11 Ln25a11 0.453889
Kn6an25a12 Ln6a12 Ln25a12 0.453889
Kn6an25a13 Ln6a13 Ln25a13 0.453889
Kn6an25a14 Ln6a14 Ln25a14 0.453889
Kn6an25a15 Ln6a15 Ln25a15 0.453889
Kn6an25a16 Ln6a16 Ln25a16 0.453889
Kn6an26a1 Ln6a1 Ln26a1 0.450243
Kn6an26a2 Ln6a2 Ln26a2 0.450243
Kn6an26a3 Ln6a3 Ln26a3 0.450243
Kn6an26a4 Ln6a4 Ln26a4 0.450243
Kn6an26a5 Ln6a5 Ln26a5 0.450243
Kn6an26a6 Ln6a6 Ln26a6 0.450243
Kn6an26a7 Ln6a7 Ln26a7 0.450243
Kn6an26a8 Ln6a8 Ln26a8 0.450243
Kn6an26a9 Ln6a9 Ln26a9 0.450243
Kn6an26a10 Ln6a10 Ln26a10 0.450243
Kn6an26a11 Ln6a11 Ln26a11 0.450243
Kn6an26a12 Ln6a12 Ln26a12 0.450243
Kn6an26a13 Ln6a13 Ln26a13 0.450243
Kn6an26a14 Ln6a14 Ln26a14 0.450243
Kn6an26a15 Ln6a15 Ln26a15 0.450243
Kn6an26a16 Ln6a16 Ln26a16 0.450243
Kn6an27a1 Ln6a1 Ln27a1 0.447456
Kn6an27a2 Ln6a2 Ln27a2 0.447456
Kn6an27a3 Ln6a3 Ln27a3 0.447456
Kn6an27a4 Ln6a4 Ln27a4 0.447456
Kn6an27a5 Ln6a5 Ln27a5 0.447456
Kn6an27a6 Ln6a6 Ln27a6 0.447456
Kn6an27a7 Ln6a7 Ln27a7 0.447456
Kn6an27a8 Ln6a8 Ln27a8 0.447456
Kn6an27a9 Ln6a9 Ln27a9 0.447456
Kn6an27a10 Ln6a10 Ln27a10 0.447456
Kn6an27a11 Ln6a11 Ln27a11 0.447456
Kn6an27a12 Ln6a12 Ln27a12 0.447456
Kn6an27a13 Ln6a13 Ln27a13 0.447456
Kn6an27a14 Ln6a14 Ln27a14 0.447456
Kn6an27a15 Ln6a15 Ln27a15 0.447456
Kn6an27a16 Ln6a16 Ln27a16 0.447456
Kn6an28a1 Ln6a1 Ln28a1 0.445700
Kn6an28a2 Ln6a2 Ln28a2 0.445700
Kn6an28a3 Ln6a3 Ln28a3 0.445700
Kn6an28a4 Ln6a4 Ln28a4 0.445700
Kn6an28a5 Ln6a5 Ln28a5 0.445700
Kn6an28a6 Ln6a6 Ln28a6 0.445700
Kn6an28a7 Ln6a7 Ln28a7 0.445700
Kn6an28a8 Ln6a8 Ln28a8 0.445700
Kn6an28a9 Ln6a9 Ln28a9 0.445700
Kn6an28a10 Ln6a10 Ln28a10 0.445700
Kn6an28a11 Ln6a11 Ln28a11 0.445700
Kn6an28a12 Ln6a12 Ln28a12 0.445700
Kn6an28a13 Ln6a13 Ln28a13 0.445700
Kn6an28a14 Ln6a14 Ln28a14 0.445700
Kn6an28a15 Ln6a15 Ln28a15 0.445700
Kn6an28a16 Ln6a16 Ln28a16 0.445700
Kn6an29a1 Ln6a1 Ln29a1 0.444759
Kn6an29a2 Ln6a2 Ln29a2 0.444759
Kn6an29a3 Ln6a3 Ln29a3 0.444759
Kn6an29a4 Ln6a4 Ln29a4 0.444759
Kn6an29a5 Ln6a5 Ln29a5 0.444759
Kn6an29a6 Ln6a6 Ln29a6 0.444759
Kn6an29a7 Ln6a7 Ln29a7 0.444759
Kn6an29a8 Ln6a8 Ln29a8 0.444759
Kn6an29a9 Ln6a9 Ln29a9 0.444759
Kn6an29a10 Ln6a10 Ln29a10 0.444759
Kn6an29a11 Ln6a11 Ln29a11 0.444759
Kn6an29a12 Ln6a12 Ln29a12 0.444759
Kn6an29a13 Ln6a13 Ln29a13 0.444759
Kn6an29a14 Ln6a14 Ln29a14 0.444759
Kn6an29a15 Ln6a15 Ln29a15 0.444759
Kn6an29a16 Ln6a16 Ln29a16 0.444759
Kn6an30a1 Ln6a1 Ln30a1 0.443914
Kn6an30a2 Ln6a2 Ln30a2 0.443914
Kn6an30a3 Ln6a3 Ln30a3 0.443914
Kn6an30a4 Ln6a4 Ln30a4 0.443914
Kn6an30a5 Ln6a5 Ln30a5 0.443914
Kn6an30a6 Ln6a6 Ln30a6 0.443914
Kn6an30a7 Ln6a7 Ln30a7 0.443914
Kn6an30a8 Ln6a8 Ln30a8 0.443914
Kn6an30a9 Ln6a9 Ln30a9 0.443914
Kn6an30a10 Ln6a10 Ln30a10 0.443914
Kn6an30a11 Ln6a11 Ln30a11 0.443914
Kn6an30a12 Ln6a12 Ln30a12 0.443914
Kn6an30a13 Ln6a13 Ln30a13 0.443914
Kn6an30a14 Ln6a14 Ln30a14 0.443914
Kn6an30a15 Ln6a15 Ln30a15 0.443914
Kn6an30a16 Ln6a16 Ln30a16 0.443914
Kn6an31a1 Ln6a1 Ln31a1 0.443172
Kn6an31a2 Ln6a2 Ln31a2 0.443172
Kn6an31a3 Ln6a3 Ln31a3 0.443172
Kn6an31a4 Ln6a4 Ln31a4 0.443172
Kn6an31a5 Ln6a5 Ln31a5 0.443172
Kn6an31a6 Ln6a6 Ln31a6 0.443172
Kn6an31a7 Ln6a7 Ln31a7 0.443172
Kn6an31a8 Ln6a8 Ln31a8 0.443172
Kn6an31a9 Ln6a9 Ln31a9 0.443172
Kn6an31a10 Ln6a10 Ln31a10 0.443172
Kn6an31a11 Ln6a11 Ln31a11 0.443172
Kn6an31a12 Ln6a12 Ln31a12 0.443172
Kn6an31a13 Ln6a13 Ln31a13 0.443172
Kn6an31a14 Ln6a14 Ln31a14 0.443172
Kn6an31a15 Ln6a15 Ln31a15 0.443172
Kn6an31a16 Ln6a16 Ln31a16 0.443172
Kn6an32a1 Ln6a1 Ln32a1 0.442527
Kn6an32a2 Ln6a2 Ln32a2 0.442527
Kn6an32a3 Ln6a3 Ln32a3 0.442527
Kn6an32a4 Ln6a4 Ln32a4 0.442527
Kn6an32a5 Ln6a5 Ln32a5 0.442527
Kn6an32a6 Ln6a6 Ln32a6 0.442527
Kn6an32a7 Ln6a7 Ln32a7 0.442527
Kn6an32a8 Ln6a8 Ln32a8 0.442527
Kn6an32a9 Ln6a9 Ln32a9 0.442527
Kn6an32a10 Ln6a10 Ln32a10 0.442527
Kn6an32a11 Ln6a11 Ln32a11 0.442527
Kn6an32a12 Ln6a12 Ln32a12 0.442527
Kn6an32a13 Ln6a13 Ln32a13 0.442527
Kn6an32a14 Ln6a14 Ln32a14 0.442527
Kn6an32a15 Ln6a15 Ln32a15 0.442527
Kn6an32a16 Ln6a16 Ln32a16 0.442527
Kn6anva1 Ln6a1 Lnva1 0.442011
Kn6anva2 Ln6a2 Lnva2 0.442011
Kn6anva3 Ln6a3 Lnva3 0.442011
Kn6anva4 Ln6a4 Lnva4 0.442011
Kn6anva5 Ln6a5 Lnva5 0.442011
Kn6anva6 Ln6a6 Lnva6 0.442011
Kn6anva7 Ln6a7 Lnva7 0.442011
Kn6anva8 Ln6a8 Lnva8 0.442011
Kn6anva9 Ln6a9 Lnva9 0.442011
Kn6anva10 Ln6a10 Lnva10 0.442011
Kn6anva11 Ln6a11 Lnva11 0.442011
Kn6anva12 Ln6a12 Lnva12 0.442011
Kn6anva13 Ln6a13 Lnva13 0.442011
Kn6anva14 Ln6a14 Lnva14 0.442011
Kn6anva15 Ln6a15 Lnva15 0.442011
Kn6anva16 Ln6a16 Lnva16 0.442011
Kn7an8a1 Ln7a1 Ln8a1 0.805155
Kn7an8a2 Ln7a2 Ln8a2 0.805155
Kn7an8a3 Ln7a3 Ln8a3 0.805155
Kn7an8a4 Ln7a4 Ln8a4 0.805155
Kn7an8a5 Ln7a5 Ln8a5 0.805155
Kn7an8a6 Ln7a6 Ln8a6 0.805155
Kn7an8a7 Ln7a7 Ln8a7 0.805155
Kn7an8a8 Ln7a8 Ln8a8 0.805155
Kn7an8a9 Ln7a9 Ln8a9 0.805155
Kn7an8a10 Ln7a10 Ln8a10 0.805155
Kn7an8a11 Ln7a11 Ln8a11 0.805155
Kn7an8a12 Ln7a12 Ln8a12 0.805155
Kn7an8a13 Ln7a13 Ln8a13 0.805155
Kn7an8a14 Ln7a14 Ln8a14 0.805155
Kn7an8a15 Ln7a15 Ln8a15 0.805155
Kn7an8a16 Ln7a16 Ln8a16 0.805155
Kn7an9a1 Ln7a1 Ln9a1 0.723730
Kn7an9a2 Ln7a2 Ln9a2 0.723730
Kn7an9a3 Ln7a3 Ln9a3 0.723730
Kn7an9a4 Ln7a4 Ln9a4 0.723730
Kn7an9a5 Ln7a5 Ln9a5 0.723730
Kn7an9a6 Ln7a6 Ln9a6 0.723730
Kn7an9a7 Ln7a7 Ln9a7 0.723730
Kn7an9a8 Ln7a8 Ln9a8 0.723730
Kn7an9a9 Ln7a9 Ln9a9 0.723730
Kn7an9a10 Ln7a10 Ln9a10 0.723730
Kn7an9a11 Ln7a11 Ln9a11 0.723730
Kn7an9a12 Ln7a12 Ln9a12 0.723730
Kn7an9a13 Ln7a13 Ln9a13 0.723730
Kn7an9a14 Ln7a14 Ln9a14 0.723730
Kn7an9a15 Ln7a15 Ln9a15 0.723730
Kn7an9a16 Ln7a16 Ln9a16 0.723730
Kn7an10a1 Ln7a1 Ln10a1 0.675208
Kn7an10a2 Ln7a2 Ln10a2 0.675208
Kn7an10a3 Ln7a3 Ln10a3 0.675208
Kn7an10a4 Ln7a4 Ln10a4 0.675208
Kn7an10a5 Ln7a5 Ln10a5 0.675208
Kn7an10a6 Ln7a6 Ln10a6 0.675208
Kn7an10a7 Ln7a7 Ln10a7 0.675208
Kn7an10a8 Ln7a8 Ln10a8 0.675208
Kn7an10a9 Ln7a9 Ln10a9 0.675208
Kn7an10a10 Ln7a10 Ln10a10 0.675208
Kn7an10a11 Ln7a11 Ln10a11 0.675208
Kn7an10a12 Ln7a12 Ln10a12 0.675208
Kn7an10a13 Ln7a13 Ln10a13 0.675208
Kn7an10a14 Ln7a14 Ln10a14 0.675208
Kn7an10a15 Ln7a15 Ln10a15 0.675208
Kn7an10a16 Ln7a16 Ln10a16 0.675208
Kn7an11a1 Ln7a1 Ln11a1 0.640637
Kn7an11a2 Ln7a2 Ln11a2 0.640637
Kn7an11a3 Ln7a3 Ln11a3 0.640637
Kn7an11a4 Ln7a4 Ln11a4 0.640637
Kn7an11a5 Ln7a5 Ln11a5 0.640637
Kn7an11a6 Ln7a6 Ln11a6 0.640637
Kn7an11a7 Ln7a7 Ln11a7 0.640637
Kn7an11a8 Ln7a8 Ln11a8 0.640637
Kn7an11a9 Ln7a9 Ln11a9 0.640637
Kn7an11a10 Ln7a10 Ln11a10 0.640637
Kn7an11a11 Ln7a11 Ln11a11 0.640637
Kn7an11a12 Ln7a12 Ln11a12 0.640637
Kn7an11a13 Ln7a13 Ln11a13 0.640637
Kn7an11a14 Ln7a14 Ln11a14 0.640637
Kn7an11a15 Ln7a15 Ln11a15 0.640637
Kn7an11a16 Ln7a16 Ln11a16 0.640637
Kn7an12a1 Ln7a1 Ln12a1 0.613723
Kn7an12a2 Ln7a2 Ln12a2 0.613723
Kn7an12a3 Ln7a3 Ln12a3 0.613723
Kn7an12a4 Ln7a4 Ln12a4 0.613723
Kn7an12a5 Ln7a5 Ln12a5 0.613723
Kn7an12a6 Ln7a6 Ln12a6 0.613723
Kn7an12a7 Ln7a7 Ln12a7 0.613723
Kn7an12a8 Ln7a8 Ln12a8 0.613723
Kn7an12a9 Ln7a9 Ln12a9 0.613723
Kn7an12a10 Ln7a10 Ln12a10 0.613723
Kn7an12a11 Ln7a11 Ln12a11 0.613723
Kn7an12a12 Ln7a12 Ln12a12 0.613723
Kn7an12a13 Ln7a13 Ln12a13 0.613723
Kn7an12a14 Ln7a14 Ln12a14 0.613723
Kn7an12a15 Ln7a15 Ln12a15 0.613723
Kn7an12a16 Ln7a16 Ln12a16 0.613723
Kn7an13a1 Ln7a1 Ln13a1 0.591812
Kn7an13a2 Ln7a2 Ln13a2 0.591812
Kn7an13a3 Ln7a3 Ln13a3 0.591812
Kn7an13a4 Ln7a4 Ln13a4 0.591812
Kn7an13a5 Ln7a5 Ln13a5 0.591812
Kn7an13a6 Ln7a6 Ln13a6 0.591812
Kn7an13a7 Ln7a7 Ln13a7 0.591812
Kn7an13a8 Ln7a8 Ln13a8 0.591812
Kn7an13a9 Ln7a9 Ln13a9 0.591812
Kn7an13a10 Ln7a10 Ln13a10 0.591812
Kn7an13a11 Ln7a11 Ln13a11 0.591812
Kn7an13a12 Ln7a12 Ln13a12 0.591812
Kn7an13a13 Ln7a13 Ln13a13 0.591812
Kn7an13a14 Ln7a14 Ln13a14 0.591812
Kn7an13a15 Ln7a15 Ln13a15 0.591812
Kn7an13a16 Ln7a16 Ln13a16 0.591812
Kn7an14a1 Ln7a1 Ln14a1 0.573237
Kn7an14a2 Ln7a2 Ln14a2 0.573237
Kn7an14a3 Ln7a3 Ln14a3 0.573237
Kn7an14a4 Ln7a4 Ln14a4 0.573237
Kn7an14a5 Ln7a5 Ln14a5 0.573237
Kn7an14a6 Ln7a6 Ln14a6 0.573237
Kn7an14a7 Ln7a7 Ln14a7 0.573237
Kn7an14a8 Ln7a8 Ln14a8 0.573237
Kn7an14a9 Ln7a9 Ln14a9 0.573237
Kn7an14a10 Ln7a10 Ln14a10 0.573237
Kn7an14a11 Ln7a11 Ln14a11 0.573237
Kn7an14a12 Ln7a12 Ln14a12 0.573237
Kn7an14a13 Ln7a13 Ln14a13 0.573237
Kn7an14a14 Ln7a14 Ln14a14 0.573237
Kn7an14a15 Ln7a15 Ln14a15 0.573237
Kn7an14a16 Ln7a16 Ln14a16 0.573237
Kn7an15a1 Ln7a1 Ln15a1 0.557165
Kn7an15a2 Ln7a2 Ln15a2 0.557165
Kn7an15a3 Ln7a3 Ln15a3 0.557165
Kn7an15a4 Ln7a4 Ln15a4 0.557165
Kn7an15a5 Ln7a5 Ln15a5 0.557165
Kn7an15a6 Ln7a6 Ln15a6 0.557165
Kn7an15a7 Ln7a7 Ln15a7 0.557165
Kn7an15a8 Ln7a8 Ln15a8 0.557165
Kn7an15a9 Ln7a9 Ln15a9 0.557165
Kn7an15a10 Ln7a10 Ln15a10 0.557165
Kn7an15a11 Ln7a11 Ln15a11 0.557165
Kn7an15a12 Ln7a12 Ln15a12 0.557165
Kn7an15a13 Ln7a13 Ln15a13 0.557165
Kn7an15a14 Ln7a14 Ln15a14 0.557165
Kn7an15a15 Ln7a15 Ln15a15 0.557165
Kn7an15a16 Ln7a16 Ln15a16 0.557165
Kn7an16a1 Ln7a1 Ln16a1 0.542987
Kn7an16a2 Ln7a2 Ln16a2 0.542987
Kn7an16a3 Ln7a3 Ln16a3 0.542987
Kn7an16a4 Ln7a4 Ln16a4 0.542987
Kn7an16a5 Ln7a5 Ln16a5 0.542987
Kn7an16a6 Ln7a6 Ln16a6 0.542987
Kn7an16a7 Ln7a7 Ln16a7 0.542987
Kn7an16a8 Ln7a8 Ln16a8 0.542987
Kn7an16a9 Ln7a9 Ln16a9 0.542987
Kn7an16a10 Ln7a10 Ln16a10 0.542987
Kn7an16a11 Ln7a11 Ln16a11 0.542987
Kn7an16a12 Ln7a12 Ln16a12 0.542987
Kn7an16a13 Ln7a13 Ln16a13 0.542987
Kn7an16a14 Ln7a14 Ln16a14 0.542987
Kn7an16a15 Ln7a15 Ln16a15 0.542987
Kn7an16a16 Ln7a16 Ln16a16 0.542987
Kn7an17a1 Ln7a1 Ln17a1 0.529400
Kn7an17a2 Ln7a2 Ln17a2 0.529400
Kn7an17a3 Ln7a3 Ln17a3 0.529400
Kn7an17a4 Ln7a4 Ln17a4 0.529400
Kn7an17a5 Ln7a5 Ln17a5 0.529400
Kn7an17a6 Ln7a6 Ln17a6 0.529400
Kn7an17a7 Ln7a7 Ln17a7 0.529400
Kn7an17a8 Ln7a8 Ln17a8 0.529400
Kn7an17a9 Ln7a9 Ln17a9 0.529400
Kn7an17a10 Ln7a10 Ln17a10 0.529400
Kn7an17a11 Ln7a11 Ln17a11 0.529400
Kn7an17a12 Ln7a12 Ln17a12 0.529400
Kn7an17a13 Ln7a13 Ln17a13 0.529400
Kn7an17a14 Ln7a14 Ln17a14 0.529400
Kn7an17a15 Ln7a15 Ln17a15 0.529400
Kn7an17a16 Ln7a16 Ln17a16 0.529400
Kn7an18a1 Ln7a1 Ln18a1 0.516943
Kn7an18a2 Ln7a2 Ln18a2 0.516943
Kn7an18a3 Ln7a3 Ln18a3 0.516943
Kn7an18a4 Ln7a4 Ln18a4 0.516943
Kn7an18a5 Ln7a5 Ln18a5 0.516943
Kn7an18a6 Ln7a6 Ln18a6 0.516943
Kn7an18a7 Ln7a7 Ln18a7 0.516943
Kn7an18a8 Ln7a8 Ln18a8 0.516943
Kn7an18a9 Ln7a9 Ln18a9 0.516943
Kn7an18a10 Ln7a10 Ln18a10 0.516943
Kn7an18a11 Ln7a11 Ln18a11 0.516943
Kn7an18a12 Ln7a12 Ln18a12 0.516943
Kn7an18a13 Ln7a13 Ln18a13 0.516943
Kn7an18a14 Ln7a14 Ln18a14 0.516943
Kn7an18a15 Ln7a15 Ln18a15 0.516943
Kn7an18a16 Ln7a16 Ln18a16 0.516943
Kn7an19a1 Ln7a1 Ln19a1 0.505455
Kn7an19a2 Ln7a2 Ln19a2 0.505455
Kn7an19a3 Ln7a3 Ln19a3 0.505455
Kn7an19a4 Ln7a4 Ln19a4 0.505455
Kn7an19a5 Ln7a5 Ln19a5 0.505455
Kn7an19a6 Ln7a6 Ln19a6 0.505455
Kn7an19a7 Ln7a7 Ln19a7 0.505455
Kn7an19a8 Ln7a8 Ln19a8 0.505455
Kn7an19a9 Ln7a9 Ln19a9 0.505455
Kn7an19a10 Ln7a10 Ln19a10 0.505455
Kn7an19a11 Ln7a11 Ln19a11 0.505455
Kn7an19a12 Ln7a12 Ln19a12 0.505455
Kn7an19a13 Ln7a13 Ln19a13 0.505455
Kn7an19a14 Ln7a14 Ln19a14 0.505455
Kn7an19a15 Ln7a15 Ln19a15 0.505455
Kn7an19a16 Ln7a16 Ln19a16 0.505455
Kn7an20a1 Ln7a1 Ln20a1 0.494887
Kn7an20a2 Ln7a2 Ln20a2 0.494887
Kn7an20a3 Ln7a3 Ln20a3 0.494887
Kn7an20a4 Ln7a4 Ln20a4 0.494887
Kn7an20a5 Ln7a5 Ln20a5 0.494887
Kn7an20a6 Ln7a6 Ln20a6 0.494887
Kn7an20a7 Ln7a7 Ln20a7 0.494887
Kn7an20a8 Ln7a8 Ln20a8 0.494887
Kn7an20a9 Ln7a9 Ln20a9 0.494887
Kn7an20a10 Ln7a10 Ln20a10 0.494887
Kn7an20a11 Ln7a11 Ln20a11 0.494887
Kn7an20a12 Ln7a12 Ln20a12 0.494887
Kn7an20a13 Ln7a13 Ln20a13 0.494887
Kn7an20a14 Ln7a14 Ln20a14 0.494887
Kn7an20a15 Ln7a15 Ln20a15 0.494887
Kn7an20a16 Ln7a16 Ln20a16 0.494887
Kn7an21a1 Ln7a1 Ln21a1 0.485771
Kn7an21a2 Ln7a2 Ln21a2 0.485771
Kn7an21a3 Ln7a3 Ln21a3 0.485771
Kn7an21a4 Ln7a4 Ln21a4 0.485771
Kn7an21a5 Ln7a5 Ln21a5 0.485771
Kn7an21a6 Ln7a6 Ln21a6 0.485771
Kn7an21a7 Ln7a7 Ln21a7 0.485771
Kn7an21a8 Ln7a8 Ln21a8 0.485771
Kn7an21a9 Ln7a9 Ln21a9 0.485771
Kn7an21a10 Ln7a10 Ln21a10 0.485771
Kn7an21a11 Ln7a11 Ln21a11 0.485771
Kn7an21a12 Ln7a12 Ln21a12 0.485771
Kn7an21a13 Ln7a13 Ln21a13 0.485771
Kn7an21a14 Ln7a14 Ln21a14 0.485771
Kn7an21a15 Ln7a15 Ln21a15 0.485771
Kn7an21a16 Ln7a16 Ln21a16 0.485771
Kn7an22a1 Ln7a1 Ln22a1 0.477226
Kn7an22a2 Ln7a2 Ln22a2 0.477226
Kn7an22a3 Ln7a3 Ln22a3 0.477226
Kn7an22a4 Ln7a4 Ln22a4 0.477226
Kn7an22a5 Ln7a5 Ln22a5 0.477226
Kn7an22a6 Ln7a6 Ln22a6 0.477226
Kn7an22a7 Ln7a7 Ln22a7 0.477226
Kn7an22a8 Ln7a8 Ln22a8 0.477226
Kn7an22a9 Ln7a9 Ln22a9 0.477226
Kn7an22a10 Ln7a10 Ln22a10 0.477226
Kn7an22a11 Ln7a11 Ln22a11 0.477226
Kn7an22a12 Ln7a12 Ln22a12 0.477226
Kn7an22a13 Ln7a13 Ln22a13 0.477226
Kn7an22a14 Ln7a14 Ln22a14 0.477226
Kn7an22a15 Ln7a15 Ln22a15 0.477226
Kn7an22a16 Ln7a16 Ln22a16 0.477226
Kn7an23a1 Ln7a1 Ln23a1 0.469680
Kn7an23a2 Ln7a2 Ln23a2 0.469680
Kn7an23a3 Ln7a3 Ln23a3 0.469680
Kn7an23a4 Ln7a4 Ln23a4 0.469680
Kn7an23a5 Ln7a5 Ln23a5 0.469680
Kn7an23a6 Ln7a6 Ln23a6 0.469680
Kn7an23a7 Ln7a7 Ln23a7 0.469680
Kn7an23a8 Ln7a8 Ln23a8 0.469680
Kn7an23a9 Ln7a9 Ln23a9 0.469680
Kn7an23a10 Ln7a10 Ln23a10 0.469680
Kn7an23a11 Ln7a11 Ln23a11 0.469680
Kn7an23a12 Ln7a12 Ln23a12 0.469680
Kn7an23a13 Ln7a13 Ln23a13 0.469680
Kn7an23a14 Ln7a14 Ln23a14 0.469680
Kn7an23a15 Ln7a15 Ln23a15 0.469680
Kn7an23a16 Ln7a16 Ln23a16 0.469680
Kn7an24a1 Ln7a1 Ln24a1 0.463523
Kn7an24a2 Ln7a2 Ln24a2 0.463523
Kn7an24a3 Ln7a3 Ln24a3 0.463523
Kn7an24a4 Ln7a4 Ln24a4 0.463523
Kn7an24a5 Ln7a5 Ln24a5 0.463523
Kn7an24a6 Ln7a6 Ln24a6 0.463523
Kn7an24a7 Ln7a7 Ln24a7 0.463523
Kn7an24a8 Ln7a8 Ln24a8 0.463523
Kn7an24a9 Ln7a9 Ln24a9 0.463523
Kn7an24a10 Ln7a10 Ln24a10 0.463523
Kn7an24a11 Ln7a11 Ln24a11 0.463523
Kn7an24a12 Ln7a12 Ln24a12 0.463523
Kn7an24a13 Ln7a13 Ln24a13 0.463523
Kn7an24a14 Ln7a14 Ln24a14 0.463523
Kn7an24a15 Ln7a15 Ln24a15 0.463523
Kn7an24a16 Ln7a16 Ln24a16 0.463523
Kn7an25a1 Ln7a1 Ln25a1 0.458074
Kn7an25a2 Ln7a2 Ln25a2 0.458074
Kn7an25a3 Ln7a3 Ln25a3 0.458074
Kn7an25a4 Ln7a4 Ln25a4 0.458074
Kn7an25a5 Ln7a5 Ln25a5 0.458074
Kn7an25a6 Ln7a6 Ln25a6 0.458074
Kn7an25a7 Ln7a7 Ln25a7 0.458074
Kn7an25a8 Ln7a8 Ln25a8 0.458074
Kn7an25a9 Ln7a9 Ln25a9 0.458074
Kn7an25a10 Ln7a10 Ln25a10 0.458074
Kn7an25a11 Ln7a11 Ln25a11 0.458074
Kn7an25a12 Ln7a12 Ln25a12 0.458074
Kn7an25a13 Ln7a13 Ln25a13 0.458074
Kn7an25a14 Ln7a14 Ln25a14 0.458074
Kn7an25a15 Ln7a15 Ln25a15 0.458074
Kn7an25a16 Ln7a16 Ln25a16 0.458074
Kn7an26a1 Ln7a1 Ln26a1 0.453889
Kn7an26a2 Ln7a2 Ln26a2 0.453889
Kn7an26a3 Ln7a3 Ln26a3 0.453889
Kn7an26a4 Ln7a4 Ln26a4 0.453889
Kn7an26a5 Ln7a5 Ln26a5 0.453889
Kn7an26a6 Ln7a6 Ln26a6 0.453889
Kn7an26a7 Ln7a7 Ln26a7 0.453889
Kn7an26a8 Ln7a8 Ln26a8 0.453889
Kn7an26a9 Ln7a9 Ln26a9 0.453889
Kn7an26a10 Ln7a10 Ln26a10 0.453889
Kn7an26a11 Ln7a11 Ln26a11 0.453889
Kn7an26a12 Ln7a12 Ln26a12 0.453889
Kn7an26a13 Ln7a13 Ln26a13 0.453889
Kn7an26a14 Ln7a14 Ln26a14 0.453889
Kn7an26a15 Ln7a15 Ln26a15 0.453889
Kn7an26a16 Ln7a16 Ln26a16 0.453889
Kn7an27a1 Ln7a1 Ln27a1 0.450243
Kn7an27a2 Ln7a2 Ln27a2 0.450243
Kn7an27a3 Ln7a3 Ln27a3 0.450243
Kn7an27a4 Ln7a4 Ln27a4 0.450243
Kn7an27a5 Ln7a5 Ln27a5 0.450243
Kn7an27a6 Ln7a6 Ln27a6 0.450243
Kn7an27a7 Ln7a7 Ln27a7 0.450243
Kn7an27a8 Ln7a8 Ln27a8 0.450243
Kn7an27a9 Ln7a9 Ln27a9 0.450243
Kn7an27a10 Ln7a10 Ln27a10 0.450243
Kn7an27a11 Ln7a11 Ln27a11 0.450243
Kn7an27a12 Ln7a12 Ln27a12 0.450243
Kn7an27a13 Ln7a13 Ln27a13 0.450243
Kn7an27a14 Ln7a14 Ln27a14 0.450243
Kn7an27a15 Ln7a15 Ln27a15 0.450243
Kn7an27a16 Ln7a16 Ln27a16 0.450243
Kn7an28a1 Ln7a1 Ln28a1 0.447456
Kn7an28a2 Ln7a2 Ln28a2 0.447456
Kn7an28a3 Ln7a3 Ln28a3 0.447456
Kn7an28a4 Ln7a4 Ln28a4 0.447456
Kn7an28a5 Ln7a5 Ln28a5 0.447456
Kn7an28a6 Ln7a6 Ln28a6 0.447456
Kn7an28a7 Ln7a7 Ln28a7 0.447456
Kn7an28a8 Ln7a8 Ln28a8 0.447456
Kn7an28a9 Ln7a9 Ln28a9 0.447456
Kn7an28a10 Ln7a10 Ln28a10 0.447456
Kn7an28a11 Ln7a11 Ln28a11 0.447456
Kn7an28a12 Ln7a12 Ln28a12 0.447456
Kn7an28a13 Ln7a13 Ln28a13 0.447456
Kn7an28a14 Ln7a14 Ln28a14 0.447456
Kn7an28a15 Ln7a15 Ln28a15 0.447456
Kn7an28a16 Ln7a16 Ln28a16 0.447456
Kn7an29a1 Ln7a1 Ln29a1 0.445700
Kn7an29a2 Ln7a2 Ln29a2 0.445700
Kn7an29a3 Ln7a3 Ln29a3 0.445700
Kn7an29a4 Ln7a4 Ln29a4 0.445700
Kn7an29a5 Ln7a5 Ln29a5 0.445700
Kn7an29a6 Ln7a6 Ln29a6 0.445700
Kn7an29a7 Ln7a7 Ln29a7 0.445700
Kn7an29a8 Ln7a8 Ln29a8 0.445700
Kn7an29a9 Ln7a9 Ln29a9 0.445700
Kn7an29a10 Ln7a10 Ln29a10 0.445700
Kn7an29a11 Ln7a11 Ln29a11 0.445700
Kn7an29a12 Ln7a12 Ln29a12 0.445700
Kn7an29a13 Ln7a13 Ln29a13 0.445700
Kn7an29a14 Ln7a14 Ln29a14 0.445700
Kn7an29a15 Ln7a15 Ln29a15 0.445700
Kn7an29a16 Ln7a16 Ln29a16 0.445700
Kn7an30a1 Ln7a1 Ln30a1 0.444759
Kn7an30a2 Ln7a2 Ln30a2 0.444759
Kn7an30a3 Ln7a3 Ln30a3 0.444759
Kn7an30a4 Ln7a4 Ln30a4 0.444759
Kn7an30a5 Ln7a5 Ln30a5 0.444759
Kn7an30a6 Ln7a6 Ln30a6 0.444759
Kn7an30a7 Ln7a7 Ln30a7 0.444759
Kn7an30a8 Ln7a8 Ln30a8 0.444759
Kn7an30a9 Ln7a9 Ln30a9 0.444759
Kn7an30a10 Ln7a10 Ln30a10 0.444759
Kn7an30a11 Ln7a11 Ln30a11 0.444759
Kn7an30a12 Ln7a12 Ln30a12 0.444759
Kn7an30a13 Ln7a13 Ln30a13 0.444759
Kn7an30a14 Ln7a14 Ln30a14 0.444759
Kn7an30a15 Ln7a15 Ln30a15 0.444759
Kn7an30a16 Ln7a16 Ln30a16 0.444759
Kn7an31a1 Ln7a1 Ln31a1 0.443914
Kn7an31a2 Ln7a2 Ln31a2 0.443914
Kn7an31a3 Ln7a3 Ln31a3 0.443914
Kn7an31a4 Ln7a4 Ln31a4 0.443914
Kn7an31a5 Ln7a5 Ln31a5 0.443914
Kn7an31a6 Ln7a6 Ln31a6 0.443914
Kn7an31a7 Ln7a7 Ln31a7 0.443914
Kn7an31a8 Ln7a8 Ln31a8 0.443914
Kn7an31a9 Ln7a9 Ln31a9 0.443914
Kn7an31a10 Ln7a10 Ln31a10 0.443914
Kn7an31a11 Ln7a11 Ln31a11 0.443914
Kn7an31a12 Ln7a12 Ln31a12 0.443914
Kn7an31a13 Ln7a13 Ln31a13 0.443914
Kn7an31a14 Ln7a14 Ln31a14 0.443914
Kn7an31a15 Ln7a15 Ln31a15 0.443914
Kn7an31a16 Ln7a16 Ln31a16 0.443914
Kn7an32a1 Ln7a1 Ln32a1 0.443172
Kn7an32a2 Ln7a2 Ln32a2 0.443172
Kn7an32a3 Ln7a3 Ln32a3 0.443172
Kn7an32a4 Ln7a4 Ln32a4 0.443172
Kn7an32a5 Ln7a5 Ln32a5 0.443172
Kn7an32a6 Ln7a6 Ln32a6 0.443172
Kn7an32a7 Ln7a7 Ln32a7 0.443172
Kn7an32a8 Ln7a8 Ln32a8 0.443172
Kn7an32a9 Ln7a9 Ln32a9 0.443172
Kn7an32a10 Ln7a10 Ln32a10 0.443172
Kn7an32a11 Ln7a11 Ln32a11 0.443172
Kn7an32a12 Ln7a12 Ln32a12 0.443172
Kn7an32a13 Ln7a13 Ln32a13 0.443172
Kn7an32a14 Ln7a14 Ln32a14 0.443172
Kn7an32a15 Ln7a15 Ln32a15 0.443172
Kn7an32a16 Ln7a16 Ln32a16 0.443172
Kn7anva1 Ln7a1 Lnva1 0.442527
Kn7anva2 Ln7a2 Lnva2 0.442527
Kn7anva3 Ln7a3 Lnva3 0.442527
Kn7anva4 Ln7a4 Lnva4 0.442527
Kn7anva5 Ln7a5 Lnva5 0.442527
Kn7anva6 Ln7a6 Lnva6 0.442527
Kn7anva7 Ln7a7 Lnva7 0.442527
Kn7anva8 Ln7a8 Lnva8 0.442527
Kn7anva9 Ln7a9 Lnva9 0.442527
Kn7anva10 Ln7a10 Lnva10 0.442527
Kn7anva11 Ln7a11 Lnva11 0.442527
Kn7anva12 Ln7a12 Lnva12 0.442527
Kn7anva13 Ln7a13 Lnva13 0.442527
Kn7anva14 Ln7a14 Lnva14 0.442527
Kn7anva15 Ln7a15 Lnva15 0.442527
Kn7anva16 Ln7a16 Lnva16 0.442527
Kn8an9a1 Ln8a1 Ln9a1 0.805155
Kn8an9a2 Ln8a2 Ln9a2 0.805155
Kn8an9a3 Ln8a3 Ln9a3 0.805155
Kn8an9a4 Ln8a4 Ln9a4 0.805155
Kn8an9a5 Ln8a5 Ln9a5 0.805155
Kn8an9a6 Ln8a6 Ln9a6 0.805155
Kn8an9a7 Ln8a7 Ln9a7 0.805155
Kn8an9a8 Ln8a8 Ln9a8 0.805155
Kn8an9a9 Ln8a9 Ln9a9 0.805155
Kn8an9a10 Ln8a10 Ln9a10 0.805155
Kn8an9a11 Ln8a11 Ln9a11 0.805155
Kn8an9a12 Ln8a12 Ln9a12 0.805155
Kn8an9a13 Ln8a13 Ln9a13 0.805155
Kn8an9a14 Ln8a14 Ln9a14 0.805155
Kn8an9a15 Ln8a15 Ln9a15 0.805155
Kn8an9a16 Ln8a16 Ln9a16 0.805155
Kn8an10a1 Ln8a1 Ln10a1 0.723730
Kn8an10a2 Ln8a2 Ln10a2 0.723730
Kn8an10a3 Ln8a3 Ln10a3 0.723730
Kn8an10a4 Ln8a4 Ln10a4 0.723730
Kn8an10a5 Ln8a5 Ln10a5 0.723730
Kn8an10a6 Ln8a6 Ln10a6 0.723730
Kn8an10a7 Ln8a7 Ln10a7 0.723730
Kn8an10a8 Ln8a8 Ln10a8 0.723730
Kn8an10a9 Ln8a9 Ln10a9 0.723730
Kn8an10a10 Ln8a10 Ln10a10 0.723730
Kn8an10a11 Ln8a11 Ln10a11 0.723730
Kn8an10a12 Ln8a12 Ln10a12 0.723730
Kn8an10a13 Ln8a13 Ln10a13 0.723730
Kn8an10a14 Ln8a14 Ln10a14 0.723730
Kn8an10a15 Ln8a15 Ln10a15 0.723730
Kn8an10a16 Ln8a16 Ln10a16 0.723730
Kn8an11a1 Ln8a1 Ln11a1 0.675208
Kn8an11a2 Ln8a2 Ln11a2 0.675208
Kn8an11a3 Ln8a3 Ln11a3 0.675208
Kn8an11a4 Ln8a4 Ln11a4 0.675208
Kn8an11a5 Ln8a5 Ln11a5 0.675208
Kn8an11a6 Ln8a6 Ln11a6 0.675208
Kn8an11a7 Ln8a7 Ln11a7 0.675208
Kn8an11a8 Ln8a8 Ln11a8 0.675208
Kn8an11a9 Ln8a9 Ln11a9 0.675208
Kn8an11a10 Ln8a10 Ln11a10 0.675208
Kn8an11a11 Ln8a11 Ln11a11 0.675208
Kn8an11a12 Ln8a12 Ln11a12 0.675208
Kn8an11a13 Ln8a13 Ln11a13 0.675208
Kn8an11a14 Ln8a14 Ln11a14 0.675208
Kn8an11a15 Ln8a15 Ln11a15 0.675208
Kn8an11a16 Ln8a16 Ln11a16 0.675208
Kn8an12a1 Ln8a1 Ln12a1 0.640637
Kn8an12a2 Ln8a2 Ln12a2 0.640637
Kn8an12a3 Ln8a3 Ln12a3 0.640637
Kn8an12a4 Ln8a4 Ln12a4 0.640637
Kn8an12a5 Ln8a5 Ln12a5 0.640637
Kn8an12a6 Ln8a6 Ln12a6 0.640637
Kn8an12a7 Ln8a7 Ln12a7 0.640637
Kn8an12a8 Ln8a8 Ln12a8 0.640637
Kn8an12a9 Ln8a9 Ln12a9 0.640637
Kn8an12a10 Ln8a10 Ln12a10 0.640637
Kn8an12a11 Ln8a11 Ln12a11 0.640637
Kn8an12a12 Ln8a12 Ln12a12 0.640637
Kn8an12a13 Ln8a13 Ln12a13 0.640637
Kn8an12a14 Ln8a14 Ln12a14 0.640637
Kn8an12a15 Ln8a15 Ln12a15 0.640637
Kn8an12a16 Ln8a16 Ln12a16 0.640637
Kn8an13a1 Ln8a1 Ln13a1 0.613723
Kn8an13a2 Ln8a2 Ln13a2 0.613723
Kn8an13a3 Ln8a3 Ln13a3 0.613723
Kn8an13a4 Ln8a4 Ln13a4 0.613723
Kn8an13a5 Ln8a5 Ln13a5 0.613723
Kn8an13a6 Ln8a6 Ln13a6 0.613723
Kn8an13a7 Ln8a7 Ln13a7 0.613723
Kn8an13a8 Ln8a8 Ln13a8 0.613723
Kn8an13a9 Ln8a9 Ln13a9 0.613723
Kn8an13a10 Ln8a10 Ln13a10 0.613723
Kn8an13a11 Ln8a11 Ln13a11 0.613723
Kn8an13a12 Ln8a12 Ln13a12 0.613723
Kn8an13a13 Ln8a13 Ln13a13 0.613723
Kn8an13a14 Ln8a14 Ln13a14 0.613723
Kn8an13a15 Ln8a15 Ln13a15 0.613723
Kn8an13a16 Ln8a16 Ln13a16 0.613723
Kn8an14a1 Ln8a1 Ln14a1 0.591812
Kn8an14a2 Ln8a2 Ln14a2 0.591812
Kn8an14a3 Ln8a3 Ln14a3 0.591812
Kn8an14a4 Ln8a4 Ln14a4 0.591812
Kn8an14a5 Ln8a5 Ln14a5 0.591812
Kn8an14a6 Ln8a6 Ln14a6 0.591812
Kn8an14a7 Ln8a7 Ln14a7 0.591812
Kn8an14a8 Ln8a8 Ln14a8 0.591812
Kn8an14a9 Ln8a9 Ln14a9 0.591812
Kn8an14a10 Ln8a10 Ln14a10 0.591812
Kn8an14a11 Ln8a11 Ln14a11 0.591812
Kn8an14a12 Ln8a12 Ln14a12 0.591812
Kn8an14a13 Ln8a13 Ln14a13 0.591812
Kn8an14a14 Ln8a14 Ln14a14 0.591812
Kn8an14a15 Ln8a15 Ln14a15 0.591812
Kn8an14a16 Ln8a16 Ln14a16 0.591812
Kn8an15a1 Ln8a1 Ln15a1 0.573237
Kn8an15a2 Ln8a2 Ln15a2 0.573237
Kn8an15a3 Ln8a3 Ln15a3 0.573237
Kn8an15a4 Ln8a4 Ln15a4 0.573237
Kn8an15a5 Ln8a5 Ln15a5 0.573237
Kn8an15a6 Ln8a6 Ln15a6 0.573237
Kn8an15a7 Ln8a7 Ln15a7 0.573237
Kn8an15a8 Ln8a8 Ln15a8 0.573237
Kn8an15a9 Ln8a9 Ln15a9 0.573237
Kn8an15a10 Ln8a10 Ln15a10 0.573237
Kn8an15a11 Ln8a11 Ln15a11 0.573237
Kn8an15a12 Ln8a12 Ln15a12 0.573237
Kn8an15a13 Ln8a13 Ln15a13 0.573237
Kn8an15a14 Ln8a14 Ln15a14 0.573237
Kn8an15a15 Ln8a15 Ln15a15 0.573237
Kn8an15a16 Ln8a16 Ln15a16 0.573237
Kn8an16a1 Ln8a1 Ln16a1 0.557165
Kn8an16a2 Ln8a2 Ln16a2 0.557165
Kn8an16a3 Ln8a3 Ln16a3 0.557165
Kn8an16a4 Ln8a4 Ln16a4 0.557165
Kn8an16a5 Ln8a5 Ln16a5 0.557165
Kn8an16a6 Ln8a6 Ln16a6 0.557165
Kn8an16a7 Ln8a7 Ln16a7 0.557165
Kn8an16a8 Ln8a8 Ln16a8 0.557165
Kn8an16a9 Ln8a9 Ln16a9 0.557165
Kn8an16a10 Ln8a10 Ln16a10 0.557165
Kn8an16a11 Ln8a11 Ln16a11 0.557165
Kn8an16a12 Ln8a12 Ln16a12 0.557165
Kn8an16a13 Ln8a13 Ln16a13 0.557165
Kn8an16a14 Ln8a14 Ln16a14 0.557165
Kn8an16a15 Ln8a15 Ln16a15 0.557165
Kn8an16a16 Ln8a16 Ln16a16 0.557165
Kn8an17a1 Ln8a1 Ln17a1 0.542987
Kn8an17a2 Ln8a2 Ln17a2 0.542987
Kn8an17a3 Ln8a3 Ln17a3 0.542987
Kn8an17a4 Ln8a4 Ln17a4 0.542987
Kn8an17a5 Ln8a5 Ln17a5 0.542987
Kn8an17a6 Ln8a6 Ln17a6 0.542987
Kn8an17a7 Ln8a7 Ln17a7 0.542987
Kn8an17a8 Ln8a8 Ln17a8 0.542987
Kn8an17a9 Ln8a9 Ln17a9 0.542987
Kn8an17a10 Ln8a10 Ln17a10 0.542987
Kn8an17a11 Ln8a11 Ln17a11 0.542987
Kn8an17a12 Ln8a12 Ln17a12 0.542987
Kn8an17a13 Ln8a13 Ln17a13 0.542987
Kn8an17a14 Ln8a14 Ln17a14 0.542987
Kn8an17a15 Ln8a15 Ln17a15 0.542987
Kn8an17a16 Ln8a16 Ln17a16 0.542987
Kn8an18a1 Ln8a1 Ln18a1 0.529400
Kn8an18a2 Ln8a2 Ln18a2 0.529400
Kn8an18a3 Ln8a3 Ln18a3 0.529400
Kn8an18a4 Ln8a4 Ln18a4 0.529400
Kn8an18a5 Ln8a5 Ln18a5 0.529400
Kn8an18a6 Ln8a6 Ln18a6 0.529400
Kn8an18a7 Ln8a7 Ln18a7 0.529400
Kn8an18a8 Ln8a8 Ln18a8 0.529400
Kn8an18a9 Ln8a9 Ln18a9 0.529400
Kn8an18a10 Ln8a10 Ln18a10 0.529400
Kn8an18a11 Ln8a11 Ln18a11 0.529400
Kn8an18a12 Ln8a12 Ln18a12 0.529400
Kn8an18a13 Ln8a13 Ln18a13 0.529400
Kn8an18a14 Ln8a14 Ln18a14 0.529400
Kn8an18a15 Ln8a15 Ln18a15 0.529400
Kn8an18a16 Ln8a16 Ln18a16 0.529400
Kn8an19a1 Ln8a1 Ln19a1 0.516943
Kn8an19a2 Ln8a2 Ln19a2 0.516943
Kn8an19a3 Ln8a3 Ln19a3 0.516943
Kn8an19a4 Ln8a4 Ln19a4 0.516943
Kn8an19a5 Ln8a5 Ln19a5 0.516943
Kn8an19a6 Ln8a6 Ln19a6 0.516943
Kn8an19a7 Ln8a7 Ln19a7 0.516943
Kn8an19a8 Ln8a8 Ln19a8 0.516943
Kn8an19a9 Ln8a9 Ln19a9 0.516943
Kn8an19a10 Ln8a10 Ln19a10 0.516943
Kn8an19a11 Ln8a11 Ln19a11 0.516943
Kn8an19a12 Ln8a12 Ln19a12 0.516943
Kn8an19a13 Ln8a13 Ln19a13 0.516943
Kn8an19a14 Ln8a14 Ln19a14 0.516943
Kn8an19a15 Ln8a15 Ln19a15 0.516943
Kn8an19a16 Ln8a16 Ln19a16 0.516943
Kn8an20a1 Ln8a1 Ln20a1 0.505455
Kn8an20a2 Ln8a2 Ln20a2 0.505455
Kn8an20a3 Ln8a3 Ln20a3 0.505455
Kn8an20a4 Ln8a4 Ln20a4 0.505455
Kn8an20a5 Ln8a5 Ln20a5 0.505455
Kn8an20a6 Ln8a6 Ln20a6 0.505455
Kn8an20a7 Ln8a7 Ln20a7 0.505455
Kn8an20a8 Ln8a8 Ln20a8 0.505455
Kn8an20a9 Ln8a9 Ln20a9 0.505455
Kn8an20a10 Ln8a10 Ln20a10 0.505455
Kn8an20a11 Ln8a11 Ln20a11 0.505455
Kn8an20a12 Ln8a12 Ln20a12 0.505455
Kn8an20a13 Ln8a13 Ln20a13 0.505455
Kn8an20a14 Ln8a14 Ln20a14 0.505455
Kn8an20a15 Ln8a15 Ln20a15 0.505455
Kn8an20a16 Ln8a16 Ln20a16 0.505455
Kn8an21a1 Ln8a1 Ln21a1 0.494887
Kn8an21a2 Ln8a2 Ln21a2 0.494887
Kn8an21a3 Ln8a3 Ln21a3 0.494887
Kn8an21a4 Ln8a4 Ln21a4 0.494887
Kn8an21a5 Ln8a5 Ln21a5 0.494887
Kn8an21a6 Ln8a6 Ln21a6 0.494887
Kn8an21a7 Ln8a7 Ln21a7 0.494887
Kn8an21a8 Ln8a8 Ln21a8 0.494887
Kn8an21a9 Ln8a9 Ln21a9 0.494887
Kn8an21a10 Ln8a10 Ln21a10 0.494887
Kn8an21a11 Ln8a11 Ln21a11 0.494887
Kn8an21a12 Ln8a12 Ln21a12 0.494887
Kn8an21a13 Ln8a13 Ln21a13 0.494887
Kn8an21a14 Ln8a14 Ln21a14 0.494887
Kn8an21a15 Ln8a15 Ln21a15 0.494887
Kn8an21a16 Ln8a16 Ln21a16 0.494887
Kn8an22a1 Ln8a1 Ln22a1 0.485771
Kn8an22a2 Ln8a2 Ln22a2 0.485771
Kn8an22a3 Ln8a3 Ln22a3 0.485771
Kn8an22a4 Ln8a4 Ln22a4 0.485771
Kn8an22a5 Ln8a5 Ln22a5 0.485771
Kn8an22a6 Ln8a6 Ln22a6 0.485771
Kn8an22a7 Ln8a7 Ln22a7 0.485771
Kn8an22a8 Ln8a8 Ln22a8 0.485771
Kn8an22a9 Ln8a9 Ln22a9 0.485771
Kn8an22a10 Ln8a10 Ln22a10 0.485771
Kn8an22a11 Ln8a11 Ln22a11 0.485771
Kn8an22a12 Ln8a12 Ln22a12 0.485771
Kn8an22a13 Ln8a13 Ln22a13 0.485771
Kn8an22a14 Ln8a14 Ln22a14 0.485771
Kn8an22a15 Ln8a15 Ln22a15 0.485771
Kn8an22a16 Ln8a16 Ln22a16 0.485771
Kn8an23a1 Ln8a1 Ln23a1 0.477226
Kn8an23a2 Ln8a2 Ln23a2 0.477226
Kn8an23a3 Ln8a3 Ln23a3 0.477226
Kn8an23a4 Ln8a4 Ln23a4 0.477226
Kn8an23a5 Ln8a5 Ln23a5 0.477226
Kn8an23a6 Ln8a6 Ln23a6 0.477226
Kn8an23a7 Ln8a7 Ln23a7 0.477226
Kn8an23a8 Ln8a8 Ln23a8 0.477226
Kn8an23a9 Ln8a9 Ln23a9 0.477226
Kn8an23a10 Ln8a10 Ln23a10 0.477226
Kn8an23a11 Ln8a11 Ln23a11 0.477226
Kn8an23a12 Ln8a12 Ln23a12 0.477226
Kn8an23a13 Ln8a13 Ln23a13 0.477226
Kn8an23a14 Ln8a14 Ln23a14 0.477226
Kn8an23a15 Ln8a15 Ln23a15 0.477226
Kn8an23a16 Ln8a16 Ln23a16 0.477226
Kn8an24a1 Ln8a1 Ln24a1 0.469680
Kn8an24a2 Ln8a2 Ln24a2 0.469680
Kn8an24a3 Ln8a3 Ln24a3 0.469680
Kn8an24a4 Ln8a4 Ln24a4 0.469680
Kn8an24a5 Ln8a5 Ln24a5 0.469680
Kn8an24a6 Ln8a6 Ln24a6 0.469680
Kn8an24a7 Ln8a7 Ln24a7 0.469680
Kn8an24a8 Ln8a8 Ln24a8 0.469680
Kn8an24a9 Ln8a9 Ln24a9 0.469680
Kn8an24a10 Ln8a10 Ln24a10 0.469680
Kn8an24a11 Ln8a11 Ln24a11 0.469680
Kn8an24a12 Ln8a12 Ln24a12 0.469680
Kn8an24a13 Ln8a13 Ln24a13 0.469680
Kn8an24a14 Ln8a14 Ln24a14 0.469680
Kn8an24a15 Ln8a15 Ln24a15 0.469680
Kn8an24a16 Ln8a16 Ln24a16 0.469680
Kn8an25a1 Ln8a1 Ln25a1 0.463523
Kn8an25a2 Ln8a2 Ln25a2 0.463523
Kn8an25a3 Ln8a3 Ln25a3 0.463523
Kn8an25a4 Ln8a4 Ln25a4 0.463523
Kn8an25a5 Ln8a5 Ln25a5 0.463523
Kn8an25a6 Ln8a6 Ln25a6 0.463523
Kn8an25a7 Ln8a7 Ln25a7 0.463523
Kn8an25a8 Ln8a8 Ln25a8 0.463523
Kn8an25a9 Ln8a9 Ln25a9 0.463523
Kn8an25a10 Ln8a10 Ln25a10 0.463523
Kn8an25a11 Ln8a11 Ln25a11 0.463523
Kn8an25a12 Ln8a12 Ln25a12 0.463523
Kn8an25a13 Ln8a13 Ln25a13 0.463523
Kn8an25a14 Ln8a14 Ln25a14 0.463523
Kn8an25a15 Ln8a15 Ln25a15 0.463523
Kn8an25a16 Ln8a16 Ln25a16 0.463523
Kn8an26a1 Ln8a1 Ln26a1 0.458074
Kn8an26a2 Ln8a2 Ln26a2 0.458074
Kn8an26a3 Ln8a3 Ln26a3 0.458074
Kn8an26a4 Ln8a4 Ln26a4 0.458074
Kn8an26a5 Ln8a5 Ln26a5 0.458074
Kn8an26a6 Ln8a6 Ln26a6 0.458074
Kn8an26a7 Ln8a7 Ln26a7 0.458074
Kn8an26a8 Ln8a8 Ln26a8 0.458074
Kn8an26a9 Ln8a9 Ln26a9 0.458074
Kn8an26a10 Ln8a10 Ln26a10 0.458074
Kn8an26a11 Ln8a11 Ln26a11 0.458074
Kn8an26a12 Ln8a12 Ln26a12 0.458074
Kn8an26a13 Ln8a13 Ln26a13 0.458074
Kn8an26a14 Ln8a14 Ln26a14 0.458074
Kn8an26a15 Ln8a15 Ln26a15 0.458074
Kn8an26a16 Ln8a16 Ln26a16 0.458074
Kn8an27a1 Ln8a1 Ln27a1 0.453889
Kn8an27a2 Ln8a2 Ln27a2 0.453889
Kn8an27a3 Ln8a3 Ln27a3 0.453889
Kn8an27a4 Ln8a4 Ln27a4 0.453889
Kn8an27a5 Ln8a5 Ln27a5 0.453889
Kn8an27a6 Ln8a6 Ln27a6 0.453889
Kn8an27a7 Ln8a7 Ln27a7 0.453889
Kn8an27a8 Ln8a8 Ln27a8 0.453889
Kn8an27a9 Ln8a9 Ln27a9 0.453889
Kn8an27a10 Ln8a10 Ln27a10 0.453889
Kn8an27a11 Ln8a11 Ln27a11 0.453889
Kn8an27a12 Ln8a12 Ln27a12 0.453889
Kn8an27a13 Ln8a13 Ln27a13 0.453889
Kn8an27a14 Ln8a14 Ln27a14 0.453889
Kn8an27a15 Ln8a15 Ln27a15 0.453889
Kn8an27a16 Ln8a16 Ln27a16 0.453889
Kn8an28a1 Ln8a1 Ln28a1 0.450243
Kn8an28a2 Ln8a2 Ln28a2 0.450243
Kn8an28a3 Ln8a3 Ln28a3 0.450243
Kn8an28a4 Ln8a4 Ln28a4 0.450243
Kn8an28a5 Ln8a5 Ln28a5 0.450243
Kn8an28a6 Ln8a6 Ln28a6 0.450243
Kn8an28a7 Ln8a7 Ln28a7 0.450243
Kn8an28a8 Ln8a8 Ln28a8 0.450243
Kn8an28a9 Ln8a9 Ln28a9 0.450243
Kn8an28a10 Ln8a10 Ln28a10 0.450243
Kn8an28a11 Ln8a11 Ln28a11 0.450243
Kn8an28a12 Ln8a12 Ln28a12 0.450243
Kn8an28a13 Ln8a13 Ln28a13 0.450243
Kn8an28a14 Ln8a14 Ln28a14 0.450243
Kn8an28a15 Ln8a15 Ln28a15 0.450243
Kn8an28a16 Ln8a16 Ln28a16 0.450243
Kn8an29a1 Ln8a1 Ln29a1 0.447456
Kn8an29a2 Ln8a2 Ln29a2 0.447456
Kn8an29a3 Ln8a3 Ln29a3 0.447456
Kn8an29a4 Ln8a4 Ln29a4 0.447456
Kn8an29a5 Ln8a5 Ln29a5 0.447456
Kn8an29a6 Ln8a6 Ln29a6 0.447456
Kn8an29a7 Ln8a7 Ln29a7 0.447456
Kn8an29a8 Ln8a8 Ln29a8 0.447456
Kn8an29a9 Ln8a9 Ln29a9 0.447456
Kn8an29a10 Ln8a10 Ln29a10 0.447456
Kn8an29a11 Ln8a11 Ln29a11 0.447456
Kn8an29a12 Ln8a12 Ln29a12 0.447456
Kn8an29a13 Ln8a13 Ln29a13 0.447456
Kn8an29a14 Ln8a14 Ln29a14 0.447456
Kn8an29a15 Ln8a15 Ln29a15 0.447456
Kn8an29a16 Ln8a16 Ln29a16 0.447456
Kn8an30a1 Ln8a1 Ln30a1 0.445700
Kn8an30a2 Ln8a2 Ln30a2 0.445700
Kn8an30a3 Ln8a3 Ln30a3 0.445700
Kn8an30a4 Ln8a4 Ln30a4 0.445700
Kn8an30a5 Ln8a5 Ln30a5 0.445700
Kn8an30a6 Ln8a6 Ln30a6 0.445700
Kn8an30a7 Ln8a7 Ln30a7 0.445700
Kn8an30a8 Ln8a8 Ln30a8 0.445700
Kn8an30a9 Ln8a9 Ln30a9 0.445700
Kn8an30a10 Ln8a10 Ln30a10 0.445700
Kn8an30a11 Ln8a11 Ln30a11 0.445700
Kn8an30a12 Ln8a12 Ln30a12 0.445700
Kn8an30a13 Ln8a13 Ln30a13 0.445700
Kn8an30a14 Ln8a14 Ln30a14 0.445700
Kn8an30a15 Ln8a15 Ln30a15 0.445700
Kn8an30a16 Ln8a16 Ln30a16 0.445700
Kn8an31a1 Ln8a1 Ln31a1 0.444759
Kn8an31a2 Ln8a2 Ln31a2 0.444759
Kn8an31a3 Ln8a3 Ln31a3 0.444759
Kn8an31a4 Ln8a4 Ln31a4 0.444759
Kn8an31a5 Ln8a5 Ln31a5 0.444759
Kn8an31a6 Ln8a6 Ln31a6 0.444759
Kn8an31a7 Ln8a7 Ln31a7 0.444759
Kn8an31a8 Ln8a8 Ln31a8 0.444759
Kn8an31a9 Ln8a9 Ln31a9 0.444759
Kn8an31a10 Ln8a10 Ln31a10 0.444759
Kn8an31a11 Ln8a11 Ln31a11 0.444759
Kn8an31a12 Ln8a12 Ln31a12 0.444759
Kn8an31a13 Ln8a13 Ln31a13 0.444759
Kn8an31a14 Ln8a14 Ln31a14 0.444759
Kn8an31a15 Ln8a15 Ln31a15 0.444759
Kn8an31a16 Ln8a16 Ln31a16 0.444759
Kn8an32a1 Ln8a1 Ln32a1 0.443914
Kn8an32a2 Ln8a2 Ln32a2 0.443914
Kn8an32a3 Ln8a3 Ln32a3 0.443914
Kn8an32a4 Ln8a4 Ln32a4 0.443914
Kn8an32a5 Ln8a5 Ln32a5 0.443914
Kn8an32a6 Ln8a6 Ln32a6 0.443914
Kn8an32a7 Ln8a7 Ln32a7 0.443914
Kn8an32a8 Ln8a8 Ln32a8 0.443914
Kn8an32a9 Ln8a9 Ln32a9 0.443914
Kn8an32a10 Ln8a10 Ln32a10 0.443914
Kn8an32a11 Ln8a11 Ln32a11 0.443914
Kn8an32a12 Ln8a12 Ln32a12 0.443914
Kn8an32a13 Ln8a13 Ln32a13 0.443914
Kn8an32a14 Ln8a14 Ln32a14 0.443914
Kn8an32a15 Ln8a15 Ln32a15 0.443914
Kn8an32a16 Ln8a16 Ln32a16 0.443914
Kn8anva1 Ln8a1 Lnva1 0.443172
Kn8anva2 Ln8a2 Lnva2 0.443172
Kn8anva3 Ln8a3 Lnva3 0.443172
Kn8anva4 Ln8a4 Lnva4 0.443172
Kn8anva5 Ln8a5 Lnva5 0.443172
Kn8anva6 Ln8a6 Lnva6 0.443172
Kn8anva7 Ln8a7 Lnva7 0.443172
Kn8anva8 Ln8a8 Lnva8 0.443172
Kn8anva9 Ln8a9 Lnva9 0.443172
Kn8anva10 Ln8a10 Lnva10 0.443172
Kn8anva11 Ln8a11 Lnva11 0.443172
Kn8anva12 Ln8a12 Lnva12 0.443172
Kn8anva13 Ln8a13 Lnva13 0.443172
Kn8anva14 Ln8a14 Lnva14 0.443172
Kn8anva15 Ln8a15 Lnva15 0.443172
Kn8anva16 Ln8a16 Lnva16 0.443172
Kn9an10a1 Ln9a1 Ln10a1 0.805155
Kn9an10a2 Ln9a2 Ln10a2 0.805155
Kn9an10a3 Ln9a3 Ln10a3 0.805155
Kn9an10a4 Ln9a4 Ln10a4 0.805155
Kn9an10a5 Ln9a5 Ln10a5 0.805155
Kn9an10a6 Ln9a6 Ln10a6 0.805155
Kn9an10a7 Ln9a7 Ln10a7 0.805155
Kn9an10a8 Ln9a8 Ln10a8 0.805155
Kn9an10a9 Ln9a9 Ln10a9 0.805155
Kn9an10a10 Ln9a10 Ln10a10 0.805155
Kn9an10a11 Ln9a11 Ln10a11 0.805155
Kn9an10a12 Ln9a12 Ln10a12 0.805155
Kn9an10a13 Ln9a13 Ln10a13 0.805155
Kn9an10a14 Ln9a14 Ln10a14 0.805155
Kn9an10a15 Ln9a15 Ln10a15 0.805155
Kn9an10a16 Ln9a16 Ln10a16 0.805155
Kn9an11a1 Ln9a1 Ln11a1 0.723730
Kn9an11a2 Ln9a2 Ln11a2 0.723730
Kn9an11a3 Ln9a3 Ln11a3 0.723730
Kn9an11a4 Ln9a4 Ln11a4 0.723730
Kn9an11a5 Ln9a5 Ln11a5 0.723730
Kn9an11a6 Ln9a6 Ln11a6 0.723730
Kn9an11a7 Ln9a7 Ln11a7 0.723730
Kn9an11a8 Ln9a8 Ln11a8 0.723730
Kn9an11a9 Ln9a9 Ln11a9 0.723730
Kn9an11a10 Ln9a10 Ln11a10 0.723730
Kn9an11a11 Ln9a11 Ln11a11 0.723730
Kn9an11a12 Ln9a12 Ln11a12 0.723730
Kn9an11a13 Ln9a13 Ln11a13 0.723730
Kn9an11a14 Ln9a14 Ln11a14 0.723730
Kn9an11a15 Ln9a15 Ln11a15 0.723730
Kn9an11a16 Ln9a16 Ln11a16 0.723730
Kn9an12a1 Ln9a1 Ln12a1 0.675208
Kn9an12a2 Ln9a2 Ln12a2 0.675208
Kn9an12a3 Ln9a3 Ln12a3 0.675208
Kn9an12a4 Ln9a4 Ln12a4 0.675208
Kn9an12a5 Ln9a5 Ln12a5 0.675208
Kn9an12a6 Ln9a6 Ln12a6 0.675208
Kn9an12a7 Ln9a7 Ln12a7 0.675208
Kn9an12a8 Ln9a8 Ln12a8 0.675208
Kn9an12a9 Ln9a9 Ln12a9 0.675208
Kn9an12a10 Ln9a10 Ln12a10 0.675208
Kn9an12a11 Ln9a11 Ln12a11 0.675208
Kn9an12a12 Ln9a12 Ln12a12 0.675208
Kn9an12a13 Ln9a13 Ln12a13 0.675208
Kn9an12a14 Ln9a14 Ln12a14 0.675208
Kn9an12a15 Ln9a15 Ln12a15 0.675208
Kn9an12a16 Ln9a16 Ln12a16 0.675208
Kn9an13a1 Ln9a1 Ln13a1 0.640637
Kn9an13a2 Ln9a2 Ln13a2 0.640637
Kn9an13a3 Ln9a3 Ln13a3 0.640637
Kn9an13a4 Ln9a4 Ln13a4 0.640637
Kn9an13a5 Ln9a5 Ln13a5 0.640637
Kn9an13a6 Ln9a6 Ln13a6 0.640637
Kn9an13a7 Ln9a7 Ln13a7 0.640637
Kn9an13a8 Ln9a8 Ln13a8 0.640637
Kn9an13a9 Ln9a9 Ln13a9 0.640637
Kn9an13a10 Ln9a10 Ln13a10 0.640637
Kn9an13a11 Ln9a11 Ln13a11 0.640637
Kn9an13a12 Ln9a12 Ln13a12 0.640637
Kn9an13a13 Ln9a13 Ln13a13 0.640637
Kn9an13a14 Ln9a14 Ln13a14 0.640637
Kn9an13a15 Ln9a15 Ln13a15 0.640637
Kn9an13a16 Ln9a16 Ln13a16 0.640637
Kn9an14a1 Ln9a1 Ln14a1 0.613723
Kn9an14a2 Ln9a2 Ln14a2 0.613723
Kn9an14a3 Ln9a3 Ln14a3 0.613723
Kn9an14a4 Ln9a4 Ln14a4 0.613723
Kn9an14a5 Ln9a5 Ln14a5 0.613723
Kn9an14a6 Ln9a6 Ln14a6 0.613723
Kn9an14a7 Ln9a7 Ln14a7 0.613723
Kn9an14a8 Ln9a8 Ln14a8 0.613723
Kn9an14a9 Ln9a9 Ln14a9 0.613723
Kn9an14a10 Ln9a10 Ln14a10 0.613723
Kn9an14a11 Ln9a11 Ln14a11 0.613723
Kn9an14a12 Ln9a12 Ln14a12 0.613723
Kn9an14a13 Ln9a13 Ln14a13 0.613723
Kn9an14a14 Ln9a14 Ln14a14 0.613723
Kn9an14a15 Ln9a15 Ln14a15 0.613723
Kn9an14a16 Ln9a16 Ln14a16 0.613723
Kn9an15a1 Ln9a1 Ln15a1 0.591812
Kn9an15a2 Ln9a2 Ln15a2 0.591812
Kn9an15a3 Ln9a3 Ln15a3 0.591812
Kn9an15a4 Ln9a4 Ln15a4 0.591812
Kn9an15a5 Ln9a5 Ln15a5 0.591812
Kn9an15a6 Ln9a6 Ln15a6 0.591812
Kn9an15a7 Ln9a7 Ln15a7 0.591812
Kn9an15a8 Ln9a8 Ln15a8 0.591812
Kn9an15a9 Ln9a9 Ln15a9 0.591812
Kn9an15a10 Ln9a10 Ln15a10 0.591812
Kn9an15a11 Ln9a11 Ln15a11 0.591812
Kn9an15a12 Ln9a12 Ln15a12 0.591812
Kn9an15a13 Ln9a13 Ln15a13 0.591812
Kn9an15a14 Ln9a14 Ln15a14 0.591812
Kn9an15a15 Ln9a15 Ln15a15 0.591812
Kn9an15a16 Ln9a16 Ln15a16 0.591812
Kn9an16a1 Ln9a1 Ln16a1 0.573237
Kn9an16a2 Ln9a2 Ln16a2 0.573237
Kn9an16a3 Ln9a3 Ln16a3 0.573237
Kn9an16a4 Ln9a4 Ln16a4 0.573237
Kn9an16a5 Ln9a5 Ln16a5 0.573237
Kn9an16a6 Ln9a6 Ln16a6 0.573237
Kn9an16a7 Ln9a7 Ln16a7 0.573237
Kn9an16a8 Ln9a8 Ln16a8 0.573237
Kn9an16a9 Ln9a9 Ln16a9 0.573237
Kn9an16a10 Ln9a10 Ln16a10 0.573237
Kn9an16a11 Ln9a11 Ln16a11 0.573237
Kn9an16a12 Ln9a12 Ln16a12 0.573237
Kn9an16a13 Ln9a13 Ln16a13 0.573237
Kn9an16a14 Ln9a14 Ln16a14 0.573237
Kn9an16a15 Ln9a15 Ln16a15 0.573237
Kn9an16a16 Ln9a16 Ln16a16 0.573237
Kn9an17a1 Ln9a1 Ln17a1 0.557165
Kn9an17a2 Ln9a2 Ln17a2 0.557165
Kn9an17a3 Ln9a3 Ln17a3 0.557165
Kn9an17a4 Ln9a4 Ln17a4 0.557165
Kn9an17a5 Ln9a5 Ln17a5 0.557165
Kn9an17a6 Ln9a6 Ln17a6 0.557165
Kn9an17a7 Ln9a7 Ln17a7 0.557165
Kn9an17a8 Ln9a8 Ln17a8 0.557165
Kn9an17a9 Ln9a9 Ln17a9 0.557165
Kn9an17a10 Ln9a10 Ln17a10 0.557165
Kn9an17a11 Ln9a11 Ln17a11 0.557165
Kn9an17a12 Ln9a12 Ln17a12 0.557165
Kn9an17a13 Ln9a13 Ln17a13 0.557165
Kn9an17a14 Ln9a14 Ln17a14 0.557165
Kn9an17a15 Ln9a15 Ln17a15 0.557165
Kn9an17a16 Ln9a16 Ln17a16 0.557165
Kn9an18a1 Ln9a1 Ln18a1 0.542987
Kn9an18a2 Ln9a2 Ln18a2 0.542987
Kn9an18a3 Ln9a3 Ln18a3 0.542987
Kn9an18a4 Ln9a4 Ln18a4 0.542987
Kn9an18a5 Ln9a5 Ln18a5 0.542987
Kn9an18a6 Ln9a6 Ln18a6 0.542987
Kn9an18a7 Ln9a7 Ln18a7 0.542987
Kn9an18a8 Ln9a8 Ln18a8 0.542987
Kn9an18a9 Ln9a9 Ln18a9 0.542987
Kn9an18a10 Ln9a10 Ln18a10 0.542987
Kn9an18a11 Ln9a11 Ln18a11 0.542987
Kn9an18a12 Ln9a12 Ln18a12 0.542987
Kn9an18a13 Ln9a13 Ln18a13 0.542987
Kn9an18a14 Ln9a14 Ln18a14 0.542987
Kn9an18a15 Ln9a15 Ln18a15 0.542987
Kn9an18a16 Ln9a16 Ln18a16 0.542987
Kn9an19a1 Ln9a1 Ln19a1 0.529400
Kn9an19a2 Ln9a2 Ln19a2 0.529400
Kn9an19a3 Ln9a3 Ln19a3 0.529400
Kn9an19a4 Ln9a4 Ln19a4 0.529400
Kn9an19a5 Ln9a5 Ln19a5 0.529400
Kn9an19a6 Ln9a6 Ln19a6 0.529400
Kn9an19a7 Ln9a7 Ln19a7 0.529400
Kn9an19a8 Ln9a8 Ln19a8 0.529400
Kn9an19a9 Ln9a9 Ln19a9 0.529400
Kn9an19a10 Ln9a10 Ln19a10 0.529400
Kn9an19a11 Ln9a11 Ln19a11 0.529400
Kn9an19a12 Ln9a12 Ln19a12 0.529400
Kn9an19a13 Ln9a13 Ln19a13 0.529400
Kn9an19a14 Ln9a14 Ln19a14 0.529400
Kn9an19a15 Ln9a15 Ln19a15 0.529400
Kn9an19a16 Ln9a16 Ln19a16 0.529400
Kn9an20a1 Ln9a1 Ln20a1 0.516943
Kn9an20a2 Ln9a2 Ln20a2 0.516943
Kn9an20a3 Ln9a3 Ln20a3 0.516943
Kn9an20a4 Ln9a4 Ln20a4 0.516943
Kn9an20a5 Ln9a5 Ln20a5 0.516943
Kn9an20a6 Ln9a6 Ln20a6 0.516943
Kn9an20a7 Ln9a7 Ln20a7 0.516943
Kn9an20a8 Ln9a8 Ln20a8 0.516943
Kn9an20a9 Ln9a9 Ln20a9 0.516943
Kn9an20a10 Ln9a10 Ln20a10 0.516943
Kn9an20a11 Ln9a11 Ln20a11 0.516943
Kn9an20a12 Ln9a12 Ln20a12 0.516943
Kn9an20a13 Ln9a13 Ln20a13 0.516943
Kn9an20a14 Ln9a14 Ln20a14 0.516943
Kn9an20a15 Ln9a15 Ln20a15 0.516943
Kn9an20a16 Ln9a16 Ln20a16 0.516943
Kn9an21a1 Ln9a1 Ln21a1 0.505455
Kn9an21a2 Ln9a2 Ln21a2 0.505455
Kn9an21a3 Ln9a3 Ln21a3 0.505455
Kn9an21a4 Ln9a4 Ln21a4 0.505455
Kn9an21a5 Ln9a5 Ln21a5 0.505455
Kn9an21a6 Ln9a6 Ln21a6 0.505455
Kn9an21a7 Ln9a7 Ln21a7 0.505455
Kn9an21a8 Ln9a8 Ln21a8 0.505455
Kn9an21a9 Ln9a9 Ln21a9 0.505455
Kn9an21a10 Ln9a10 Ln21a10 0.505455
Kn9an21a11 Ln9a11 Ln21a11 0.505455
Kn9an21a12 Ln9a12 Ln21a12 0.505455
Kn9an21a13 Ln9a13 Ln21a13 0.505455
Kn9an21a14 Ln9a14 Ln21a14 0.505455
Kn9an21a15 Ln9a15 Ln21a15 0.505455
Kn9an21a16 Ln9a16 Ln21a16 0.505455
Kn9an22a1 Ln9a1 Ln22a1 0.494887
Kn9an22a2 Ln9a2 Ln22a2 0.494887
Kn9an22a3 Ln9a3 Ln22a3 0.494887
Kn9an22a4 Ln9a4 Ln22a4 0.494887
Kn9an22a5 Ln9a5 Ln22a5 0.494887
Kn9an22a6 Ln9a6 Ln22a6 0.494887
Kn9an22a7 Ln9a7 Ln22a7 0.494887
Kn9an22a8 Ln9a8 Ln22a8 0.494887
Kn9an22a9 Ln9a9 Ln22a9 0.494887
Kn9an22a10 Ln9a10 Ln22a10 0.494887
Kn9an22a11 Ln9a11 Ln22a11 0.494887
Kn9an22a12 Ln9a12 Ln22a12 0.494887
Kn9an22a13 Ln9a13 Ln22a13 0.494887
Kn9an22a14 Ln9a14 Ln22a14 0.494887
Kn9an22a15 Ln9a15 Ln22a15 0.494887
Kn9an22a16 Ln9a16 Ln22a16 0.494887
Kn9an23a1 Ln9a1 Ln23a1 0.485771
Kn9an23a2 Ln9a2 Ln23a2 0.485771
Kn9an23a3 Ln9a3 Ln23a3 0.485771
Kn9an23a4 Ln9a4 Ln23a4 0.485771
Kn9an23a5 Ln9a5 Ln23a5 0.485771
Kn9an23a6 Ln9a6 Ln23a6 0.485771
Kn9an23a7 Ln9a7 Ln23a7 0.485771
Kn9an23a8 Ln9a8 Ln23a8 0.485771
Kn9an23a9 Ln9a9 Ln23a9 0.485771
Kn9an23a10 Ln9a10 Ln23a10 0.485771
Kn9an23a11 Ln9a11 Ln23a11 0.485771
Kn9an23a12 Ln9a12 Ln23a12 0.485771
Kn9an23a13 Ln9a13 Ln23a13 0.485771
Kn9an23a14 Ln9a14 Ln23a14 0.485771
Kn9an23a15 Ln9a15 Ln23a15 0.485771
Kn9an23a16 Ln9a16 Ln23a16 0.485771
Kn9an24a1 Ln9a1 Ln24a1 0.477226
Kn9an24a2 Ln9a2 Ln24a2 0.477226
Kn9an24a3 Ln9a3 Ln24a3 0.477226
Kn9an24a4 Ln9a4 Ln24a4 0.477226
Kn9an24a5 Ln9a5 Ln24a5 0.477226
Kn9an24a6 Ln9a6 Ln24a6 0.477226
Kn9an24a7 Ln9a7 Ln24a7 0.477226
Kn9an24a8 Ln9a8 Ln24a8 0.477226
Kn9an24a9 Ln9a9 Ln24a9 0.477226
Kn9an24a10 Ln9a10 Ln24a10 0.477226
Kn9an24a11 Ln9a11 Ln24a11 0.477226
Kn9an24a12 Ln9a12 Ln24a12 0.477226
Kn9an24a13 Ln9a13 Ln24a13 0.477226
Kn9an24a14 Ln9a14 Ln24a14 0.477226
Kn9an24a15 Ln9a15 Ln24a15 0.477226
Kn9an24a16 Ln9a16 Ln24a16 0.477226
Kn9an25a1 Ln9a1 Ln25a1 0.469680
Kn9an25a2 Ln9a2 Ln25a2 0.469680
Kn9an25a3 Ln9a3 Ln25a3 0.469680
Kn9an25a4 Ln9a4 Ln25a4 0.469680
Kn9an25a5 Ln9a5 Ln25a5 0.469680
Kn9an25a6 Ln9a6 Ln25a6 0.469680
Kn9an25a7 Ln9a7 Ln25a7 0.469680
Kn9an25a8 Ln9a8 Ln25a8 0.469680
Kn9an25a9 Ln9a9 Ln25a9 0.469680
Kn9an25a10 Ln9a10 Ln25a10 0.469680
Kn9an25a11 Ln9a11 Ln25a11 0.469680
Kn9an25a12 Ln9a12 Ln25a12 0.469680
Kn9an25a13 Ln9a13 Ln25a13 0.469680
Kn9an25a14 Ln9a14 Ln25a14 0.469680
Kn9an25a15 Ln9a15 Ln25a15 0.469680
Kn9an25a16 Ln9a16 Ln25a16 0.469680
Kn9an26a1 Ln9a1 Ln26a1 0.463523
Kn9an26a2 Ln9a2 Ln26a2 0.463523
Kn9an26a3 Ln9a3 Ln26a3 0.463523
Kn9an26a4 Ln9a4 Ln26a4 0.463523
Kn9an26a5 Ln9a5 Ln26a5 0.463523
Kn9an26a6 Ln9a6 Ln26a6 0.463523
Kn9an26a7 Ln9a7 Ln26a7 0.463523
Kn9an26a8 Ln9a8 Ln26a8 0.463523
Kn9an26a9 Ln9a9 Ln26a9 0.463523
Kn9an26a10 Ln9a10 Ln26a10 0.463523
Kn9an26a11 Ln9a11 Ln26a11 0.463523
Kn9an26a12 Ln9a12 Ln26a12 0.463523
Kn9an26a13 Ln9a13 Ln26a13 0.463523
Kn9an26a14 Ln9a14 Ln26a14 0.463523
Kn9an26a15 Ln9a15 Ln26a15 0.463523
Kn9an26a16 Ln9a16 Ln26a16 0.463523
Kn9an27a1 Ln9a1 Ln27a1 0.458074
Kn9an27a2 Ln9a2 Ln27a2 0.458074
Kn9an27a3 Ln9a3 Ln27a3 0.458074
Kn9an27a4 Ln9a4 Ln27a4 0.458074
Kn9an27a5 Ln9a5 Ln27a5 0.458074
Kn9an27a6 Ln9a6 Ln27a6 0.458074
Kn9an27a7 Ln9a7 Ln27a7 0.458074
Kn9an27a8 Ln9a8 Ln27a8 0.458074
Kn9an27a9 Ln9a9 Ln27a9 0.458074
Kn9an27a10 Ln9a10 Ln27a10 0.458074
Kn9an27a11 Ln9a11 Ln27a11 0.458074
Kn9an27a12 Ln9a12 Ln27a12 0.458074
Kn9an27a13 Ln9a13 Ln27a13 0.458074
Kn9an27a14 Ln9a14 Ln27a14 0.458074
Kn9an27a15 Ln9a15 Ln27a15 0.458074
Kn9an27a16 Ln9a16 Ln27a16 0.458074
Kn9an28a1 Ln9a1 Ln28a1 0.453889
Kn9an28a2 Ln9a2 Ln28a2 0.453889
Kn9an28a3 Ln9a3 Ln28a3 0.453889
Kn9an28a4 Ln9a4 Ln28a4 0.453889
Kn9an28a5 Ln9a5 Ln28a5 0.453889
Kn9an28a6 Ln9a6 Ln28a6 0.453889
Kn9an28a7 Ln9a7 Ln28a7 0.453889
Kn9an28a8 Ln9a8 Ln28a8 0.453889
Kn9an28a9 Ln9a9 Ln28a9 0.453889
Kn9an28a10 Ln9a10 Ln28a10 0.453889
Kn9an28a11 Ln9a11 Ln28a11 0.453889
Kn9an28a12 Ln9a12 Ln28a12 0.453889
Kn9an28a13 Ln9a13 Ln28a13 0.453889
Kn9an28a14 Ln9a14 Ln28a14 0.453889
Kn9an28a15 Ln9a15 Ln28a15 0.453889
Kn9an28a16 Ln9a16 Ln28a16 0.453889
Kn9an29a1 Ln9a1 Ln29a1 0.450243
Kn9an29a2 Ln9a2 Ln29a2 0.450243
Kn9an29a3 Ln9a3 Ln29a3 0.450243
Kn9an29a4 Ln9a4 Ln29a4 0.450243
Kn9an29a5 Ln9a5 Ln29a5 0.450243
Kn9an29a6 Ln9a6 Ln29a6 0.450243
Kn9an29a7 Ln9a7 Ln29a7 0.450243
Kn9an29a8 Ln9a8 Ln29a8 0.450243
Kn9an29a9 Ln9a9 Ln29a9 0.450243
Kn9an29a10 Ln9a10 Ln29a10 0.450243
Kn9an29a11 Ln9a11 Ln29a11 0.450243
Kn9an29a12 Ln9a12 Ln29a12 0.450243
Kn9an29a13 Ln9a13 Ln29a13 0.450243
Kn9an29a14 Ln9a14 Ln29a14 0.450243
Kn9an29a15 Ln9a15 Ln29a15 0.450243
Kn9an29a16 Ln9a16 Ln29a16 0.450243
Kn9an30a1 Ln9a1 Ln30a1 0.447456
Kn9an30a2 Ln9a2 Ln30a2 0.447456
Kn9an30a3 Ln9a3 Ln30a3 0.447456
Kn9an30a4 Ln9a4 Ln30a4 0.447456
Kn9an30a5 Ln9a5 Ln30a5 0.447456
Kn9an30a6 Ln9a6 Ln30a6 0.447456
Kn9an30a7 Ln9a7 Ln30a7 0.447456
Kn9an30a8 Ln9a8 Ln30a8 0.447456
Kn9an30a9 Ln9a9 Ln30a9 0.447456
Kn9an30a10 Ln9a10 Ln30a10 0.447456
Kn9an30a11 Ln9a11 Ln30a11 0.447456
Kn9an30a12 Ln9a12 Ln30a12 0.447456
Kn9an30a13 Ln9a13 Ln30a13 0.447456
Kn9an30a14 Ln9a14 Ln30a14 0.447456
Kn9an30a15 Ln9a15 Ln30a15 0.447456
Kn9an30a16 Ln9a16 Ln30a16 0.447456
Kn9an31a1 Ln9a1 Ln31a1 0.445700
Kn9an31a2 Ln9a2 Ln31a2 0.445700
Kn9an31a3 Ln9a3 Ln31a3 0.445700
Kn9an31a4 Ln9a4 Ln31a4 0.445700
Kn9an31a5 Ln9a5 Ln31a5 0.445700
Kn9an31a6 Ln9a6 Ln31a6 0.445700
Kn9an31a7 Ln9a7 Ln31a7 0.445700
Kn9an31a8 Ln9a8 Ln31a8 0.445700
Kn9an31a9 Ln9a9 Ln31a9 0.445700
Kn9an31a10 Ln9a10 Ln31a10 0.445700
Kn9an31a11 Ln9a11 Ln31a11 0.445700
Kn9an31a12 Ln9a12 Ln31a12 0.445700
Kn9an31a13 Ln9a13 Ln31a13 0.445700
Kn9an31a14 Ln9a14 Ln31a14 0.445700
Kn9an31a15 Ln9a15 Ln31a15 0.445700
Kn9an31a16 Ln9a16 Ln31a16 0.445700
Kn9an32a1 Ln9a1 Ln32a1 0.444759
Kn9an32a2 Ln9a2 Ln32a2 0.444759
Kn9an32a3 Ln9a3 Ln32a3 0.444759
Kn9an32a4 Ln9a4 Ln32a4 0.444759
Kn9an32a5 Ln9a5 Ln32a5 0.444759
Kn9an32a6 Ln9a6 Ln32a6 0.444759
Kn9an32a7 Ln9a7 Ln32a7 0.444759
Kn9an32a8 Ln9a8 Ln32a8 0.444759
Kn9an32a9 Ln9a9 Ln32a9 0.444759
Kn9an32a10 Ln9a10 Ln32a10 0.444759
Kn9an32a11 Ln9a11 Ln32a11 0.444759
Kn9an32a12 Ln9a12 Ln32a12 0.444759
Kn9an32a13 Ln9a13 Ln32a13 0.444759
Kn9an32a14 Ln9a14 Ln32a14 0.444759
Kn9an32a15 Ln9a15 Ln32a15 0.444759
Kn9an32a16 Ln9a16 Ln32a16 0.444759
Kn9anva1 Ln9a1 Lnva1 0.443914
Kn9anva2 Ln9a2 Lnva2 0.443914
Kn9anva3 Ln9a3 Lnva3 0.443914
Kn9anva4 Ln9a4 Lnva4 0.443914
Kn9anva5 Ln9a5 Lnva5 0.443914
Kn9anva6 Ln9a6 Lnva6 0.443914
Kn9anva7 Ln9a7 Lnva7 0.443914
Kn9anva8 Ln9a8 Lnva8 0.443914
Kn9anva9 Ln9a9 Lnva9 0.443914
Kn9anva10 Ln9a10 Lnva10 0.443914
Kn9anva11 Ln9a11 Lnva11 0.443914
Kn9anva12 Ln9a12 Lnva12 0.443914
Kn9anva13 Ln9a13 Lnva13 0.443914
Kn9anva14 Ln9a14 Lnva14 0.443914
Kn9anva15 Ln9a15 Lnva15 0.443914
Kn9anva16 Ln9a16 Lnva16 0.443914
Kn10an11a1 Ln10a1 Ln11a1 0.805155
Kn10an11a2 Ln10a2 Ln11a2 0.805155
Kn10an11a3 Ln10a3 Ln11a3 0.805155
Kn10an11a4 Ln10a4 Ln11a4 0.805155
Kn10an11a5 Ln10a5 Ln11a5 0.805155
Kn10an11a6 Ln10a6 Ln11a6 0.805155
Kn10an11a7 Ln10a7 Ln11a7 0.805155
Kn10an11a8 Ln10a8 Ln11a8 0.805155
Kn10an11a9 Ln10a9 Ln11a9 0.805155
Kn10an11a10 Ln10a10 Ln11a10 0.805155
Kn10an11a11 Ln10a11 Ln11a11 0.805155
Kn10an11a12 Ln10a12 Ln11a12 0.805155
Kn10an11a13 Ln10a13 Ln11a13 0.805155
Kn10an11a14 Ln10a14 Ln11a14 0.805155
Kn10an11a15 Ln10a15 Ln11a15 0.805155
Kn10an11a16 Ln10a16 Ln11a16 0.805155
Kn10an12a1 Ln10a1 Ln12a1 0.723730
Kn10an12a2 Ln10a2 Ln12a2 0.723730
Kn10an12a3 Ln10a3 Ln12a3 0.723730
Kn10an12a4 Ln10a4 Ln12a4 0.723730
Kn10an12a5 Ln10a5 Ln12a5 0.723730
Kn10an12a6 Ln10a6 Ln12a6 0.723730
Kn10an12a7 Ln10a7 Ln12a7 0.723730
Kn10an12a8 Ln10a8 Ln12a8 0.723730
Kn10an12a9 Ln10a9 Ln12a9 0.723730
Kn10an12a10 Ln10a10 Ln12a10 0.723730
Kn10an12a11 Ln10a11 Ln12a11 0.723730
Kn10an12a12 Ln10a12 Ln12a12 0.723730
Kn10an12a13 Ln10a13 Ln12a13 0.723730
Kn10an12a14 Ln10a14 Ln12a14 0.723730
Kn10an12a15 Ln10a15 Ln12a15 0.723730
Kn10an12a16 Ln10a16 Ln12a16 0.723730
Kn10an13a1 Ln10a1 Ln13a1 0.675208
Kn10an13a2 Ln10a2 Ln13a2 0.675208
Kn10an13a3 Ln10a3 Ln13a3 0.675208
Kn10an13a4 Ln10a4 Ln13a4 0.675208
Kn10an13a5 Ln10a5 Ln13a5 0.675208
Kn10an13a6 Ln10a6 Ln13a6 0.675208
Kn10an13a7 Ln10a7 Ln13a7 0.675208
Kn10an13a8 Ln10a8 Ln13a8 0.675208
Kn10an13a9 Ln10a9 Ln13a9 0.675208
Kn10an13a10 Ln10a10 Ln13a10 0.675208
Kn10an13a11 Ln10a11 Ln13a11 0.675208
Kn10an13a12 Ln10a12 Ln13a12 0.675208
Kn10an13a13 Ln10a13 Ln13a13 0.675208
Kn10an13a14 Ln10a14 Ln13a14 0.675208
Kn10an13a15 Ln10a15 Ln13a15 0.675208
Kn10an13a16 Ln10a16 Ln13a16 0.675208
Kn10an14a1 Ln10a1 Ln14a1 0.640637
Kn10an14a2 Ln10a2 Ln14a2 0.640637
Kn10an14a3 Ln10a3 Ln14a3 0.640637
Kn10an14a4 Ln10a4 Ln14a4 0.640637
Kn10an14a5 Ln10a5 Ln14a5 0.640637
Kn10an14a6 Ln10a6 Ln14a6 0.640637
Kn10an14a7 Ln10a7 Ln14a7 0.640637
Kn10an14a8 Ln10a8 Ln14a8 0.640637
Kn10an14a9 Ln10a9 Ln14a9 0.640637
Kn10an14a10 Ln10a10 Ln14a10 0.640637
Kn10an14a11 Ln10a11 Ln14a11 0.640637
Kn10an14a12 Ln10a12 Ln14a12 0.640637
Kn10an14a13 Ln10a13 Ln14a13 0.640637
Kn10an14a14 Ln10a14 Ln14a14 0.640637
Kn10an14a15 Ln10a15 Ln14a15 0.640637
Kn10an14a16 Ln10a16 Ln14a16 0.640637
Kn10an15a1 Ln10a1 Ln15a1 0.613723
Kn10an15a2 Ln10a2 Ln15a2 0.613723
Kn10an15a3 Ln10a3 Ln15a3 0.613723
Kn10an15a4 Ln10a4 Ln15a4 0.613723
Kn10an15a5 Ln10a5 Ln15a5 0.613723
Kn10an15a6 Ln10a6 Ln15a6 0.613723
Kn10an15a7 Ln10a7 Ln15a7 0.613723
Kn10an15a8 Ln10a8 Ln15a8 0.613723
Kn10an15a9 Ln10a9 Ln15a9 0.613723
Kn10an15a10 Ln10a10 Ln15a10 0.613723
Kn10an15a11 Ln10a11 Ln15a11 0.613723
Kn10an15a12 Ln10a12 Ln15a12 0.613723
Kn10an15a13 Ln10a13 Ln15a13 0.613723
Kn10an15a14 Ln10a14 Ln15a14 0.613723
Kn10an15a15 Ln10a15 Ln15a15 0.613723
Kn10an15a16 Ln10a16 Ln15a16 0.613723
Kn10an16a1 Ln10a1 Ln16a1 0.591812
Kn10an16a2 Ln10a2 Ln16a2 0.591812
Kn10an16a3 Ln10a3 Ln16a3 0.591812
Kn10an16a4 Ln10a4 Ln16a4 0.591812
Kn10an16a5 Ln10a5 Ln16a5 0.591812
Kn10an16a6 Ln10a6 Ln16a6 0.591812
Kn10an16a7 Ln10a7 Ln16a7 0.591812
Kn10an16a8 Ln10a8 Ln16a8 0.591812
Kn10an16a9 Ln10a9 Ln16a9 0.591812
Kn10an16a10 Ln10a10 Ln16a10 0.591812
Kn10an16a11 Ln10a11 Ln16a11 0.591812
Kn10an16a12 Ln10a12 Ln16a12 0.591812
Kn10an16a13 Ln10a13 Ln16a13 0.591812
Kn10an16a14 Ln10a14 Ln16a14 0.591812
Kn10an16a15 Ln10a15 Ln16a15 0.591812
Kn10an16a16 Ln10a16 Ln16a16 0.591812
Kn10an17a1 Ln10a1 Ln17a1 0.573237
Kn10an17a2 Ln10a2 Ln17a2 0.573237
Kn10an17a3 Ln10a3 Ln17a3 0.573237
Kn10an17a4 Ln10a4 Ln17a4 0.573237
Kn10an17a5 Ln10a5 Ln17a5 0.573237
Kn10an17a6 Ln10a6 Ln17a6 0.573237
Kn10an17a7 Ln10a7 Ln17a7 0.573237
Kn10an17a8 Ln10a8 Ln17a8 0.573237
Kn10an17a9 Ln10a9 Ln17a9 0.573237
Kn10an17a10 Ln10a10 Ln17a10 0.573237
Kn10an17a11 Ln10a11 Ln17a11 0.573237
Kn10an17a12 Ln10a12 Ln17a12 0.573237
Kn10an17a13 Ln10a13 Ln17a13 0.573237
Kn10an17a14 Ln10a14 Ln17a14 0.573237
Kn10an17a15 Ln10a15 Ln17a15 0.573237
Kn10an17a16 Ln10a16 Ln17a16 0.573237
Kn10an18a1 Ln10a1 Ln18a1 0.557165
Kn10an18a2 Ln10a2 Ln18a2 0.557165
Kn10an18a3 Ln10a3 Ln18a3 0.557165
Kn10an18a4 Ln10a4 Ln18a4 0.557165
Kn10an18a5 Ln10a5 Ln18a5 0.557165
Kn10an18a6 Ln10a6 Ln18a6 0.557165
Kn10an18a7 Ln10a7 Ln18a7 0.557165
Kn10an18a8 Ln10a8 Ln18a8 0.557165
Kn10an18a9 Ln10a9 Ln18a9 0.557165
Kn10an18a10 Ln10a10 Ln18a10 0.557165
Kn10an18a11 Ln10a11 Ln18a11 0.557165
Kn10an18a12 Ln10a12 Ln18a12 0.557165
Kn10an18a13 Ln10a13 Ln18a13 0.557165
Kn10an18a14 Ln10a14 Ln18a14 0.557165
Kn10an18a15 Ln10a15 Ln18a15 0.557165
Kn10an18a16 Ln10a16 Ln18a16 0.557165
Kn10an19a1 Ln10a1 Ln19a1 0.542987
Kn10an19a2 Ln10a2 Ln19a2 0.542987
Kn10an19a3 Ln10a3 Ln19a3 0.542987
Kn10an19a4 Ln10a4 Ln19a4 0.542987
Kn10an19a5 Ln10a5 Ln19a5 0.542987
Kn10an19a6 Ln10a6 Ln19a6 0.542987
Kn10an19a7 Ln10a7 Ln19a7 0.542987
Kn10an19a8 Ln10a8 Ln19a8 0.542987
Kn10an19a9 Ln10a9 Ln19a9 0.542987
Kn10an19a10 Ln10a10 Ln19a10 0.542987
Kn10an19a11 Ln10a11 Ln19a11 0.542987
Kn10an19a12 Ln10a12 Ln19a12 0.542987
Kn10an19a13 Ln10a13 Ln19a13 0.542987
Kn10an19a14 Ln10a14 Ln19a14 0.542987
Kn10an19a15 Ln10a15 Ln19a15 0.542987
Kn10an19a16 Ln10a16 Ln19a16 0.542987
Kn10an20a1 Ln10a1 Ln20a1 0.529400
Kn10an20a2 Ln10a2 Ln20a2 0.529400
Kn10an20a3 Ln10a3 Ln20a3 0.529400
Kn10an20a4 Ln10a4 Ln20a4 0.529400
Kn10an20a5 Ln10a5 Ln20a5 0.529400
Kn10an20a6 Ln10a6 Ln20a6 0.529400
Kn10an20a7 Ln10a7 Ln20a7 0.529400
Kn10an20a8 Ln10a8 Ln20a8 0.529400
Kn10an20a9 Ln10a9 Ln20a9 0.529400
Kn10an20a10 Ln10a10 Ln20a10 0.529400
Kn10an20a11 Ln10a11 Ln20a11 0.529400
Kn10an20a12 Ln10a12 Ln20a12 0.529400
Kn10an20a13 Ln10a13 Ln20a13 0.529400
Kn10an20a14 Ln10a14 Ln20a14 0.529400
Kn10an20a15 Ln10a15 Ln20a15 0.529400
Kn10an20a16 Ln10a16 Ln20a16 0.529400
Kn10an21a1 Ln10a1 Ln21a1 0.516943
Kn10an21a2 Ln10a2 Ln21a2 0.516943
Kn10an21a3 Ln10a3 Ln21a3 0.516943
Kn10an21a4 Ln10a4 Ln21a4 0.516943
Kn10an21a5 Ln10a5 Ln21a5 0.516943
Kn10an21a6 Ln10a6 Ln21a6 0.516943
Kn10an21a7 Ln10a7 Ln21a7 0.516943
Kn10an21a8 Ln10a8 Ln21a8 0.516943
Kn10an21a9 Ln10a9 Ln21a9 0.516943
Kn10an21a10 Ln10a10 Ln21a10 0.516943
Kn10an21a11 Ln10a11 Ln21a11 0.516943
Kn10an21a12 Ln10a12 Ln21a12 0.516943
Kn10an21a13 Ln10a13 Ln21a13 0.516943
Kn10an21a14 Ln10a14 Ln21a14 0.516943
Kn10an21a15 Ln10a15 Ln21a15 0.516943
Kn10an21a16 Ln10a16 Ln21a16 0.516943
Kn10an22a1 Ln10a1 Ln22a1 0.505455
Kn10an22a2 Ln10a2 Ln22a2 0.505455
Kn10an22a3 Ln10a3 Ln22a3 0.505455
Kn10an22a4 Ln10a4 Ln22a4 0.505455
Kn10an22a5 Ln10a5 Ln22a5 0.505455
Kn10an22a6 Ln10a6 Ln22a6 0.505455
Kn10an22a7 Ln10a7 Ln22a7 0.505455
Kn10an22a8 Ln10a8 Ln22a8 0.505455
Kn10an22a9 Ln10a9 Ln22a9 0.505455
Kn10an22a10 Ln10a10 Ln22a10 0.505455
Kn10an22a11 Ln10a11 Ln22a11 0.505455
Kn10an22a12 Ln10a12 Ln22a12 0.505455
Kn10an22a13 Ln10a13 Ln22a13 0.505455
Kn10an22a14 Ln10a14 Ln22a14 0.505455
Kn10an22a15 Ln10a15 Ln22a15 0.505455
Kn10an22a16 Ln10a16 Ln22a16 0.505455
Kn10an23a1 Ln10a1 Ln23a1 0.494887
Kn10an23a2 Ln10a2 Ln23a2 0.494887
Kn10an23a3 Ln10a3 Ln23a3 0.494887
Kn10an23a4 Ln10a4 Ln23a4 0.494887
Kn10an23a5 Ln10a5 Ln23a5 0.494887
Kn10an23a6 Ln10a6 Ln23a6 0.494887
Kn10an23a7 Ln10a7 Ln23a7 0.494887
Kn10an23a8 Ln10a8 Ln23a8 0.494887
Kn10an23a9 Ln10a9 Ln23a9 0.494887
Kn10an23a10 Ln10a10 Ln23a10 0.494887
Kn10an23a11 Ln10a11 Ln23a11 0.494887
Kn10an23a12 Ln10a12 Ln23a12 0.494887
Kn10an23a13 Ln10a13 Ln23a13 0.494887
Kn10an23a14 Ln10a14 Ln23a14 0.494887
Kn10an23a15 Ln10a15 Ln23a15 0.494887
Kn10an23a16 Ln10a16 Ln23a16 0.494887
Kn10an24a1 Ln10a1 Ln24a1 0.485771
Kn10an24a2 Ln10a2 Ln24a2 0.485771
Kn10an24a3 Ln10a3 Ln24a3 0.485771
Kn10an24a4 Ln10a4 Ln24a4 0.485771
Kn10an24a5 Ln10a5 Ln24a5 0.485771
Kn10an24a6 Ln10a6 Ln24a6 0.485771
Kn10an24a7 Ln10a7 Ln24a7 0.485771
Kn10an24a8 Ln10a8 Ln24a8 0.485771
Kn10an24a9 Ln10a9 Ln24a9 0.485771
Kn10an24a10 Ln10a10 Ln24a10 0.485771
Kn10an24a11 Ln10a11 Ln24a11 0.485771
Kn10an24a12 Ln10a12 Ln24a12 0.485771
Kn10an24a13 Ln10a13 Ln24a13 0.485771
Kn10an24a14 Ln10a14 Ln24a14 0.485771
Kn10an24a15 Ln10a15 Ln24a15 0.485771
Kn10an24a16 Ln10a16 Ln24a16 0.485771
Kn10an25a1 Ln10a1 Ln25a1 0.477226
Kn10an25a2 Ln10a2 Ln25a2 0.477226
Kn10an25a3 Ln10a3 Ln25a3 0.477226
Kn10an25a4 Ln10a4 Ln25a4 0.477226
Kn10an25a5 Ln10a5 Ln25a5 0.477226
Kn10an25a6 Ln10a6 Ln25a6 0.477226
Kn10an25a7 Ln10a7 Ln25a7 0.477226
Kn10an25a8 Ln10a8 Ln25a8 0.477226
Kn10an25a9 Ln10a9 Ln25a9 0.477226
Kn10an25a10 Ln10a10 Ln25a10 0.477226
Kn10an25a11 Ln10a11 Ln25a11 0.477226
Kn10an25a12 Ln10a12 Ln25a12 0.477226
Kn10an25a13 Ln10a13 Ln25a13 0.477226
Kn10an25a14 Ln10a14 Ln25a14 0.477226
Kn10an25a15 Ln10a15 Ln25a15 0.477226
Kn10an25a16 Ln10a16 Ln25a16 0.477226
Kn10an26a1 Ln10a1 Ln26a1 0.469680
Kn10an26a2 Ln10a2 Ln26a2 0.469680
Kn10an26a3 Ln10a3 Ln26a3 0.469680
Kn10an26a4 Ln10a4 Ln26a4 0.469680
Kn10an26a5 Ln10a5 Ln26a5 0.469680
Kn10an26a6 Ln10a6 Ln26a6 0.469680
Kn10an26a7 Ln10a7 Ln26a7 0.469680
Kn10an26a8 Ln10a8 Ln26a8 0.469680
Kn10an26a9 Ln10a9 Ln26a9 0.469680
Kn10an26a10 Ln10a10 Ln26a10 0.469680
Kn10an26a11 Ln10a11 Ln26a11 0.469680
Kn10an26a12 Ln10a12 Ln26a12 0.469680
Kn10an26a13 Ln10a13 Ln26a13 0.469680
Kn10an26a14 Ln10a14 Ln26a14 0.469680
Kn10an26a15 Ln10a15 Ln26a15 0.469680
Kn10an26a16 Ln10a16 Ln26a16 0.469680
Kn10an27a1 Ln10a1 Ln27a1 0.463523
Kn10an27a2 Ln10a2 Ln27a2 0.463523
Kn10an27a3 Ln10a3 Ln27a3 0.463523
Kn10an27a4 Ln10a4 Ln27a4 0.463523
Kn10an27a5 Ln10a5 Ln27a5 0.463523
Kn10an27a6 Ln10a6 Ln27a6 0.463523
Kn10an27a7 Ln10a7 Ln27a7 0.463523
Kn10an27a8 Ln10a8 Ln27a8 0.463523
Kn10an27a9 Ln10a9 Ln27a9 0.463523
Kn10an27a10 Ln10a10 Ln27a10 0.463523
Kn10an27a11 Ln10a11 Ln27a11 0.463523
Kn10an27a12 Ln10a12 Ln27a12 0.463523
Kn10an27a13 Ln10a13 Ln27a13 0.463523
Kn10an27a14 Ln10a14 Ln27a14 0.463523
Kn10an27a15 Ln10a15 Ln27a15 0.463523
Kn10an27a16 Ln10a16 Ln27a16 0.463523
Kn10an28a1 Ln10a1 Ln28a1 0.458074
Kn10an28a2 Ln10a2 Ln28a2 0.458074
Kn10an28a3 Ln10a3 Ln28a3 0.458074
Kn10an28a4 Ln10a4 Ln28a4 0.458074
Kn10an28a5 Ln10a5 Ln28a5 0.458074
Kn10an28a6 Ln10a6 Ln28a6 0.458074
Kn10an28a7 Ln10a7 Ln28a7 0.458074
Kn10an28a8 Ln10a8 Ln28a8 0.458074
Kn10an28a9 Ln10a9 Ln28a9 0.458074
Kn10an28a10 Ln10a10 Ln28a10 0.458074
Kn10an28a11 Ln10a11 Ln28a11 0.458074
Kn10an28a12 Ln10a12 Ln28a12 0.458074
Kn10an28a13 Ln10a13 Ln28a13 0.458074
Kn10an28a14 Ln10a14 Ln28a14 0.458074
Kn10an28a15 Ln10a15 Ln28a15 0.458074
Kn10an28a16 Ln10a16 Ln28a16 0.458074
Kn10an29a1 Ln10a1 Ln29a1 0.453889
Kn10an29a2 Ln10a2 Ln29a2 0.453889
Kn10an29a3 Ln10a3 Ln29a3 0.453889
Kn10an29a4 Ln10a4 Ln29a4 0.453889
Kn10an29a5 Ln10a5 Ln29a5 0.453889
Kn10an29a6 Ln10a6 Ln29a6 0.453889
Kn10an29a7 Ln10a7 Ln29a7 0.453889
Kn10an29a8 Ln10a8 Ln29a8 0.453889
Kn10an29a9 Ln10a9 Ln29a9 0.453889
Kn10an29a10 Ln10a10 Ln29a10 0.453889
Kn10an29a11 Ln10a11 Ln29a11 0.453889
Kn10an29a12 Ln10a12 Ln29a12 0.453889
Kn10an29a13 Ln10a13 Ln29a13 0.453889
Kn10an29a14 Ln10a14 Ln29a14 0.453889
Kn10an29a15 Ln10a15 Ln29a15 0.453889
Kn10an29a16 Ln10a16 Ln29a16 0.453889
Kn10an30a1 Ln10a1 Ln30a1 0.450243
Kn10an30a2 Ln10a2 Ln30a2 0.450243
Kn10an30a3 Ln10a3 Ln30a3 0.450243
Kn10an30a4 Ln10a4 Ln30a4 0.450243
Kn10an30a5 Ln10a5 Ln30a5 0.450243
Kn10an30a6 Ln10a6 Ln30a6 0.450243
Kn10an30a7 Ln10a7 Ln30a7 0.450243
Kn10an30a8 Ln10a8 Ln30a8 0.450243
Kn10an30a9 Ln10a9 Ln30a9 0.450243
Kn10an30a10 Ln10a10 Ln30a10 0.450243
Kn10an30a11 Ln10a11 Ln30a11 0.450243
Kn10an30a12 Ln10a12 Ln30a12 0.450243
Kn10an30a13 Ln10a13 Ln30a13 0.450243
Kn10an30a14 Ln10a14 Ln30a14 0.450243
Kn10an30a15 Ln10a15 Ln30a15 0.450243
Kn10an30a16 Ln10a16 Ln30a16 0.450243
Kn10an31a1 Ln10a1 Ln31a1 0.447456
Kn10an31a2 Ln10a2 Ln31a2 0.447456
Kn10an31a3 Ln10a3 Ln31a3 0.447456
Kn10an31a4 Ln10a4 Ln31a4 0.447456
Kn10an31a5 Ln10a5 Ln31a5 0.447456
Kn10an31a6 Ln10a6 Ln31a6 0.447456
Kn10an31a7 Ln10a7 Ln31a7 0.447456
Kn10an31a8 Ln10a8 Ln31a8 0.447456
Kn10an31a9 Ln10a9 Ln31a9 0.447456
Kn10an31a10 Ln10a10 Ln31a10 0.447456
Kn10an31a11 Ln10a11 Ln31a11 0.447456
Kn10an31a12 Ln10a12 Ln31a12 0.447456
Kn10an31a13 Ln10a13 Ln31a13 0.447456
Kn10an31a14 Ln10a14 Ln31a14 0.447456
Kn10an31a15 Ln10a15 Ln31a15 0.447456
Kn10an31a16 Ln10a16 Ln31a16 0.447456
Kn10an32a1 Ln10a1 Ln32a1 0.445700
Kn10an32a2 Ln10a2 Ln32a2 0.445700
Kn10an32a3 Ln10a3 Ln32a3 0.445700
Kn10an32a4 Ln10a4 Ln32a4 0.445700
Kn10an32a5 Ln10a5 Ln32a5 0.445700
Kn10an32a6 Ln10a6 Ln32a6 0.445700
Kn10an32a7 Ln10a7 Ln32a7 0.445700
Kn10an32a8 Ln10a8 Ln32a8 0.445700
Kn10an32a9 Ln10a9 Ln32a9 0.445700
Kn10an32a10 Ln10a10 Ln32a10 0.445700
Kn10an32a11 Ln10a11 Ln32a11 0.445700
Kn10an32a12 Ln10a12 Ln32a12 0.445700
Kn10an32a13 Ln10a13 Ln32a13 0.445700
Kn10an32a14 Ln10a14 Ln32a14 0.445700
Kn10an32a15 Ln10a15 Ln32a15 0.445700
Kn10an32a16 Ln10a16 Ln32a16 0.445700
Kn10anva1 Ln10a1 Lnva1 0.444759
Kn10anva2 Ln10a2 Lnva2 0.444759
Kn10anva3 Ln10a3 Lnva3 0.444759
Kn10anva4 Ln10a4 Lnva4 0.444759
Kn10anva5 Ln10a5 Lnva5 0.444759
Kn10anva6 Ln10a6 Lnva6 0.444759
Kn10anva7 Ln10a7 Lnva7 0.444759
Kn10anva8 Ln10a8 Lnva8 0.444759
Kn10anva9 Ln10a9 Lnva9 0.444759
Kn10anva10 Ln10a10 Lnva10 0.444759
Kn10anva11 Ln10a11 Lnva11 0.444759
Kn10anva12 Ln10a12 Lnva12 0.444759
Kn10anva13 Ln10a13 Lnva13 0.444759
Kn10anva14 Ln10a14 Lnva14 0.444759
Kn10anva15 Ln10a15 Lnva15 0.444759
Kn10anva16 Ln10a16 Lnva16 0.444759
Kn11an12a1 Ln11a1 Ln12a1 0.805155
Kn11an12a2 Ln11a2 Ln12a2 0.805155
Kn11an12a3 Ln11a3 Ln12a3 0.805155
Kn11an12a4 Ln11a4 Ln12a4 0.805155
Kn11an12a5 Ln11a5 Ln12a5 0.805155
Kn11an12a6 Ln11a6 Ln12a6 0.805155
Kn11an12a7 Ln11a7 Ln12a7 0.805155
Kn11an12a8 Ln11a8 Ln12a8 0.805155
Kn11an12a9 Ln11a9 Ln12a9 0.805155
Kn11an12a10 Ln11a10 Ln12a10 0.805155
Kn11an12a11 Ln11a11 Ln12a11 0.805155
Kn11an12a12 Ln11a12 Ln12a12 0.805155
Kn11an12a13 Ln11a13 Ln12a13 0.805155
Kn11an12a14 Ln11a14 Ln12a14 0.805155
Kn11an12a15 Ln11a15 Ln12a15 0.805155
Kn11an12a16 Ln11a16 Ln12a16 0.805155
Kn11an13a1 Ln11a1 Ln13a1 0.723730
Kn11an13a2 Ln11a2 Ln13a2 0.723730
Kn11an13a3 Ln11a3 Ln13a3 0.723730
Kn11an13a4 Ln11a4 Ln13a4 0.723730
Kn11an13a5 Ln11a5 Ln13a5 0.723730
Kn11an13a6 Ln11a6 Ln13a6 0.723730
Kn11an13a7 Ln11a7 Ln13a7 0.723730
Kn11an13a8 Ln11a8 Ln13a8 0.723730
Kn11an13a9 Ln11a9 Ln13a9 0.723730
Kn11an13a10 Ln11a10 Ln13a10 0.723730
Kn11an13a11 Ln11a11 Ln13a11 0.723730
Kn11an13a12 Ln11a12 Ln13a12 0.723730
Kn11an13a13 Ln11a13 Ln13a13 0.723730
Kn11an13a14 Ln11a14 Ln13a14 0.723730
Kn11an13a15 Ln11a15 Ln13a15 0.723730
Kn11an13a16 Ln11a16 Ln13a16 0.723730
Kn11an14a1 Ln11a1 Ln14a1 0.675208
Kn11an14a2 Ln11a2 Ln14a2 0.675208
Kn11an14a3 Ln11a3 Ln14a3 0.675208
Kn11an14a4 Ln11a4 Ln14a4 0.675208
Kn11an14a5 Ln11a5 Ln14a5 0.675208
Kn11an14a6 Ln11a6 Ln14a6 0.675208
Kn11an14a7 Ln11a7 Ln14a7 0.675208
Kn11an14a8 Ln11a8 Ln14a8 0.675208
Kn11an14a9 Ln11a9 Ln14a9 0.675208
Kn11an14a10 Ln11a10 Ln14a10 0.675208
Kn11an14a11 Ln11a11 Ln14a11 0.675208
Kn11an14a12 Ln11a12 Ln14a12 0.675208
Kn11an14a13 Ln11a13 Ln14a13 0.675208
Kn11an14a14 Ln11a14 Ln14a14 0.675208
Kn11an14a15 Ln11a15 Ln14a15 0.675208
Kn11an14a16 Ln11a16 Ln14a16 0.675208
Kn11an15a1 Ln11a1 Ln15a1 0.640637
Kn11an15a2 Ln11a2 Ln15a2 0.640637
Kn11an15a3 Ln11a3 Ln15a3 0.640637
Kn11an15a4 Ln11a4 Ln15a4 0.640637
Kn11an15a5 Ln11a5 Ln15a5 0.640637
Kn11an15a6 Ln11a6 Ln15a6 0.640637
Kn11an15a7 Ln11a7 Ln15a7 0.640637
Kn11an15a8 Ln11a8 Ln15a8 0.640637
Kn11an15a9 Ln11a9 Ln15a9 0.640637
Kn11an15a10 Ln11a10 Ln15a10 0.640637
Kn11an15a11 Ln11a11 Ln15a11 0.640637
Kn11an15a12 Ln11a12 Ln15a12 0.640637
Kn11an15a13 Ln11a13 Ln15a13 0.640637
Kn11an15a14 Ln11a14 Ln15a14 0.640637
Kn11an15a15 Ln11a15 Ln15a15 0.640637
Kn11an15a16 Ln11a16 Ln15a16 0.640637
Kn11an16a1 Ln11a1 Ln16a1 0.613723
Kn11an16a2 Ln11a2 Ln16a2 0.613723
Kn11an16a3 Ln11a3 Ln16a3 0.613723
Kn11an16a4 Ln11a4 Ln16a4 0.613723
Kn11an16a5 Ln11a5 Ln16a5 0.613723
Kn11an16a6 Ln11a6 Ln16a6 0.613723
Kn11an16a7 Ln11a7 Ln16a7 0.613723
Kn11an16a8 Ln11a8 Ln16a8 0.613723
Kn11an16a9 Ln11a9 Ln16a9 0.613723
Kn11an16a10 Ln11a10 Ln16a10 0.613723
Kn11an16a11 Ln11a11 Ln16a11 0.613723
Kn11an16a12 Ln11a12 Ln16a12 0.613723
Kn11an16a13 Ln11a13 Ln16a13 0.613723
Kn11an16a14 Ln11a14 Ln16a14 0.613723
Kn11an16a15 Ln11a15 Ln16a15 0.613723
Kn11an16a16 Ln11a16 Ln16a16 0.613723
Kn11an17a1 Ln11a1 Ln17a1 0.591812
Kn11an17a2 Ln11a2 Ln17a2 0.591812
Kn11an17a3 Ln11a3 Ln17a3 0.591812
Kn11an17a4 Ln11a4 Ln17a4 0.591812
Kn11an17a5 Ln11a5 Ln17a5 0.591812
Kn11an17a6 Ln11a6 Ln17a6 0.591812
Kn11an17a7 Ln11a7 Ln17a7 0.591812
Kn11an17a8 Ln11a8 Ln17a8 0.591812
Kn11an17a9 Ln11a9 Ln17a9 0.591812
Kn11an17a10 Ln11a10 Ln17a10 0.591812
Kn11an17a11 Ln11a11 Ln17a11 0.591812
Kn11an17a12 Ln11a12 Ln17a12 0.591812
Kn11an17a13 Ln11a13 Ln17a13 0.591812
Kn11an17a14 Ln11a14 Ln17a14 0.591812
Kn11an17a15 Ln11a15 Ln17a15 0.591812
Kn11an17a16 Ln11a16 Ln17a16 0.591812
Kn11an18a1 Ln11a1 Ln18a1 0.573237
Kn11an18a2 Ln11a2 Ln18a2 0.573237
Kn11an18a3 Ln11a3 Ln18a3 0.573237
Kn11an18a4 Ln11a4 Ln18a4 0.573237
Kn11an18a5 Ln11a5 Ln18a5 0.573237
Kn11an18a6 Ln11a6 Ln18a6 0.573237
Kn11an18a7 Ln11a7 Ln18a7 0.573237
Kn11an18a8 Ln11a8 Ln18a8 0.573237
Kn11an18a9 Ln11a9 Ln18a9 0.573237
Kn11an18a10 Ln11a10 Ln18a10 0.573237
Kn11an18a11 Ln11a11 Ln18a11 0.573237
Kn11an18a12 Ln11a12 Ln18a12 0.573237
Kn11an18a13 Ln11a13 Ln18a13 0.573237
Kn11an18a14 Ln11a14 Ln18a14 0.573237
Kn11an18a15 Ln11a15 Ln18a15 0.573237
Kn11an18a16 Ln11a16 Ln18a16 0.573237
Kn11an19a1 Ln11a1 Ln19a1 0.557165
Kn11an19a2 Ln11a2 Ln19a2 0.557165
Kn11an19a3 Ln11a3 Ln19a3 0.557165
Kn11an19a4 Ln11a4 Ln19a4 0.557165
Kn11an19a5 Ln11a5 Ln19a5 0.557165
Kn11an19a6 Ln11a6 Ln19a6 0.557165
Kn11an19a7 Ln11a7 Ln19a7 0.557165
Kn11an19a8 Ln11a8 Ln19a8 0.557165
Kn11an19a9 Ln11a9 Ln19a9 0.557165
Kn11an19a10 Ln11a10 Ln19a10 0.557165
Kn11an19a11 Ln11a11 Ln19a11 0.557165
Kn11an19a12 Ln11a12 Ln19a12 0.557165
Kn11an19a13 Ln11a13 Ln19a13 0.557165
Kn11an19a14 Ln11a14 Ln19a14 0.557165
Kn11an19a15 Ln11a15 Ln19a15 0.557165
Kn11an19a16 Ln11a16 Ln19a16 0.557165
Kn11an20a1 Ln11a1 Ln20a1 0.542987
Kn11an20a2 Ln11a2 Ln20a2 0.542987
Kn11an20a3 Ln11a3 Ln20a3 0.542987
Kn11an20a4 Ln11a4 Ln20a4 0.542987
Kn11an20a5 Ln11a5 Ln20a5 0.542987
Kn11an20a6 Ln11a6 Ln20a6 0.542987
Kn11an20a7 Ln11a7 Ln20a7 0.542987
Kn11an20a8 Ln11a8 Ln20a8 0.542987
Kn11an20a9 Ln11a9 Ln20a9 0.542987
Kn11an20a10 Ln11a10 Ln20a10 0.542987
Kn11an20a11 Ln11a11 Ln20a11 0.542987
Kn11an20a12 Ln11a12 Ln20a12 0.542987
Kn11an20a13 Ln11a13 Ln20a13 0.542987
Kn11an20a14 Ln11a14 Ln20a14 0.542987
Kn11an20a15 Ln11a15 Ln20a15 0.542987
Kn11an20a16 Ln11a16 Ln20a16 0.542987
Kn11an21a1 Ln11a1 Ln21a1 0.529400
Kn11an21a2 Ln11a2 Ln21a2 0.529400
Kn11an21a3 Ln11a3 Ln21a3 0.529400
Kn11an21a4 Ln11a4 Ln21a4 0.529400
Kn11an21a5 Ln11a5 Ln21a5 0.529400
Kn11an21a6 Ln11a6 Ln21a6 0.529400
Kn11an21a7 Ln11a7 Ln21a7 0.529400
Kn11an21a8 Ln11a8 Ln21a8 0.529400
Kn11an21a9 Ln11a9 Ln21a9 0.529400
Kn11an21a10 Ln11a10 Ln21a10 0.529400
Kn11an21a11 Ln11a11 Ln21a11 0.529400
Kn11an21a12 Ln11a12 Ln21a12 0.529400
Kn11an21a13 Ln11a13 Ln21a13 0.529400
Kn11an21a14 Ln11a14 Ln21a14 0.529400
Kn11an21a15 Ln11a15 Ln21a15 0.529400
Kn11an21a16 Ln11a16 Ln21a16 0.529400
Kn11an22a1 Ln11a1 Ln22a1 0.516943
Kn11an22a2 Ln11a2 Ln22a2 0.516943
Kn11an22a3 Ln11a3 Ln22a3 0.516943
Kn11an22a4 Ln11a4 Ln22a4 0.516943
Kn11an22a5 Ln11a5 Ln22a5 0.516943
Kn11an22a6 Ln11a6 Ln22a6 0.516943
Kn11an22a7 Ln11a7 Ln22a7 0.516943
Kn11an22a8 Ln11a8 Ln22a8 0.516943
Kn11an22a9 Ln11a9 Ln22a9 0.516943
Kn11an22a10 Ln11a10 Ln22a10 0.516943
Kn11an22a11 Ln11a11 Ln22a11 0.516943
Kn11an22a12 Ln11a12 Ln22a12 0.516943
Kn11an22a13 Ln11a13 Ln22a13 0.516943
Kn11an22a14 Ln11a14 Ln22a14 0.516943
Kn11an22a15 Ln11a15 Ln22a15 0.516943
Kn11an22a16 Ln11a16 Ln22a16 0.516943
Kn11an23a1 Ln11a1 Ln23a1 0.505455
Kn11an23a2 Ln11a2 Ln23a2 0.505455
Kn11an23a3 Ln11a3 Ln23a3 0.505455
Kn11an23a4 Ln11a4 Ln23a4 0.505455
Kn11an23a5 Ln11a5 Ln23a5 0.505455
Kn11an23a6 Ln11a6 Ln23a6 0.505455
Kn11an23a7 Ln11a7 Ln23a7 0.505455
Kn11an23a8 Ln11a8 Ln23a8 0.505455
Kn11an23a9 Ln11a9 Ln23a9 0.505455
Kn11an23a10 Ln11a10 Ln23a10 0.505455
Kn11an23a11 Ln11a11 Ln23a11 0.505455
Kn11an23a12 Ln11a12 Ln23a12 0.505455
Kn11an23a13 Ln11a13 Ln23a13 0.505455
Kn11an23a14 Ln11a14 Ln23a14 0.505455
Kn11an23a15 Ln11a15 Ln23a15 0.505455
Kn11an23a16 Ln11a16 Ln23a16 0.505455
Kn11an24a1 Ln11a1 Ln24a1 0.494887
Kn11an24a2 Ln11a2 Ln24a2 0.494887
Kn11an24a3 Ln11a3 Ln24a3 0.494887
Kn11an24a4 Ln11a4 Ln24a4 0.494887
Kn11an24a5 Ln11a5 Ln24a5 0.494887
Kn11an24a6 Ln11a6 Ln24a6 0.494887
Kn11an24a7 Ln11a7 Ln24a7 0.494887
Kn11an24a8 Ln11a8 Ln24a8 0.494887
Kn11an24a9 Ln11a9 Ln24a9 0.494887
Kn11an24a10 Ln11a10 Ln24a10 0.494887
Kn11an24a11 Ln11a11 Ln24a11 0.494887
Kn11an24a12 Ln11a12 Ln24a12 0.494887
Kn11an24a13 Ln11a13 Ln24a13 0.494887
Kn11an24a14 Ln11a14 Ln24a14 0.494887
Kn11an24a15 Ln11a15 Ln24a15 0.494887
Kn11an24a16 Ln11a16 Ln24a16 0.494887
Kn11an25a1 Ln11a1 Ln25a1 0.485771
Kn11an25a2 Ln11a2 Ln25a2 0.485771
Kn11an25a3 Ln11a3 Ln25a3 0.485771
Kn11an25a4 Ln11a4 Ln25a4 0.485771
Kn11an25a5 Ln11a5 Ln25a5 0.485771
Kn11an25a6 Ln11a6 Ln25a6 0.485771
Kn11an25a7 Ln11a7 Ln25a7 0.485771
Kn11an25a8 Ln11a8 Ln25a8 0.485771
Kn11an25a9 Ln11a9 Ln25a9 0.485771
Kn11an25a10 Ln11a10 Ln25a10 0.485771
Kn11an25a11 Ln11a11 Ln25a11 0.485771
Kn11an25a12 Ln11a12 Ln25a12 0.485771
Kn11an25a13 Ln11a13 Ln25a13 0.485771
Kn11an25a14 Ln11a14 Ln25a14 0.485771
Kn11an25a15 Ln11a15 Ln25a15 0.485771
Kn11an25a16 Ln11a16 Ln25a16 0.485771
Kn11an26a1 Ln11a1 Ln26a1 0.477226
Kn11an26a2 Ln11a2 Ln26a2 0.477226
Kn11an26a3 Ln11a3 Ln26a3 0.477226
Kn11an26a4 Ln11a4 Ln26a4 0.477226
Kn11an26a5 Ln11a5 Ln26a5 0.477226
Kn11an26a6 Ln11a6 Ln26a6 0.477226
Kn11an26a7 Ln11a7 Ln26a7 0.477226
Kn11an26a8 Ln11a8 Ln26a8 0.477226
Kn11an26a9 Ln11a9 Ln26a9 0.477226
Kn11an26a10 Ln11a10 Ln26a10 0.477226
Kn11an26a11 Ln11a11 Ln26a11 0.477226
Kn11an26a12 Ln11a12 Ln26a12 0.477226
Kn11an26a13 Ln11a13 Ln26a13 0.477226
Kn11an26a14 Ln11a14 Ln26a14 0.477226
Kn11an26a15 Ln11a15 Ln26a15 0.477226
Kn11an26a16 Ln11a16 Ln26a16 0.477226
Kn11an27a1 Ln11a1 Ln27a1 0.469680
Kn11an27a2 Ln11a2 Ln27a2 0.469680
Kn11an27a3 Ln11a3 Ln27a3 0.469680
Kn11an27a4 Ln11a4 Ln27a4 0.469680
Kn11an27a5 Ln11a5 Ln27a5 0.469680
Kn11an27a6 Ln11a6 Ln27a6 0.469680
Kn11an27a7 Ln11a7 Ln27a7 0.469680
Kn11an27a8 Ln11a8 Ln27a8 0.469680
Kn11an27a9 Ln11a9 Ln27a9 0.469680
Kn11an27a10 Ln11a10 Ln27a10 0.469680
Kn11an27a11 Ln11a11 Ln27a11 0.469680
Kn11an27a12 Ln11a12 Ln27a12 0.469680
Kn11an27a13 Ln11a13 Ln27a13 0.469680
Kn11an27a14 Ln11a14 Ln27a14 0.469680
Kn11an27a15 Ln11a15 Ln27a15 0.469680
Kn11an27a16 Ln11a16 Ln27a16 0.469680
Kn11an28a1 Ln11a1 Ln28a1 0.463523
Kn11an28a2 Ln11a2 Ln28a2 0.463523
Kn11an28a3 Ln11a3 Ln28a3 0.463523
Kn11an28a4 Ln11a4 Ln28a4 0.463523
Kn11an28a5 Ln11a5 Ln28a5 0.463523
Kn11an28a6 Ln11a6 Ln28a6 0.463523
Kn11an28a7 Ln11a7 Ln28a7 0.463523
Kn11an28a8 Ln11a8 Ln28a8 0.463523
Kn11an28a9 Ln11a9 Ln28a9 0.463523
Kn11an28a10 Ln11a10 Ln28a10 0.463523
Kn11an28a11 Ln11a11 Ln28a11 0.463523
Kn11an28a12 Ln11a12 Ln28a12 0.463523
Kn11an28a13 Ln11a13 Ln28a13 0.463523
Kn11an28a14 Ln11a14 Ln28a14 0.463523
Kn11an28a15 Ln11a15 Ln28a15 0.463523
Kn11an28a16 Ln11a16 Ln28a16 0.463523
Kn11an29a1 Ln11a1 Ln29a1 0.458074
Kn11an29a2 Ln11a2 Ln29a2 0.458074
Kn11an29a3 Ln11a3 Ln29a3 0.458074
Kn11an29a4 Ln11a4 Ln29a4 0.458074
Kn11an29a5 Ln11a5 Ln29a5 0.458074
Kn11an29a6 Ln11a6 Ln29a6 0.458074
Kn11an29a7 Ln11a7 Ln29a7 0.458074
Kn11an29a8 Ln11a8 Ln29a8 0.458074
Kn11an29a9 Ln11a9 Ln29a9 0.458074
Kn11an29a10 Ln11a10 Ln29a10 0.458074
Kn11an29a11 Ln11a11 Ln29a11 0.458074
Kn11an29a12 Ln11a12 Ln29a12 0.458074
Kn11an29a13 Ln11a13 Ln29a13 0.458074
Kn11an29a14 Ln11a14 Ln29a14 0.458074
Kn11an29a15 Ln11a15 Ln29a15 0.458074
Kn11an29a16 Ln11a16 Ln29a16 0.458074
Kn11an30a1 Ln11a1 Ln30a1 0.453889
Kn11an30a2 Ln11a2 Ln30a2 0.453889
Kn11an30a3 Ln11a3 Ln30a3 0.453889
Kn11an30a4 Ln11a4 Ln30a4 0.453889
Kn11an30a5 Ln11a5 Ln30a5 0.453889
Kn11an30a6 Ln11a6 Ln30a6 0.453889
Kn11an30a7 Ln11a7 Ln30a7 0.453889
Kn11an30a8 Ln11a8 Ln30a8 0.453889
Kn11an30a9 Ln11a9 Ln30a9 0.453889
Kn11an30a10 Ln11a10 Ln30a10 0.453889
Kn11an30a11 Ln11a11 Ln30a11 0.453889
Kn11an30a12 Ln11a12 Ln30a12 0.453889
Kn11an30a13 Ln11a13 Ln30a13 0.453889
Kn11an30a14 Ln11a14 Ln30a14 0.453889
Kn11an30a15 Ln11a15 Ln30a15 0.453889
Kn11an30a16 Ln11a16 Ln30a16 0.453889
Kn11an31a1 Ln11a1 Ln31a1 0.450243
Kn11an31a2 Ln11a2 Ln31a2 0.450243
Kn11an31a3 Ln11a3 Ln31a3 0.450243
Kn11an31a4 Ln11a4 Ln31a4 0.450243
Kn11an31a5 Ln11a5 Ln31a5 0.450243
Kn11an31a6 Ln11a6 Ln31a6 0.450243
Kn11an31a7 Ln11a7 Ln31a7 0.450243
Kn11an31a8 Ln11a8 Ln31a8 0.450243
Kn11an31a9 Ln11a9 Ln31a9 0.450243
Kn11an31a10 Ln11a10 Ln31a10 0.450243
Kn11an31a11 Ln11a11 Ln31a11 0.450243
Kn11an31a12 Ln11a12 Ln31a12 0.450243
Kn11an31a13 Ln11a13 Ln31a13 0.450243
Kn11an31a14 Ln11a14 Ln31a14 0.450243
Kn11an31a15 Ln11a15 Ln31a15 0.450243
Kn11an31a16 Ln11a16 Ln31a16 0.450243
Kn11an32a1 Ln11a1 Ln32a1 0.447456
Kn11an32a2 Ln11a2 Ln32a2 0.447456
Kn11an32a3 Ln11a3 Ln32a3 0.447456
Kn11an32a4 Ln11a4 Ln32a4 0.447456
Kn11an32a5 Ln11a5 Ln32a5 0.447456
Kn11an32a6 Ln11a6 Ln32a6 0.447456
Kn11an32a7 Ln11a7 Ln32a7 0.447456
Kn11an32a8 Ln11a8 Ln32a8 0.447456
Kn11an32a9 Ln11a9 Ln32a9 0.447456
Kn11an32a10 Ln11a10 Ln32a10 0.447456
Kn11an32a11 Ln11a11 Ln32a11 0.447456
Kn11an32a12 Ln11a12 Ln32a12 0.447456
Kn11an32a13 Ln11a13 Ln32a13 0.447456
Kn11an32a14 Ln11a14 Ln32a14 0.447456
Kn11an32a15 Ln11a15 Ln32a15 0.447456
Kn11an32a16 Ln11a16 Ln32a16 0.447456
Kn11anva1 Ln11a1 Lnva1 0.445700
Kn11anva2 Ln11a2 Lnva2 0.445700
Kn11anva3 Ln11a3 Lnva3 0.445700
Kn11anva4 Ln11a4 Lnva4 0.445700
Kn11anva5 Ln11a5 Lnva5 0.445700
Kn11anva6 Ln11a6 Lnva6 0.445700
Kn11anva7 Ln11a7 Lnva7 0.445700
Kn11anva8 Ln11a8 Lnva8 0.445700
Kn11anva9 Ln11a9 Lnva9 0.445700
Kn11anva10 Ln11a10 Lnva10 0.445700
Kn11anva11 Ln11a11 Lnva11 0.445700
Kn11anva12 Ln11a12 Lnva12 0.445700
Kn11anva13 Ln11a13 Lnva13 0.445700
Kn11anva14 Ln11a14 Lnva14 0.445700
Kn11anva15 Ln11a15 Lnva15 0.445700
Kn11anva16 Ln11a16 Lnva16 0.445700
Kn12an13a1 Ln12a1 Ln13a1 0.805155
Kn12an13a2 Ln12a2 Ln13a2 0.805155
Kn12an13a3 Ln12a3 Ln13a3 0.805155
Kn12an13a4 Ln12a4 Ln13a4 0.805155
Kn12an13a5 Ln12a5 Ln13a5 0.805155
Kn12an13a6 Ln12a6 Ln13a6 0.805155
Kn12an13a7 Ln12a7 Ln13a7 0.805155
Kn12an13a8 Ln12a8 Ln13a8 0.805155
Kn12an13a9 Ln12a9 Ln13a9 0.805155
Kn12an13a10 Ln12a10 Ln13a10 0.805155
Kn12an13a11 Ln12a11 Ln13a11 0.805155
Kn12an13a12 Ln12a12 Ln13a12 0.805155
Kn12an13a13 Ln12a13 Ln13a13 0.805155
Kn12an13a14 Ln12a14 Ln13a14 0.805155
Kn12an13a15 Ln12a15 Ln13a15 0.805155
Kn12an13a16 Ln12a16 Ln13a16 0.805155
Kn12an14a1 Ln12a1 Ln14a1 0.723730
Kn12an14a2 Ln12a2 Ln14a2 0.723730
Kn12an14a3 Ln12a3 Ln14a3 0.723730
Kn12an14a4 Ln12a4 Ln14a4 0.723730
Kn12an14a5 Ln12a5 Ln14a5 0.723730
Kn12an14a6 Ln12a6 Ln14a6 0.723730
Kn12an14a7 Ln12a7 Ln14a7 0.723730
Kn12an14a8 Ln12a8 Ln14a8 0.723730
Kn12an14a9 Ln12a9 Ln14a9 0.723730
Kn12an14a10 Ln12a10 Ln14a10 0.723730
Kn12an14a11 Ln12a11 Ln14a11 0.723730
Kn12an14a12 Ln12a12 Ln14a12 0.723730
Kn12an14a13 Ln12a13 Ln14a13 0.723730
Kn12an14a14 Ln12a14 Ln14a14 0.723730
Kn12an14a15 Ln12a15 Ln14a15 0.723730
Kn12an14a16 Ln12a16 Ln14a16 0.723730
Kn12an15a1 Ln12a1 Ln15a1 0.675208
Kn12an15a2 Ln12a2 Ln15a2 0.675208
Kn12an15a3 Ln12a3 Ln15a3 0.675208
Kn12an15a4 Ln12a4 Ln15a4 0.675208
Kn12an15a5 Ln12a5 Ln15a5 0.675208
Kn12an15a6 Ln12a6 Ln15a6 0.675208
Kn12an15a7 Ln12a7 Ln15a7 0.675208
Kn12an15a8 Ln12a8 Ln15a8 0.675208
Kn12an15a9 Ln12a9 Ln15a9 0.675208
Kn12an15a10 Ln12a10 Ln15a10 0.675208
Kn12an15a11 Ln12a11 Ln15a11 0.675208
Kn12an15a12 Ln12a12 Ln15a12 0.675208
Kn12an15a13 Ln12a13 Ln15a13 0.675208
Kn12an15a14 Ln12a14 Ln15a14 0.675208
Kn12an15a15 Ln12a15 Ln15a15 0.675208
Kn12an15a16 Ln12a16 Ln15a16 0.675208
Kn12an16a1 Ln12a1 Ln16a1 0.640637
Kn12an16a2 Ln12a2 Ln16a2 0.640637
Kn12an16a3 Ln12a3 Ln16a3 0.640637
Kn12an16a4 Ln12a4 Ln16a4 0.640637
Kn12an16a5 Ln12a5 Ln16a5 0.640637
Kn12an16a6 Ln12a6 Ln16a6 0.640637
Kn12an16a7 Ln12a7 Ln16a7 0.640637
Kn12an16a8 Ln12a8 Ln16a8 0.640637
Kn12an16a9 Ln12a9 Ln16a9 0.640637
Kn12an16a10 Ln12a10 Ln16a10 0.640637
Kn12an16a11 Ln12a11 Ln16a11 0.640637
Kn12an16a12 Ln12a12 Ln16a12 0.640637
Kn12an16a13 Ln12a13 Ln16a13 0.640637
Kn12an16a14 Ln12a14 Ln16a14 0.640637
Kn12an16a15 Ln12a15 Ln16a15 0.640637
Kn12an16a16 Ln12a16 Ln16a16 0.640637
Kn12an17a1 Ln12a1 Ln17a1 0.613723
Kn12an17a2 Ln12a2 Ln17a2 0.613723
Kn12an17a3 Ln12a3 Ln17a3 0.613723
Kn12an17a4 Ln12a4 Ln17a4 0.613723
Kn12an17a5 Ln12a5 Ln17a5 0.613723
Kn12an17a6 Ln12a6 Ln17a6 0.613723
Kn12an17a7 Ln12a7 Ln17a7 0.613723
Kn12an17a8 Ln12a8 Ln17a8 0.613723
Kn12an17a9 Ln12a9 Ln17a9 0.613723
Kn12an17a10 Ln12a10 Ln17a10 0.613723
Kn12an17a11 Ln12a11 Ln17a11 0.613723
Kn12an17a12 Ln12a12 Ln17a12 0.613723
Kn12an17a13 Ln12a13 Ln17a13 0.613723
Kn12an17a14 Ln12a14 Ln17a14 0.613723
Kn12an17a15 Ln12a15 Ln17a15 0.613723
Kn12an17a16 Ln12a16 Ln17a16 0.613723
Kn12an18a1 Ln12a1 Ln18a1 0.591812
Kn12an18a2 Ln12a2 Ln18a2 0.591812
Kn12an18a3 Ln12a3 Ln18a3 0.591812
Kn12an18a4 Ln12a4 Ln18a4 0.591812
Kn12an18a5 Ln12a5 Ln18a5 0.591812
Kn12an18a6 Ln12a6 Ln18a6 0.591812
Kn12an18a7 Ln12a7 Ln18a7 0.591812
Kn12an18a8 Ln12a8 Ln18a8 0.591812
Kn12an18a9 Ln12a9 Ln18a9 0.591812
Kn12an18a10 Ln12a10 Ln18a10 0.591812
Kn12an18a11 Ln12a11 Ln18a11 0.591812
Kn12an18a12 Ln12a12 Ln18a12 0.591812
Kn12an18a13 Ln12a13 Ln18a13 0.591812
Kn12an18a14 Ln12a14 Ln18a14 0.591812
Kn12an18a15 Ln12a15 Ln18a15 0.591812
Kn12an18a16 Ln12a16 Ln18a16 0.591812
Kn12an19a1 Ln12a1 Ln19a1 0.573237
Kn12an19a2 Ln12a2 Ln19a2 0.573237
Kn12an19a3 Ln12a3 Ln19a3 0.573237
Kn12an19a4 Ln12a4 Ln19a4 0.573237
Kn12an19a5 Ln12a5 Ln19a5 0.573237
Kn12an19a6 Ln12a6 Ln19a6 0.573237
Kn12an19a7 Ln12a7 Ln19a7 0.573237
Kn12an19a8 Ln12a8 Ln19a8 0.573237
Kn12an19a9 Ln12a9 Ln19a9 0.573237
Kn12an19a10 Ln12a10 Ln19a10 0.573237
Kn12an19a11 Ln12a11 Ln19a11 0.573237
Kn12an19a12 Ln12a12 Ln19a12 0.573237
Kn12an19a13 Ln12a13 Ln19a13 0.573237
Kn12an19a14 Ln12a14 Ln19a14 0.573237
Kn12an19a15 Ln12a15 Ln19a15 0.573237
Kn12an19a16 Ln12a16 Ln19a16 0.573237
Kn12an20a1 Ln12a1 Ln20a1 0.557165
Kn12an20a2 Ln12a2 Ln20a2 0.557165
Kn12an20a3 Ln12a3 Ln20a3 0.557165
Kn12an20a4 Ln12a4 Ln20a4 0.557165
Kn12an20a5 Ln12a5 Ln20a5 0.557165
Kn12an20a6 Ln12a6 Ln20a6 0.557165
Kn12an20a7 Ln12a7 Ln20a7 0.557165
Kn12an20a8 Ln12a8 Ln20a8 0.557165
Kn12an20a9 Ln12a9 Ln20a9 0.557165
Kn12an20a10 Ln12a10 Ln20a10 0.557165
Kn12an20a11 Ln12a11 Ln20a11 0.557165
Kn12an20a12 Ln12a12 Ln20a12 0.557165
Kn12an20a13 Ln12a13 Ln20a13 0.557165
Kn12an20a14 Ln12a14 Ln20a14 0.557165
Kn12an20a15 Ln12a15 Ln20a15 0.557165
Kn12an20a16 Ln12a16 Ln20a16 0.557165
Kn12an21a1 Ln12a1 Ln21a1 0.542987
Kn12an21a2 Ln12a2 Ln21a2 0.542987
Kn12an21a3 Ln12a3 Ln21a3 0.542987
Kn12an21a4 Ln12a4 Ln21a4 0.542987
Kn12an21a5 Ln12a5 Ln21a5 0.542987
Kn12an21a6 Ln12a6 Ln21a6 0.542987
Kn12an21a7 Ln12a7 Ln21a7 0.542987
Kn12an21a8 Ln12a8 Ln21a8 0.542987
Kn12an21a9 Ln12a9 Ln21a9 0.542987
Kn12an21a10 Ln12a10 Ln21a10 0.542987
Kn12an21a11 Ln12a11 Ln21a11 0.542987
Kn12an21a12 Ln12a12 Ln21a12 0.542987
Kn12an21a13 Ln12a13 Ln21a13 0.542987
Kn12an21a14 Ln12a14 Ln21a14 0.542987
Kn12an21a15 Ln12a15 Ln21a15 0.542987
Kn12an21a16 Ln12a16 Ln21a16 0.542987
Kn12an22a1 Ln12a1 Ln22a1 0.529400
Kn12an22a2 Ln12a2 Ln22a2 0.529400
Kn12an22a3 Ln12a3 Ln22a3 0.529400
Kn12an22a4 Ln12a4 Ln22a4 0.529400
Kn12an22a5 Ln12a5 Ln22a5 0.529400
Kn12an22a6 Ln12a6 Ln22a6 0.529400
Kn12an22a7 Ln12a7 Ln22a7 0.529400
Kn12an22a8 Ln12a8 Ln22a8 0.529400
Kn12an22a9 Ln12a9 Ln22a9 0.529400
Kn12an22a10 Ln12a10 Ln22a10 0.529400
Kn12an22a11 Ln12a11 Ln22a11 0.529400
Kn12an22a12 Ln12a12 Ln22a12 0.529400
Kn12an22a13 Ln12a13 Ln22a13 0.529400
Kn12an22a14 Ln12a14 Ln22a14 0.529400
Kn12an22a15 Ln12a15 Ln22a15 0.529400
Kn12an22a16 Ln12a16 Ln22a16 0.529400
Kn12an23a1 Ln12a1 Ln23a1 0.516943
Kn12an23a2 Ln12a2 Ln23a2 0.516943
Kn12an23a3 Ln12a3 Ln23a3 0.516943
Kn12an23a4 Ln12a4 Ln23a4 0.516943
Kn12an23a5 Ln12a5 Ln23a5 0.516943
Kn12an23a6 Ln12a6 Ln23a6 0.516943
Kn12an23a7 Ln12a7 Ln23a7 0.516943
Kn12an23a8 Ln12a8 Ln23a8 0.516943
Kn12an23a9 Ln12a9 Ln23a9 0.516943
Kn12an23a10 Ln12a10 Ln23a10 0.516943
Kn12an23a11 Ln12a11 Ln23a11 0.516943
Kn12an23a12 Ln12a12 Ln23a12 0.516943
Kn12an23a13 Ln12a13 Ln23a13 0.516943
Kn12an23a14 Ln12a14 Ln23a14 0.516943
Kn12an23a15 Ln12a15 Ln23a15 0.516943
Kn12an23a16 Ln12a16 Ln23a16 0.516943
Kn12an24a1 Ln12a1 Ln24a1 0.505455
Kn12an24a2 Ln12a2 Ln24a2 0.505455
Kn12an24a3 Ln12a3 Ln24a3 0.505455
Kn12an24a4 Ln12a4 Ln24a4 0.505455
Kn12an24a5 Ln12a5 Ln24a5 0.505455
Kn12an24a6 Ln12a6 Ln24a6 0.505455
Kn12an24a7 Ln12a7 Ln24a7 0.505455
Kn12an24a8 Ln12a8 Ln24a8 0.505455
Kn12an24a9 Ln12a9 Ln24a9 0.505455
Kn12an24a10 Ln12a10 Ln24a10 0.505455
Kn12an24a11 Ln12a11 Ln24a11 0.505455
Kn12an24a12 Ln12a12 Ln24a12 0.505455
Kn12an24a13 Ln12a13 Ln24a13 0.505455
Kn12an24a14 Ln12a14 Ln24a14 0.505455
Kn12an24a15 Ln12a15 Ln24a15 0.505455
Kn12an24a16 Ln12a16 Ln24a16 0.505455
Kn12an25a1 Ln12a1 Ln25a1 0.494887
Kn12an25a2 Ln12a2 Ln25a2 0.494887
Kn12an25a3 Ln12a3 Ln25a3 0.494887
Kn12an25a4 Ln12a4 Ln25a4 0.494887
Kn12an25a5 Ln12a5 Ln25a5 0.494887
Kn12an25a6 Ln12a6 Ln25a6 0.494887
Kn12an25a7 Ln12a7 Ln25a7 0.494887
Kn12an25a8 Ln12a8 Ln25a8 0.494887
Kn12an25a9 Ln12a9 Ln25a9 0.494887
Kn12an25a10 Ln12a10 Ln25a10 0.494887
Kn12an25a11 Ln12a11 Ln25a11 0.494887
Kn12an25a12 Ln12a12 Ln25a12 0.494887
Kn12an25a13 Ln12a13 Ln25a13 0.494887
Kn12an25a14 Ln12a14 Ln25a14 0.494887
Kn12an25a15 Ln12a15 Ln25a15 0.494887
Kn12an25a16 Ln12a16 Ln25a16 0.494887
Kn12an26a1 Ln12a1 Ln26a1 0.485771
Kn12an26a2 Ln12a2 Ln26a2 0.485771
Kn12an26a3 Ln12a3 Ln26a3 0.485771
Kn12an26a4 Ln12a4 Ln26a4 0.485771
Kn12an26a5 Ln12a5 Ln26a5 0.485771
Kn12an26a6 Ln12a6 Ln26a6 0.485771
Kn12an26a7 Ln12a7 Ln26a7 0.485771
Kn12an26a8 Ln12a8 Ln26a8 0.485771
Kn12an26a9 Ln12a9 Ln26a9 0.485771
Kn12an26a10 Ln12a10 Ln26a10 0.485771
Kn12an26a11 Ln12a11 Ln26a11 0.485771
Kn12an26a12 Ln12a12 Ln26a12 0.485771
Kn12an26a13 Ln12a13 Ln26a13 0.485771
Kn12an26a14 Ln12a14 Ln26a14 0.485771
Kn12an26a15 Ln12a15 Ln26a15 0.485771
Kn12an26a16 Ln12a16 Ln26a16 0.485771
Kn12an27a1 Ln12a1 Ln27a1 0.477226
Kn12an27a2 Ln12a2 Ln27a2 0.477226
Kn12an27a3 Ln12a3 Ln27a3 0.477226
Kn12an27a4 Ln12a4 Ln27a4 0.477226
Kn12an27a5 Ln12a5 Ln27a5 0.477226
Kn12an27a6 Ln12a6 Ln27a6 0.477226
Kn12an27a7 Ln12a7 Ln27a7 0.477226
Kn12an27a8 Ln12a8 Ln27a8 0.477226
Kn12an27a9 Ln12a9 Ln27a9 0.477226
Kn12an27a10 Ln12a10 Ln27a10 0.477226
Kn12an27a11 Ln12a11 Ln27a11 0.477226
Kn12an27a12 Ln12a12 Ln27a12 0.477226
Kn12an27a13 Ln12a13 Ln27a13 0.477226
Kn12an27a14 Ln12a14 Ln27a14 0.477226
Kn12an27a15 Ln12a15 Ln27a15 0.477226
Kn12an27a16 Ln12a16 Ln27a16 0.477226
Kn12an28a1 Ln12a1 Ln28a1 0.469680
Kn12an28a2 Ln12a2 Ln28a2 0.469680
Kn12an28a3 Ln12a3 Ln28a3 0.469680
Kn12an28a4 Ln12a4 Ln28a4 0.469680
Kn12an28a5 Ln12a5 Ln28a5 0.469680
Kn12an28a6 Ln12a6 Ln28a6 0.469680
Kn12an28a7 Ln12a7 Ln28a7 0.469680
Kn12an28a8 Ln12a8 Ln28a8 0.469680
Kn12an28a9 Ln12a9 Ln28a9 0.469680
Kn12an28a10 Ln12a10 Ln28a10 0.469680
Kn12an28a11 Ln12a11 Ln28a11 0.469680
Kn12an28a12 Ln12a12 Ln28a12 0.469680
Kn12an28a13 Ln12a13 Ln28a13 0.469680
Kn12an28a14 Ln12a14 Ln28a14 0.469680
Kn12an28a15 Ln12a15 Ln28a15 0.469680
Kn12an28a16 Ln12a16 Ln28a16 0.469680
Kn12an29a1 Ln12a1 Ln29a1 0.463523
Kn12an29a2 Ln12a2 Ln29a2 0.463523
Kn12an29a3 Ln12a3 Ln29a3 0.463523
Kn12an29a4 Ln12a4 Ln29a4 0.463523
Kn12an29a5 Ln12a5 Ln29a5 0.463523
Kn12an29a6 Ln12a6 Ln29a6 0.463523
Kn12an29a7 Ln12a7 Ln29a7 0.463523
Kn12an29a8 Ln12a8 Ln29a8 0.463523
Kn12an29a9 Ln12a9 Ln29a9 0.463523
Kn12an29a10 Ln12a10 Ln29a10 0.463523
Kn12an29a11 Ln12a11 Ln29a11 0.463523
Kn12an29a12 Ln12a12 Ln29a12 0.463523
Kn12an29a13 Ln12a13 Ln29a13 0.463523
Kn12an29a14 Ln12a14 Ln29a14 0.463523
Kn12an29a15 Ln12a15 Ln29a15 0.463523
Kn12an29a16 Ln12a16 Ln29a16 0.463523
Kn12an30a1 Ln12a1 Ln30a1 0.458074
Kn12an30a2 Ln12a2 Ln30a2 0.458074
Kn12an30a3 Ln12a3 Ln30a3 0.458074
Kn12an30a4 Ln12a4 Ln30a4 0.458074
Kn12an30a5 Ln12a5 Ln30a5 0.458074
Kn12an30a6 Ln12a6 Ln30a6 0.458074
Kn12an30a7 Ln12a7 Ln30a7 0.458074
Kn12an30a8 Ln12a8 Ln30a8 0.458074
Kn12an30a9 Ln12a9 Ln30a9 0.458074
Kn12an30a10 Ln12a10 Ln30a10 0.458074
Kn12an30a11 Ln12a11 Ln30a11 0.458074
Kn12an30a12 Ln12a12 Ln30a12 0.458074
Kn12an30a13 Ln12a13 Ln30a13 0.458074
Kn12an30a14 Ln12a14 Ln30a14 0.458074
Kn12an30a15 Ln12a15 Ln30a15 0.458074
Kn12an30a16 Ln12a16 Ln30a16 0.458074
Kn12an31a1 Ln12a1 Ln31a1 0.453889
Kn12an31a2 Ln12a2 Ln31a2 0.453889
Kn12an31a3 Ln12a3 Ln31a3 0.453889
Kn12an31a4 Ln12a4 Ln31a4 0.453889
Kn12an31a5 Ln12a5 Ln31a5 0.453889
Kn12an31a6 Ln12a6 Ln31a6 0.453889
Kn12an31a7 Ln12a7 Ln31a7 0.453889
Kn12an31a8 Ln12a8 Ln31a8 0.453889
Kn12an31a9 Ln12a9 Ln31a9 0.453889
Kn12an31a10 Ln12a10 Ln31a10 0.453889
Kn12an31a11 Ln12a11 Ln31a11 0.453889
Kn12an31a12 Ln12a12 Ln31a12 0.453889
Kn12an31a13 Ln12a13 Ln31a13 0.453889
Kn12an31a14 Ln12a14 Ln31a14 0.453889
Kn12an31a15 Ln12a15 Ln31a15 0.453889
Kn12an31a16 Ln12a16 Ln31a16 0.453889
Kn12an32a1 Ln12a1 Ln32a1 0.450243
Kn12an32a2 Ln12a2 Ln32a2 0.450243
Kn12an32a3 Ln12a3 Ln32a3 0.450243
Kn12an32a4 Ln12a4 Ln32a4 0.450243
Kn12an32a5 Ln12a5 Ln32a5 0.450243
Kn12an32a6 Ln12a6 Ln32a6 0.450243
Kn12an32a7 Ln12a7 Ln32a7 0.450243
Kn12an32a8 Ln12a8 Ln32a8 0.450243
Kn12an32a9 Ln12a9 Ln32a9 0.450243
Kn12an32a10 Ln12a10 Ln32a10 0.450243
Kn12an32a11 Ln12a11 Ln32a11 0.450243
Kn12an32a12 Ln12a12 Ln32a12 0.450243
Kn12an32a13 Ln12a13 Ln32a13 0.450243
Kn12an32a14 Ln12a14 Ln32a14 0.450243
Kn12an32a15 Ln12a15 Ln32a15 0.450243
Kn12an32a16 Ln12a16 Ln32a16 0.450243
Kn12anva1 Ln12a1 Lnva1 0.447456
Kn12anva2 Ln12a2 Lnva2 0.447456
Kn12anva3 Ln12a3 Lnva3 0.447456
Kn12anva4 Ln12a4 Lnva4 0.447456
Kn12anva5 Ln12a5 Lnva5 0.447456
Kn12anva6 Ln12a6 Lnva6 0.447456
Kn12anva7 Ln12a7 Lnva7 0.447456
Kn12anva8 Ln12a8 Lnva8 0.447456
Kn12anva9 Ln12a9 Lnva9 0.447456
Kn12anva10 Ln12a10 Lnva10 0.447456
Kn12anva11 Ln12a11 Lnva11 0.447456
Kn12anva12 Ln12a12 Lnva12 0.447456
Kn12anva13 Ln12a13 Lnva13 0.447456
Kn12anva14 Ln12a14 Lnva14 0.447456
Kn12anva15 Ln12a15 Lnva15 0.447456
Kn12anva16 Ln12a16 Lnva16 0.447456
Kn13an14a1 Ln13a1 Ln14a1 0.805155
Kn13an14a2 Ln13a2 Ln14a2 0.805155
Kn13an14a3 Ln13a3 Ln14a3 0.805155
Kn13an14a4 Ln13a4 Ln14a4 0.805155
Kn13an14a5 Ln13a5 Ln14a5 0.805155
Kn13an14a6 Ln13a6 Ln14a6 0.805155
Kn13an14a7 Ln13a7 Ln14a7 0.805155
Kn13an14a8 Ln13a8 Ln14a8 0.805155
Kn13an14a9 Ln13a9 Ln14a9 0.805155
Kn13an14a10 Ln13a10 Ln14a10 0.805155
Kn13an14a11 Ln13a11 Ln14a11 0.805155
Kn13an14a12 Ln13a12 Ln14a12 0.805155
Kn13an14a13 Ln13a13 Ln14a13 0.805155
Kn13an14a14 Ln13a14 Ln14a14 0.805155
Kn13an14a15 Ln13a15 Ln14a15 0.805155
Kn13an14a16 Ln13a16 Ln14a16 0.805155
Kn13an15a1 Ln13a1 Ln15a1 0.723730
Kn13an15a2 Ln13a2 Ln15a2 0.723730
Kn13an15a3 Ln13a3 Ln15a3 0.723730
Kn13an15a4 Ln13a4 Ln15a4 0.723730
Kn13an15a5 Ln13a5 Ln15a5 0.723730
Kn13an15a6 Ln13a6 Ln15a6 0.723730
Kn13an15a7 Ln13a7 Ln15a7 0.723730
Kn13an15a8 Ln13a8 Ln15a8 0.723730
Kn13an15a9 Ln13a9 Ln15a9 0.723730
Kn13an15a10 Ln13a10 Ln15a10 0.723730
Kn13an15a11 Ln13a11 Ln15a11 0.723730
Kn13an15a12 Ln13a12 Ln15a12 0.723730
Kn13an15a13 Ln13a13 Ln15a13 0.723730
Kn13an15a14 Ln13a14 Ln15a14 0.723730
Kn13an15a15 Ln13a15 Ln15a15 0.723730
Kn13an15a16 Ln13a16 Ln15a16 0.723730
Kn13an16a1 Ln13a1 Ln16a1 0.675208
Kn13an16a2 Ln13a2 Ln16a2 0.675208
Kn13an16a3 Ln13a3 Ln16a3 0.675208
Kn13an16a4 Ln13a4 Ln16a4 0.675208
Kn13an16a5 Ln13a5 Ln16a5 0.675208
Kn13an16a6 Ln13a6 Ln16a6 0.675208
Kn13an16a7 Ln13a7 Ln16a7 0.675208
Kn13an16a8 Ln13a8 Ln16a8 0.675208
Kn13an16a9 Ln13a9 Ln16a9 0.675208
Kn13an16a10 Ln13a10 Ln16a10 0.675208
Kn13an16a11 Ln13a11 Ln16a11 0.675208
Kn13an16a12 Ln13a12 Ln16a12 0.675208
Kn13an16a13 Ln13a13 Ln16a13 0.675208
Kn13an16a14 Ln13a14 Ln16a14 0.675208
Kn13an16a15 Ln13a15 Ln16a15 0.675208
Kn13an16a16 Ln13a16 Ln16a16 0.675208
Kn13an17a1 Ln13a1 Ln17a1 0.640637
Kn13an17a2 Ln13a2 Ln17a2 0.640637
Kn13an17a3 Ln13a3 Ln17a3 0.640637
Kn13an17a4 Ln13a4 Ln17a4 0.640637
Kn13an17a5 Ln13a5 Ln17a5 0.640637
Kn13an17a6 Ln13a6 Ln17a6 0.640637
Kn13an17a7 Ln13a7 Ln17a7 0.640637
Kn13an17a8 Ln13a8 Ln17a8 0.640637
Kn13an17a9 Ln13a9 Ln17a9 0.640637
Kn13an17a10 Ln13a10 Ln17a10 0.640637
Kn13an17a11 Ln13a11 Ln17a11 0.640637
Kn13an17a12 Ln13a12 Ln17a12 0.640637
Kn13an17a13 Ln13a13 Ln17a13 0.640637
Kn13an17a14 Ln13a14 Ln17a14 0.640637
Kn13an17a15 Ln13a15 Ln17a15 0.640637
Kn13an17a16 Ln13a16 Ln17a16 0.640637
Kn13an18a1 Ln13a1 Ln18a1 0.613723
Kn13an18a2 Ln13a2 Ln18a2 0.613723
Kn13an18a3 Ln13a3 Ln18a3 0.613723
Kn13an18a4 Ln13a4 Ln18a4 0.613723
Kn13an18a5 Ln13a5 Ln18a5 0.613723
Kn13an18a6 Ln13a6 Ln18a6 0.613723
Kn13an18a7 Ln13a7 Ln18a7 0.613723
Kn13an18a8 Ln13a8 Ln18a8 0.613723
Kn13an18a9 Ln13a9 Ln18a9 0.613723
Kn13an18a10 Ln13a10 Ln18a10 0.613723
Kn13an18a11 Ln13a11 Ln18a11 0.613723
Kn13an18a12 Ln13a12 Ln18a12 0.613723
Kn13an18a13 Ln13a13 Ln18a13 0.613723
Kn13an18a14 Ln13a14 Ln18a14 0.613723
Kn13an18a15 Ln13a15 Ln18a15 0.613723
Kn13an18a16 Ln13a16 Ln18a16 0.613723
Kn13an19a1 Ln13a1 Ln19a1 0.591812
Kn13an19a2 Ln13a2 Ln19a2 0.591812
Kn13an19a3 Ln13a3 Ln19a3 0.591812
Kn13an19a4 Ln13a4 Ln19a4 0.591812
Kn13an19a5 Ln13a5 Ln19a5 0.591812
Kn13an19a6 Ln13a6 Ln19a6 0.591812
Kn13an19a7 Ln13a7 Ln19a7 0.591812
Kn13an19a8 Ln13a8 Ln19a8 0.591812
Kn13an19a9 Ln13a9 Ln19a9 0.591812
Kn13an19a10 Ln13a10 Ln19a10 0.591812
Kn13an19a11 Ln13a11 Ln19a11 0.591812
Kn13an19a12 Ln13a12 Ln19a12 0.591812
Kn13an19a13 Ln13a13 Ln19a13 0.591812
Kn13an19a14 Ln13a14 Ln19a14 0.591812
Kn13an19a15 Ln13a15 Ln19a15 0.591812
Kn13an19a16 Ln13a16 Ln19a16 0.591812
Kn13an20a1 Ln13a1 Ln20a1 0.573237
Kn13an20a2 Ln13a2 Ln20a2 0.573237
Kn13an20a3 Ln13a3 Ln20a3 0.573237
Kn13an20a4 Ln13a4 Ln20a4 0.573237
Kn13an20a5 Ln13a5 Ln20a5 0.573237
Kn13an20a6 Ln13a6 Ln20a6 0.573237
Kn13an20a7 Ln13a7 Ln20a7 0.573237
Kn13an20a8 Ln13a8 Ln20a8 0.573237
Kn13an20a9 Ln13a9 Ln20a9 0.573237
Kn13an20a10 Ln13a10 Ln20a10 0.573237
Kn13an20a11 Ln13a11 Ln20a11 0.573237
Kn13an20a12 Ln13a12 Ln20a12 0.573237
Kn13an20a13 Ln13a13 Ln20a13 0.573237
Kn13an20a14 Ln13a14 Ln20a14 0.573237
Kn13an20a15 Ln13a15 Ln20a15 0.573237
Kn13an20a16 Ln13a16 Ln20a16 0.573237
Kn13an21a1 Ln13a1 Ln21a1 0.557165
Kn13an21a2 Ln13a2 Ln21a2 0.557165
Kn13an21a3 Ln13a3 Ln21a3 0.557165
Kn13an21a4 Ln13a4 Ln21a4 0.557165
Kn13an21a5 Ln13a5 Ln21a5 0.557165
Kn13an21a6 Ln13a6 Ln21a6 0.557165
Kn13an21a7 Ln13a7 Ln21a7 0.557165
Kn13an21a8 Ln13a8 Ln21a8 0.557165
Kn13an21a9 Ln13a9 Ln21a9 0.557165
Kn13an21a10 Ln13a10 Ln21a10 0.557165
Kn13an21a11 Ln13a11 Ln21a11 0.557165
Kn13an21a12 Ln13a12 Ln21a12 0.557165
Kn13an21a13 Ln13a13 Ln21a13 0.557165
Kn13an21a14 Ln13a14 Ln21a14 0.557165
Kn13an21a15 Ln13a15 Ln21a15 0.557165
Kn13an21a16 Ln13a16 Ln21a16 0.557165
Kn13an22a1 Ln13a1 Ln22a1 0.542987
Kn13an22a2 Ln13a2 Ln22a2 0.542987
Kn13an22a3 Ln13a3 Ln22a3 0.542987
Kn13an22a4 Ln13a4 Ln22a4 0.542987
Kn13an22a5 Ln13a5 Ln22a5 0.542987
Kn13an22a6 Ln13a6 Ln22a6 0.542987
Kn13an22a7 Ln13a7 Ln22a7 0.542987
Kn13an22a8 Ln13a8 Ln22a8 0.542987
Kn13an22a9 Ln13a9 Ln22a9 0.542987
Kn13an22a10 Ln13a10 Ln22a10 0.542987
Kn13an22a11 Ln13a11 Ln22a11 0.542987
Kn13an22a12 Ln13a12 Ln22a12 0.542987
Kn13an22a13 Ln13a13 Ln22a13 0.542987
Kn13an22a14 Ln13a14 Ln22a14 0.542987
Kn13an22a15 Ln13a15 Ln22a15 0.542987
Kn13an22a16 Ln13a16 Ln22a16 0.542987
Kn13an23a1 Ln13a1 Ln23a1 0.529400
Kn13an23a2 Ln13a2 Ln23a2 0.529400
Kn13an23a3 Ln13a3 Ln23a3 0.529400
Kn13an23a4 Ln13a4 Ln23a4 0.529400
Kn13an23a5 Ln13a5 Ln23a5 0.529400
Kn13an23a6 Ln13a6 Ln23a6 0.529400
Kn13an23a7 Ln13a7 Ln23a7 0.529400
Kn13an23a8 Ln13a8 Ln23a8 0.529400
Kn13an23a9 Ln13a9 Ln23a9 0.529400
Kn13an23a10 Ln13a10 Ln23a10 0.529400
Kn13an23a11 Ln13a11 Ln23a11 0.529400
Kn13an23a12 Ln13a12 Ln23a12 0.529400
Kn13an23a13 Ln13a13 Ln23a13 0.529400
Kn13an23a14 Ln13a14 Ln23a14 0.529400
Kn13an23a15 Ln13a15 Ln23a15 0.529400
Kn13an23a16 Ln13a16 Ln23a16 0.529400
Kn13an24a1 Ln13a1 Ln24a1 0.516943
Kn13an24a2 Ln13a2 Ln24a2 0.516943
Kn13an24a3 Ln13a3 Ln24a3 0.516943
Kn13an24a4 Ln13a4 Ln24a4 0.516943
Kn13an24a5 Ln13a5 Ln24a5 0.516943
Kn13an24a6 Ln13a6 Ln24a6 0.516943
Kn13an24a7 Ln13a7 Ln24a7 0.516943
Kn13an24a8 Ln13a8 Ln24a8 0.516943
Kn13an24a9 Ln13a9 Ln24a9 0.516943
Kn13an24a10 Ln13a10 Ln24a10 0.516943
Kn13an24a11 Ln13a11 Ln24a11 0.516943
Kn13an24a12 Ln13a12 Ln24a12 0.516943
Kn13an24a13 Ln13a13 Ln24a13 0.516943
Kn13an24a14 Ln13a14 Ln24a14 0.516943
Kn13an24a15 Ln13a15 Ln24a15 0.516943
Kn13an24a16 Ln13a16 Ln24a16 0.516943
Kn13an25a1 Ln13a1 Ln25a1 0.505455
Kn13an25a2 Ln13a2 Ln25a2 0.505455
Kn13an25a3 Ln13a3 Ln25a3 0.505455
Kn13an25a4 Ln13a4 Ln25a4 0.505455
Kn13an25a5 Ln13a5 Ln25a5 0.505455
Kn13an25a6 Ln13a6 Ln25a6 0.505455
Kn13an25a7 Ln13a7 Ln25a7 0.505455
Kn13an25a8 Ln13a8 Ln25a8 0.505455
Kn13an25a9 Ln13a9 Ln25a9 0.505455
Kn13an25a10 Ln13a10 Ln25a10 0.505455
Kn13an25a11 Ln13a11 Ln25a11 0.505455
Kn13an25a12 Ln13a12 Ln25a12 0.505455
Kn13an25a13 Ln13a13 Ln25a13 0.505455
Kn13an25a14 Ln13a14 Ln25a14 0.505455
Kn13an25a15 Ln13a15 Ln25a15 0.505455
Kn13an25a16 Ln13a16 Ln25a16 0.505455
Kn13an26a1 Ln13a1 Ln26a1 0.494887
Kn13an26a2 Ln13a2 Ln26a2 0.494887
Kn13an26a3 Ln13a3 Ln26a3 0.494887
Kn13an26a4 Ln13a4 Ln26a4 0.494887
Kn13an26a5 Ln13a5 Ln26a5 0.494887
Kn13an26a6 Ln13a6 Ln26a6 0.494887
Kn13an26a7 Ln13a7 Ln26a7 0.494887
Kn13an26a8 Ln13a8 Ln26a8 0.494887
Kn13an26a9 Ln13a9 Ln26a9 0.494887
Kn13an26a10 Ln13a10 Ln26a10 0.494887
Kn13an26a11 Ln13a11 Ln26a11 0.494887
Kn13an26a12 Ln13a12 Ln26a12 0.494887
Kn13an26a13 Ln13a13 Ln26a13 0.494887
Kn13an26a14 Ln13a14 Ln26a14 0.494887
Kn13an26a15 Ln13a15 Ln26a15 0.494887
Kn13an26a16 Ln13a16 Ln26a16 0.494887
Kn13an27a1 Ln13a1 Ln27a1 0.485771
Kn13an27a2 Ln13a2 Ln27a2 0.485771
Kn13an27a3 Ln13a3 Ln27a3 0.485771
Kn13an27a4 Ln13a4 Ln27a4 0.485771
Kn13an27a5 Ln13a5 Ln27a5 0.485771
Kn13an27a6 Ln13a6 Ln27a6 0.485771
Kn13an27a7 Ln13a7 Ln27a7 0.485771
Kn13an27a8 Ln13a8 Ln27a8 0.485771
Kn13an27a9 Ln13a9 Ln27a9 0.485771
Kn13an27a10 Ln13a10 Ln27a10 0.485771
Kn13an27a11 Ln13a11 Ln27a11 0.485771
Kn13an27a12 Ln13a12 Ln27a12 0.485771
Kn13an27a13 Ln13a13 Ln27a13 0.485771
Kn13an27a14 Ln13a14 Ln27a14 0.485771
Kn13an27a15 Ln13a15 Ln27a15 0.485771
Kn13an27a16 Ln13a16 Ln27a16 0.485771
Kn13an28a1 Ln13a1 Ln28a1 0.477226
Kn13an28a2 Ln13a2 Ln28a2 0.477226
Kn13an28a3 Ln13a3 Ln28a3 0.477226
Kn13an28a4 Ln13a4 Ln28a4 0.477226
Kn13an28a5 Ln13a5 Ln28a5 0.477226
Kn13an28a6 Ln13a6 Ln28a6 0.477226
Kn13an28a7 Ln13a7 Ln28a7 0.477226
Kn13an28a8 Ln13a8 Ln28a8 0.477226
Kn13an28a9 Ln13a9 Ln28a9 0.477226
Kn13an28a10 Ln13a10 Ln28a10 0.477226
Kn13an28a11 Ln13a11 Ln28a11 0.477226
Kn13an28a12 Ln13a12 Ln28a12 0.477226
Kn13an28a13 Ln13a13 Ln28a13 0.477226
Kn13an28a14 Ln13a14 Ln28a14 0.477226
Kn13an28a15 Ln13a15 Ln28a15 0.477226
Kn13an28a16 Ln13a16 Ln28a16 0.477226
Kn13an29a1 Ln13a1 Ln29a1 0.469680
Kn13an29a2 Ln13a2 Ln29a2 0.469680
Kn13an29a3 Ln13a3 Ln29a3 0.469680
Kn13an29a4 Ln13a4 Ln29a4 0.469680
Kn13an29a5 Ln13a5 Ln29a5 0.469680
Kn13an29a6 Ln13a6 Ln29a6 0.469680
Kn13an29a7 Ln13a7 Ln29a7 0.469680
Kn13an29a8 Ln13a8 Ln29a8 0.469680
Kn13an29a9 Ln13a9 Ln29a9 0.469680
Kn13an29a10 Ln13a10 Ln29a10 0.469680
Kn13an29a11 Ln13a11 Ln29a11 0.469680
Kn13an29a12 Ln13a12 Ln29a12 0.469680
Kn13an29a13 Ln13a13 Ln29a13 0.469680
Kn13an29a14 Ln13a14 Ln29a14 0.469680
Kn13an29a15 Ln13a15 Ln29a15 0.469680
Kn13an29a16 Ln13a16 Ln29a16 0.469680
Kn13an30a1 Ln13a1 Ln30a1 0.463523
Kn13an30a2 Ln13a2 Ln30a2 0.463523
Kn13an30a3 Ln13a3 Ln30a3 0.463523
Kn13an30a4 Ln13a4 Ln30a4 0.463523
Kn13an30a5 Ln13a5 Ln30a5 0.463523
Kn13an30a6 Ln13a6 Ln30a6 0.463523
Kn13an30a7 Ln13a7 Ln30a7 0.463523
Kn13an30a8 Ln13a8 Ln30a8 0.463523
Kn13an30a9 Ln13a9 Ln30a9 0.463523
Kn13an30a10 Ln13a10 Ln30a10 0.463523
Kn13an30a11 Ln13a11 Ln30a11 0.463523
Kn13an30a12 Ln13a12 Ln30a12 0.463523
Kn13an30a13 Ln13a13 Ln30a13 0.463523
Kn13an30a14 Ln13a14 Ln30a14 0.463523
Kn13an30a15 Ln13a15 Ln30a15 0.463523
Kn13an30a16 Ln13a16 Ln30a16 0.463523
Kn13an31a1 Ln13a1 Ln31a1 0.458074
Kn13an31a2 Ln13a2 Ln31a2 0.458074
Kn13an31a3 Ln13a3 Ln31a3 0.458074
Kn13an31a4 Ln13a4 Ln31a4 0.458074
Kn13an31a5 Ln13a5 Ln31a5 0.458074
Kn13an31a6 Ln13a6 Ln31a6 0.458074
Kn13an31a7 Ln13a7 Ln31a7 0.458074
Kn13an31a8 Ln13a8 Ln31a8 0.458074
Kn13an31a9 Ln13a9 Ln31a9 0.458074
Kn13an31a10 Ln13a10 Ln31a10 0.458074
Kn13an31a11 Ln13a11 Ln31a11 0.458074
Kn13an31a12 Ln13a12 Ln31a12 0.458074
Kn13an31a13 Ln13a13 Ln31a13 0.458074
Kn13an31a14 Ln13a14 Ln31a14 0.458074
Kn13an31a15 Ln13a15 Ln31a15 0.458074
Kn13an31a16 Ln13a16 Ln31a16 0.458074
Kn13an32a1 Ln13a1 Ln32a1 0.453889
Kn13an32a2 Ln13a2 Ln32a2 0.453889
Kn13an32a3 Ln13a3 Ln32a3 0.453889
Kn13an32a4 Ln13a4 Ln32a4 0.453889
Kn13an32a5 Ln13a5 Ln32a5 0.453889
Kn13an32a6 Ln13a6 Ln32a6 0.453889
Kn13an32a7 Ln13a7 Ln32a7 0.453889
Kn13an32a8 Ln13a8 Ln32a8 0.453889
Kn13an32a9 Ln13a9 Ln32a9 0.453889
Kn13an32a10 Ln13a10 Ln32a10 0.453889
Kn13an32a11 Ln13a11 Ln32a11 0.453889
Kn13an32a12 Ln13a12 Ln32a12 0.453889
Kn13an32a13 Ln13a13 Ln32a13 0.453889
Kn13an32a14 Ln13a14 Ln32a14 0.453889
Kn13an32a15 Ln13a15 Ln32a15 0.453889
Kn13an32a16 Ln13a16 Ln32a16 0.453889
Kn13anva1 Ln13a1 Lnva1 0.450243
Kn13anva2 Ln13a2 Lnva2 0.450243
Kn13anva3 Ln13a3 Lnva3 0.450243
Kn13anva4 Ln13a4 Lnva4 0.450243
Kn13anva5 Ln13a5 Lnva5 0.450243
Kn13anva6 Ln13a6 Lnva6 0.450243
Kn13anva7 Ln13a7 Lnva7 0.450243
Kn13anva8 Ln13a8 Lnva8 0.450243
Kn13anva9 Ln13a9 Lnva9 0.450243
Kn13anva10 Ln13a10 Lnva10 0.450243
Kn13anva11 Ln13a11 Lnva11 0.450243
Kn13anva12 Ln13a12 Lnva12 0.450243
Kn13anva13 Ln13a13 Lnva13 0.450243
Kn13anva14 Ln13a14 Lnva14 0.450243
Kn13anva15 Ln13a15 Lnva15 0.450243
Kn13anva16 Ln13a16 Lnva16 0.450243
Kn14an15a1 Ln14a1 Ln15a1 0.805155
Kn14an15a2 Ln14a2 Ln15a2 0.805155
Kn14an15a3 Ln14a3 Ln15a3 0.805155
Kn14an15a4 Ln14a4 Ln15a4 0.805155
Kn14an15a5 Ln14a5 Ln15a5 0.805155
Kn14an15a6 Ln14a6 Ln15a6 0.805155
Kn14an15a7 Ln14a7 Ln15a7 0.805155
Kn14an15a8 Ln14a8 Ln15a8 0.805155
Kn14an15a9 Ln14a9 Ln15a9 0.805155
Kn14an15a10 Ln14a10 Ln15a10 0.805155
Kn14an15a11 Ln14a11 Ln15a11 0.805155
Kn14an15a12 Ln14a12 Ln15a12 0.805155
Kn14an15a13 Ln14a13 Ln15a13 0.805155
Kn14an15a14 Ln14a14 Ln15a14 0.805155
Kn14an15a15 Ln14a15 Ln15a15 0.805155
Kn14an15a16 Ln14a16 Ln15a16 0.805155
Kn14an16a1 Ln14a1 Ln16a1 0.723730
Kn14an16a2 Ln14a2 Ln16a2 0.723730
Kn14an16a3 Ln14a3 Ln16a3 0.723730
Kn14an16a4 Ln14a4 Ln16a4 0.723730
Kn14an16a5 Ln14a5 Ln16a5 0.723730
Kn14an16a6 Ln14a6 Ln16a6 0.723730
Kn14an16a7 Ln14a7 Ln16a7 0.723730
Kn14an16a8 Ln14a8 Ln16a8 0.723730
Kn14an16a9 Ln14a9 Ln16a9 0.723730
Kn14an16a10 Ln14a10 Ln16a10 0.723730
Kn14an16a11 Ln14a11 Ln16a11 0.723730
Kn14an16a12 Ln14a12 Ln16a12 0.723730
Kn14an16a13 Ln14a13 Ln16a13 0.723730
Kn14an16a14 Ln14a14 Ln16a14 0.723730
Kn14an16a15 Ln14a15 Ln16a15 0.723730
Kn14an16a16 Ln14a16 Ln16a16 0.723730
Kn14an17a1 Ln14a1 Ln17a1 0.675208
Kn14an17a2 Ln14a2 Ln17a2 0.675208
Kn14an17a3 Ln14a3 Ln17a3 0.675208
Kn14an17a4 Ln14a4 Ln17a4 0.675208
Kn14an17a5 Ln14a5 Ln17a5 0.675208
Kn14an17a6 Ln14a6 Ln17a6 0.675208
Kn14an17a7 Ln14a7 Ln17a7 0.675208
Kn14an17a8 Ln14a8 Ln17a8 0.675208
Kn14an17a9 Ln14a9 Ln17a9 0.675208
Kn14an17a10 Ln14a10 Ln17a10 0.675208
Kn14an17a11 Ln14a11 Ln17a11 0.675208
Kn14an17a12 Ln14a12 Ln17a12 0.675208
Kn14an17a13 Ln14a13 Ln17a13 0.675208
Kn14an17a14 Ln14a14 Ln17a14 0.675208
Kn14an17a15 Ln14a15 Ln17a15 0.675208
Kn14an17a16 Ln14a16 Ln17a16 0.675208
Kn14an18a1 Ln14a1 Ln18a1 0.640637
Kn14an18a2 Ln14a2 Ln18a2 0.640637
Kn14an18a3 Ln14a3 Ln18a3 0.640637
Kn14an18a4 Ln14a4 Ln18a4 0.640637
Kn14an18a5 Ln14a5 Ln18a5 0.640637
Kn14an18a6 Ln14a6 Ln18a6 0.640637
Kn14an18a7 Ln14a7 Ln18a7 0.640637
Kn14an18a8 Ln14a8 Ln18a8 0.640637
Kn14an18a9 Ln14a9 Ln18a9 0.640637
Kn14an18a10 Ln14a10 Ln18a10 0.640637
Kn14an18a11 Ln14a11 Ln18a11 0.640637
Kn14an18a12 Ln14a12 Ln18a12 0.640637
Kn14an18a13 Ln14a13 Ln18a13 0.640637
Kn14an18a14 Ln14a14 Ln18a14 0.640637
Kn14an18a15 Ln14a15 Ln18a15 0.640637
Kn14an18a16 Ln14a16 Ln18a16 0.640637
Kn14an19a1 Ln14a1 Ln19a1 0.613723
Kn14an19a2 Ln14a2 Ln19a2 0.613723
Kn14an19a3 Ln14a3 Ln19a3 0.613723
Kn14an19a4 Ln14a4 Ln19a4 0.613723
Kn14an19a5 Ln14a5 Ln19a5 0.613723
Kn14an19a6 Ln14a6 Ln19a6 0.613723
Kn14an19a7 Ln14a7 Ln19a7 0.613723
Kn14an19a8 Ln14a8 Ln19a8 0.613723
Kn14an19a9 Ln14a9 Ln19a9 0.613723
Kn14an19a10 Ln14a10 Ln19a10 0.613723
Kn14an19a11 Ln14a11 Ln19a11 0.613723
Kn14an19a12 Ln14a12 Ln19a12 0.613723
Kn14an19a13 Ln14a13 Ln19a13 0.613723
Kn14an19a14 Ln14a14 Ln19a14 0.613723
Kn14an19a15 Ln14a15 Ln19a15 0.613723
Kn14an19a16 Ln14a16 Ln19a16 0.613723
Kn14an20a1 Ln14a1 Ln20a1 0.591812
Kn14an20a2 Ln14a2 Ln20a2 0.591812
Kn14an20a3 Ln14a3 Ln20a3 0.591812
Kn14an20a4 Ln14a4 Ln20a4 0.591812
Kn14an20a5 Ln14a5 Ln20a5 0.591812
Kn14an20a6 Ln14a6 Ln20a6 0.591812
Kn14an20a7 Ln14a7 Ln20a7 0.591812
Kn14an20a8 Ln14a8 Ln20a8 0.591812
Kn14an20a9 Ln14a9 Ln20a9 0.591812
Kn14an20a10 Ln14a10 Ln20a10 0.591812
Kn14an20a11 Ln14a11 Ln20a11 0.591812
Kn14an20a12 Ln14a12 Ln20a12 0.591812
Kn14an20a13 Ln14a13 Ln20a13 0.591812
Kn14an20a14 Ln14a14 Ln20a14 0.591812
Kn14an20a15 Ln14a15 Ln20a15 0.591812
Kn14an20a16 Ln14a16 Ln20a16 0.591812
Kn14an21a1 Ln14a1 Ln21a1 0.573237
Kn14an21a2 Ln14a2 Ln21a2 0.573237
Kn14an21a3 Ln14a3 Ln21a3 0.573237
Kn14an21a4 Ln14a4 Ln21a4 0.573237
Kn14an21a5 Ln14a5 Ln21a5 0.573237
Kn14an21a6 Ln14a6 Ln21a6 0.573237
Kn14an21a7 Ln14a7 Ln21a7 0.573237
Kn14an21a8 Ln14a8 Ln21a8 0.573237
Kn14an21a9 Ln14a9 Ln21a9 0.573237
Kn14an21a10 Ln14a10 Ln21a10 0.573237
Kn14an21a11 Ln14a11 Ln21a11 0.573237
Kn14an21a12 Ln14a12 Ln21a12 0.573237
Kn14an21a13 Ln14a13 Ln21a13 0.573237
Kn14an21a14 Ln14a14 Ln21a14 0.573237
Kn14an21a15 Ln14a15 Ln21a15 0.573237
Kn14an21a16 Ln14a16 Ln21a16 0.573237
Kn14an22a1 Ln14a1 Ln22a1 0.557165
Kn14an22a2 Ln14a2 Ln22a2 0.557165
Kn14an22a3 Ln14a3 Ln22a3 0.557165
Kn14an22a4 Ln14a4 Ln22a4 0.557165
Kn14an22a5 Ln14a5 Ln22a5 0.557165
Kn14an22a6 Ln14a6 Ln22a6 0.557165
Kn14an22a7 Ln14a7 Ln22a7 0.557165
Kn14an22a8 Ln14a8 Ln22a8 0.557165
Kn14an22a9 Ln14a9 Ln22a9 0.557165
Kn14an22a10 Ln14a10 Ln22a10 0.557165
Kn14an22a11 Ln14a11 Ln22a11 0.557165
Kn14an22a12 Ln14a12 Ln22a12 0.557165
Kn14an22a13 Ln14a13 Ln22a13 0.557165
Kn14an22a14 Ln14a14 Ln22a14 0.557165
Kn14an22a15 Ln14a15 Ln22a15 0.557165
Kn14an22a16 Ln14a16 Ln22a16 0.557165
Kn14an23a1 Ln14a1 Ln23a1 0.542987
Kn14an23a2 Ln14a2 Ln23a2 0.542987
Kn14an23a3 Ln14a3 Ln23a3 0.542987
Kn14an23a4 Ln14a4 Ln23a4 0.542987
Kn14an23a5 Ln14a5 Ln23a5 0.542987
Kn14an23a6 Ln14a6 Ln23a6 0.542987
Kn14an23a7 Ln14a7 Ln23a7 0.542987
Kn14an23a8 Ln14a8 Ln23a8 0.542987
Kn14an23a9 Ln14a9 Ln23a9 0.542987
Kn14an23a10 Ln14a10 Ln23a10 0.542987
Kn14an23a11 Ln14a11 Ln23a11 0.542987
Kn14an23a12 Ln14a12 Ln23a12 0.542987
Kn14an23a13 Ln14a13 Ln23a13 0.542987
Kn14an23a14 Ln14a14 Ln23a14 0.542987
Kn14an23a15 Ln14a15 Ln23a15 0.542987
Kn14an23a16 Ln14a16 Ln23a16 0.542987
Kn14an24a1 Ln14a1 Ln24a1 0.529400
Kn14an24a2 Ln14a2 Ln24a2 0.529400
Kn14an24a3 Ln14a3 Ln24a3 0.529400
Kn14an24a4 Ln14a4 Ln24a4 0.529400
Kn14an24a5 Ln14a5 Ln24a5 0.529400
Kn14an24a6 Ln14a6 Ln24a6 0.529400
Kn14an24a7 Ln14a7 Ln24a7 0.529400
Kn14an24a8 Ln14a8 Ln24a8 0.529400
Kn14an24a9 Ln14a9 Ln24a9 0.529400
Kn14an24a10 Ln14a10 Ln24a10 0.529400
Kn14an24a11 Ln14a11 Ln24a11 0.529400
Kn14an24a12 Ln14a12 Ln24a12 0.529400
Kn14an24a13 Ln14a13 Ln24a13 0.529400
Kn14an24a14 Ln14a14 Ln24a14 0.529400
Kn14an24a15 Ln14a15 Ln24a15 0.529400
Kn14an24a16 Ln14a16 Ln24a16 0.529400
Kn14an25a1 Ln14a1 Ln25a1 0.516943
Kn14an25a2 Ln14a2 Ln25a2 0.516943
Kn14an25a3 Ln14a3 Ln25a3 0.516943
Kn14an25a4 Ln14a4 Ln25a4 0.516943
Kn14an25a5 Ln14a5 Ln25a5 0.516943
Kn14an25a6 Ln14a6 Ln25a6 0.516943
Kn14an25a7 Ln14a7 Ln25a7 0.516943
Kn14an25a8 Ln14a8 Ln25a8 0.516943
Kn14an25a9 Ln14a9 Ln25a9 0.516943
Kn14an25a10 Ln14a10 Ln25a10 0.516943
Kn14an25a11 Ln14a11 Ln25a11 0.516943
Kn14an25a12 Ln14a12 Ln25a12 0.516943
Kn14an25a13 Ln14a13 Ln25a13 0.516943
Kn14an25a14 Ln14a14 Ln25a14 0.516943
Kn14an25a15 Ln14a15 Ln25a15 0.516943
Kn14an25a16 Ln14a16 Ln25a16 0.516943
Kn14an26a1 Ln14a1 Ln26a1 0.505455
Kn14an26a2 Ln14a2 Ln26a2 0.505455
Kn14an26a3 Ln14a3 Ln26a3 0.505455
Kn14an26a4 Ln14a4 Ln26a4 0.505455
Kn14an26a5 Ln14a5 Ln26a5 0.505455
Kn14an26a6 Ln14a6 Ln26a6 0.505455
Kn14an26a7 Ln14a7 Ln26a7 0.505455
Kn14an26a8 Ln14a8 Ln26a8 0.505455
Kn14an26a9 Ln14a9 Ln26a9 0.505455
Kn14an26a10 Ln14a10 Ln26a10 0.505455
Kn14an26a11 Ln14a11 Ln26a11 0.505455
Kn14an26a12 Ln14a12 Ln26a12 0.505455
Kn14an26a13 Ln14a13 Ln26a13 0.505455
Kn14an26a14 Ln14a14 Ln26a14 0.505455
Kn14an26a15 Ln14a15 Ln26a15 0.505455
Kn14an26a16 Ln14a16 Ln26a16 0.505455
Kn14an27a1 Ln14a1 Ln27a1 0.494887
Kn14an27a2 Ln14a2 Ln27a2 0.494887
Kn14an27a3 Ln14a3 Ln27a3 0.494887
Kn14an27a4 Ln14a4 Ln27a4 0.494887
Kn14an27a5 Ln14a5 Ln27a5 0.494887
Kn14an27a6 Ln14a6 Ln27a6 0.494887
Kn14an27a7 Ln14a7 Ln27a7 0.494887
Kn14an27a8 Ln14a8 Ln27a8 0.494887
Kn14an27a9 Ln14a9 Ln27a9 0.494887
Kn14an27a10 Ln14a10 Ln27a10 0.494887
Kn14an27a11 Ln14a11 Ln27a11 0.494887
Kn14an27a12 Ln14a12 Ln27a12 0.494887
Kn14an27a13 Ln14a13 Ln27a13 0.494887
Kn14an27a14 Ln14a14 Ln27a14 0.494887
Kn14an27a15 Ln14a15 Ln27a15 0.494887
Kn14an27a16 Ln14a16 Ln27a16 0.494887
Kn14an28a1 Ln14a1 Ln28a1 0.485771
Kn14an28a2 Ln14a2 Ln28a2 0.485771
Kn14an28a3 Ln14a3 Ln28a3 0.485771
Kn14an28a4 Ln14a4 Ln28a4 0.485771
Kn14an28a5 Ln14a5 Ln28a5 0.485771
Kn14an28a6 Ln14a6 Ln28a6 0.485771
Kn14an28a7 Ln14a7 Ln28a7 0.485771
Kn14an28a8 Ln14a8 Ln28a8 0.485771
Kn14an28a9 Ln14a9 Ln28a9 0.485771
Kn14an28a10 Ln14a10 Ln28a10 0.485771
Kn14an28a11 Ln14a11 Ln28a11 0.485771
Kn14an28a12 Ln14a12 Ln28a12 0.485771
Kn14an28a13 Ln14a13 Ln28a13 0.485771
Kn14an28a14 Ln14a14 Ln28a14 0.485771
Kn14an28a15 Ln14a15 Ln28a15 0.485771
Kn14an28a16 Ln14a16 Ln28a16 0.485771
Kn14an29a1 Ln14a1 Ln29a1 0.477226
Kn14an29a2 Ln14a2 Ln29a2 0.477226
Kn14an29a3 Ln14a3 Ln29a3 0.477226
Kn14an29a4 Ln14a4 Ln29a4 0.477226
Kn14an29a5 Ln14a5 Ln29a5 0.477226
Kn14an29a6 Ln14a6 Ln29a6 0.477226
Kn14an29a7 Ln14a7 Ln29a7 0.477226
Kn14an29a8 Ln14a8 Ln29a8 0.477226
Kn14an29a9 Ln14a9 Ln29a9 0.477226
Kn14an29a10 Ln14a10 Ln29a10 0.477226
Kn14an29a11 Ln14a11 Ln29a11 0.477226
Kn14an29a12 Ln14a12 Ln29a12 0.477226
Kn14an29a13 Ln14a13 Ln29a13 0.477226
Kn14an29a14 Ln14a14 Ln29a14 0.477226
Kn14an29a15 Ln14a15 Ln29a15 0.477226
Kn14an29a16 Ln14a16 Ln29a16 0.477226
Kn14an30a1 Ln14a1 Ln30a1 0.469680
Kn14an30a2 Ln14a2 Ln30a2 0.469680
Kn14an30a3 Ln14a3 Ln30a3 0.469680
Kn14an30a4 Ln14a4 Ln30a4 0.469680
Kn14an30a5 Ln14a5 Ln30a5 0.469680
Kn14an30a6 Ln14a6 Ln30a6 0.469680
Kn14an30a7 Ln14a7 Ln30a7 0.469680
Kn14an30a8 Ln14a8 Ln30a8 0.469680
Kn14an30a9 Ln14a9 Ln30a9 0.469680
Kn14an30a10 Ln14a10 Ln30a10 0.469680
Kn14an30a11 Ln14a11 Ln30a11 0.469680
Kn14an30a12 Ln14a12 Ln30a12 0.469680
Kn14an30a13 Ln14a13 Ln30a13 0.469680
Kn14an30a14 Ln14a14 Ln30a14 0.469680
Kn14an30a15 Ln14a15 Ln30a15 0.469680
Kn14an30a16 Ln14a16 Ln30a16 0.469680
Kn14an31a1 Ln14a1 Ln31a1 0.463523
Kn14an31a2 Ln14a2 Ln31a2 0.463523
Kn14an31a3 Ln14a3 Ln31a3 0.463523
Kn14an31a4 Ln14a4 Ln31a4 0.463523
Kn14an31a5 Ln14a5 Ln31a5 0.463523
Kn14an31a6 Ln14a6 Ln31a6 0.463523
Kn14an31a7 Ln14a7 Ln31a7 0.463523
Kn14an31a8 Ln14a8 Ln31a8 0.463523
Kn14an31a9 Ln14a9 Ln31a9 0.463523
Kn14an31a10 Ln14a10 Ln31a10 0.463523
Kn14an31a11 Ln14a11 Ln31a11 0.463523
Kn14an31a12 Ln14a12 Ln31a12 0.463523
Kn14an31a13 Ln14a13 Ln31a13 0.463523
Kn14an31a14 Ln14a14 Ln31a14 0.463523
Kn14an31a15 Ln14a15 Ln31a15 0.463523
Kn14an31a16 Ln14a16 Ln31a16 0.463523
Kn14an32a1 Ln14a1 Ln32a1 0.458074
Kn14an32a2 Ln14a2 Ln32a2 0.458074
Kn14an32a3 Ln14a3 Ln32a3 0.458074
Kn14an32a4 Ln14a4 Ln32a4 0.458074
Kn14an32a5 Ln14a5 Ln32a5 0.458074
Kn14an32a6 Ln14a6 Ln32a6 0.458074
Kn14an32a7 Ln14a7 Ln32a7 0.458074
Kn14an32a8 Ln14a8 Ln32a8 0.458074
Kn14an32a9 Ln14a9 Ln32a9 0.458074
Kn14an32a10 Ln14a10 Ln32a10 0.458074
Kn14an32a11 Ln14a11 Ln32a11 0.458074
Kn14an32a12 Ln14a12 Ln32a12 0.458074
Kn14an32a13 Ln14a13 Ln32a13 0.458074
Kn14an32a14 Ln14a14 Ln32a14 0.458074
Kn14an32a15 Ln14a15 Ln32a15 0.458074
Kn14an32a16 Ln14a16 Ln32a16 0.458074
Kn14anva1 Ln14a1 Lnva1 0.453889
Kn14anva2 Ln14a2 Lnva2 0.453889
Kn14anva3 Ln14a3 Lnva3 0.453889
Kn14anva4 Ln14a4 Lnva4 0.453889
Kn14anva5 Ln14a5 Lnva5 0.453889
Kn14anva6 Ln14a6 Lnva6 0.453889
Kn14anva7 Ln14a7 Lnva7 0.453889
Kn14anva8 Ln14a8 Lnva8 0.453889
Kn14anva9 Ln14a9 Lnva9 0.453889
Kn14anva10 Ln14a10 Lnva10 0.453889
Kn14anva11 Ln14a11 Lnva11 0.453889
Kn14anva12 Ln14a12 Lnva12 0.453889
Kn14anva13 Ln14a13 Lnva13 0.453889
Kn14anva14 Ln14a14 Lnva14 0.453889
Kn14anva15 Ln14a15 Lnva15 0.453889
Kn14anva16 Ln14a16 Lnva16 0.453889
Kn15an16a1 Ln15a1 Ln16a1 0.805155
Kn15an16a2 Ln15a2 Ln16a2 0.805155
Kn15an16a3 Ln15a3 Ln16a3 0.805155
Kn15an16a4 Ln15a4 Ln16a4 0.805155
Kn15an16a5 Ln15a5 Ln16a5 0.805155
Kn15an16a6 Ln15a6 Ln16a6 0.805155
Kn15an16a7 Ln15a7 Ln16a7 0.805155
Kn15an16a8 Ln15a8 Ln16a8 0.805155
Kn15an16a9 Ln15a9 Ln16a9 0.805155
Kn15an16a10 Ln15a10 Ln16a10 0.805155
Kn15an16a11 Ln15a11 Ln16a11 0.805155
Kn15an16a12 Ln15a12 Ln16a12 0.805155
Kn15an16a13 Ln15a13 Ln16a13 0.805155
Kn15an16a14 Ln15a14 Ln16a14 0.805155
Kn15an16a15 Ln15a15 Ln16a15 0.805155
Kn15an16a16 Ln15a16 Ln16a16 0.805155
Kn15an17a1 Ln15a1 Ln17a1 0.723730
Kn15an17a2 Ln15a2 Ln17a2 0.723730
Kn15an17a3 Ln15a3 Ln17a3 0.723730
Kn15an17a4 Ln15a4 Ln17a4 0.723730
Kn15an17a5 Ln15a5 Ln17a5 0.723730
Kn15an17a6 Ln15a6 Ln17a6 0.723730
Kn15an17a7 Ln15a7 Ln17a7 0.723730
Kn15an17a8 Ln15a8 Ln17a8 0.723730
Kn15an17a9 Ln15a9 Ln17a9 0.723730
Kn15an17a10 Ln15a10 Ln17a10 0.723730
Kn15an17a11 Ln15a11 Ln17a11 0.723730
Kn15an17a12 Ln15a12 Ln17a12 0.723730
Kn15an17a13 Ln15a13 Ln17a13 0.723730
Kn15an17a14 Ln15a14 Ln17a14 0.723730
Kn15an17a15 Ln15a15 Ln17a15 0.723730
Kn15an17a16 Ln15a16 Ln17a16 0.723730
Kn15an18a1 Ln15a1 Ln18a1 0.675208
Kn15an18a2 Ln15a2 Ln18a2 0.675208
Kn15an18a3 Ln15a3 Ln18a3 0.675208
Kn15an18a4 Ln15a4 Ln18a4 0.675208
Kn15an18a5 Ln15a5 Ln18a5 0.675208
Kn15an18a6 Ln15a6 Ln18a6 0.675208
Kn15an18a7 Ln15a7 Ln18a7 0.675208
Kn15an18a8 Ln15a8 Ln18a8 0.675208
Kn15an18a9 Ln15a9 Ln18a9 0.675208
Kn15an18a10 Ln15a10 Ln18a10 0.675208
Kn15an18a11 Ln15a11 Ln18a11 0.675208
Kn15an18a12 Ln15a12 Ln18a12 0.675208
Kn15an18a13 Ln15a13 Ln18a13 0.675208
Kn15an18a14 Ln15a14 Ln18a14 0.675208
Kn15an18a15 Ln15a15 Ln18a15 0.675208
Kn15an18a16 Ln15a16 Ln18a16 0.675208
Kn15an19a1 Ln15a1 Ln19a1 0.640637
Kn15an19a2 Ln15a2 Ln19a2 0.640637
Kn15an19a3 Ln15a3 Ln19a3 0.640637
Kn15an19a4 Ln15a4 Ln19a4 0.640637
Kn15an19a5 Ln15a5 Ln19a5 0.640637
Kn15an19a6 Ln15a6 Ln19a6 0.640637
Kn15an19a7 Ln15a7 Ln19a7 0.640637
Kn15an19a8 Ln15a8 Ln19a8 0.640637
Kn15an19a9 Ln15a9 Ln19a9 0.640637
Kn15an19a10 Ln15a10 Ln19a10 0.640637
Kn15an19a11 Ln15a11 Ln19a11 0.640637
Kn15an19a12 Ln15a12 Ln19a12 0.640637
Kn15an19a13 Ln15a13 Ln19a13 0.640637
Kn15an19a14 Ln15a14 Ln19a14 0.640637
Kn15an19a15 Ln15a15 Ln19a15 0.640637
Kn15an19a16 Ln15a16 Ln19a16 0.640637
Kn15an20a1 Ln15a1 Ln20a1 0.613723
Kn15an20a2 Ln15a2 Ln20a2 0.613723
Kn15an20a3 Ln15a3 Ln20a3 0.613723
Kn15an20a4 Ln15a4 Ln20a4 0.613723
Kn15an20a5 Ln15a5 Ln20a5 0.613723
Kn15an20a6 Ln15a6 Ln20a6 0.613723
Kn15an20a7 Ln15a7 Ln20a7 0.613723
Kn15an20a8 Ln15a8 Ln20a8 0.613723
Kn15an20a9 Ln15a9 Ln20a9 0.613723
Kn15an20a10 Ln15a10 Ln20a10 0.613723
Kn15an20a11 Ln15a11 Ln20a11 0.613723
Kn15an20a12 Ln15a12 Ln20a12 0.613723
Kn15an20a13 Ln15a13 Ln20a13 0.613723
Kn15an20a14 Ln15a14 Ln20a14 0.613723
Kn15an20a15 Ln15a15 Ln20a15 0.613723
Kn15an20a16 Ln15a16 Ln20a16 0.613723
Kn15an21a1 Ln15a1 Ln21a1 0.591812
Kn15an21a2 Ln15a2 Ln21a2 0.591812
Kn15an21a3 Ln15a3 Ln21a3 0.591812
Kn15an21a4 Ln15a4 Ln21a4 0.591812
Kn15an21a5 Ln15a5 Ln21a5 0.591812
Kn15an21a6 Ln15a6 Ln21a6 0.591812
Kn15an21a7 Ln15a7 Ln21a7 0.591812
Kn15an21a8 Ln15a8 Ln21a8 0.591812
Kn15an21a9 Ln15a9 Ln21a9 0.591812
Kn15an21a10 Ln15a10 Ln21a10 0.591812
Kn15an21a11 Ln15a11 Ln21a11 0.591812
Kn15an21a12 Ln15a12 Ln21a12 0.591812
Kn15an21a13 Ln15a13 Ln21a13 0.591812
Kn15an21a14 Ln15a14 Ln21a14 0.591812
Kn15an21a15 Ln15a15 Ln21a15 0.591812
Kn15an21a16 Ln15a16 Ln21a16 0.591812
Kn15an22a1 Ln15a1 Ln22a1 0.573237
Kn15an22a2 Ln15a2 Ln22a2 0.573237
Kn15an22a3 Ln15a3 Ln22a3 0.573237
Kn15an22a4 Ln15a4 Ln22a4 0.573237
Kn15an22a5 Ln15a5 Ln22a5 0.573237
Kn15an22a6 Ln15a6 Ln22a6 0.573237
Kn15an22a7 Ln15a7 Ln22a7 0.573237
Kn15an22a8 Ln15a8 Ln22a8 0.573237
Kn15an22a9 Ln15a9 Ln22a9 0.573237
Kn15an22a10 Ln15a10 Ln22a10 0.573237
Kn15an22a11 Ln15a11 Ln22a11 0.573237
Kn15an22a12 Ln15a12 Ln22a12 0.573237
Kn15an22a13 Ln15a13 Ln22a13 0.573237
Kn15an22a14 Ln15a14 Ln22a14 0.573237
Kn15an22a15 Ln15a15 Ln22a15 0.573237
Kn15an22a16 Ln15a16 Ln22a16 0.573237
Kn15an23a1 Ln15a1 Ln23a1 0.557165
Kn15an23a2 Ln15a2 Ln23a2 0.557165
Kn15an23a3 Ln15a3 Ln23a3 0.557165
Kn15an23a4 Ln15a4 Ln23a4 0.557165
Kn15an23a5 Ln15a5 Ln23a5 0.557165
Kn15an23a6 Ln15a6 Ln23a6 0.557165
Kn15an23a7 Ln15a7 Ln23a7 0.557165
Kn15an23a8 Ln15a8 Ln23a8 0.557165
Kn15an23a9 Ln15a9 Ln23a9 0.557165
Kn15an23a10 Ln15a10 Ln23a10 0.557165
Kn15an23a11 Ln15a11 Ln23a11 0.557165
Kn15an23a12 Ln15a12 Ln23a12 0.557165
Kn15an23a13 Ln15a13 Ln23a13 0.557165
Kn15an23a14 Ln15a14 Ln23a14 0.557165
Kn15an23a15 Ln15a15 Ln23a15 0.557165
Kn15an23a16 Ln15a16 Ln23a16 0.557165
Kn15an24a1 Ln15a1 Ln24a1 0.542987
Kn15an24a2 Ln15a2 Ln24a2 0.542987
Kn15an24a3 Ln15a3 Ln24a3 0.542987
Kn15an24a4 Ln15a4 Ln24a4 0.542987
Kn15an24a5 Ln15a5 Ln24a5 0.542987
Kn15an24a6 Ln15a6 Ln24a6 0.542987
Kn15an24a7 Ln15a7 Ln24a7 0.542987
Kn15an24a8 Ln15a8 Ln24a8 0.542987
Kn15an24a9 Ln15a9 Ln24a9 0.542987
Kn15an24a10 Ln15a10 Ln24a10 0.542987
Kn15an24a11 Ln15a11 Ln24a11 0.542987
Kn15an24a12 Ln15a12 Ln24a12 0.542987
Kn15an24a13 Ln15a13 Ln24a13 0.542987
Kn15an24a14 Ln15a14 Ln24a14 0.542987
Kn15an24a15 Ln15a15 Ln24a15 0.542987
Kn15an24a16 Ln15a16 Ln24a16 0.542987
Kn15an25a1 Ln15a1 Ln25a1 0.529400
Kn15an25a2 Ln15a2 Ln25a2 0.529400
Kn15an25a3 Ln15a3 Ln25a3 0.529400
Kn15an25a4 Ln15a4 Ln25a4 0.529400
Kn15an25a5 Ln15a5 Ln25a5 0.529400
Kn15an25a6 Ln15a6 Ln25a6 0.529400
Kn15an25a7 Ln15a7 Ln25a7 0.529400
Kn15an25a8 Ln15a8 Ln25a8 0.529400
Kn15an25a9 Ln15a9 Ln25a9 0.529400
Kn15an25a10 Ln15a10 Ln25a10 0.529400
Kn15an25a11 Ln15a11 Ln25a11 0.529400
Kn15an25a12 Ln15a12 Ln25a12 0.529400
Kn15an25a13 Ln15a13 Ln25a13 0.529400
Kn15an25a14 Ln15a14 Ln25a14 0.529400
Kn15an25a15 Ln15a15 Ln25a15 0.529400
Kn15an25a16 Ln15a16 Ln25a16 0.529400
Kn15an26a1 Ln15a1 Ln26a1 0.516943
Kn15an26a2 Ln15a2 Ln26a2 0.516943
Kn15an26a3 Ln15a3 Ln26a3 0.516943
Kn15an26a4 Ln15a4 Ln26a4 0.516943
Kn15an26a5 Ln15a5 Ln26a5 0.516943
Kn15an26a6 Ln15a6 Ln26a6 0.516943
Kn15an26a7 Ln15a7 Ln26a7 0.516943
Kn15an26a8 Ln15a8 Ln26a8 0.516943
Kn15an26a9 Ln15a9 Ln26a9 0.516943
Kn15an26a10 Ln15a10 Ln26a10 0.516943
Kn15an26a11 Ln15a11 Ln26a11 0.516943
Kn15an26a12 Ln15a12 Ln26a12 0.516943
Kn15an26a13 Ln15a13 Ln26a13 0.516943
Kn15an26a14 Ln15a14 Ln26a14 0.516943
Kn15an26a15 Ln15a15 Ln26a15 0.516943
Kn15an26a16 Ln15a16 Ln26a16 0.516943
Kn15an27a1 Ln15a1 Ln27a1 0.505455
Kn15an27a2 Ln15a2 Ln27a2 0.505455
Kn15an27a3 Ln15a3 Ln27a3 0.505455
Kn15an27a4 Ln15a4 Ln27a4 0.505455
Kn15an27a5 Ln15a5 Ln27a5 0.505455
Kn15an27a6 Ln15a6 Ln27a6 0.505455
Kn15an27a7 Ln15a7 Ln27a7 0.505455
Kn15an27a8 Ln15a8 Ln27a8 0.505455
Kn15an27a9 Ln15a9 Ln27a9 0.505455
Kn15an27a10 Ln15a10 Ln27a10 0.505455
Kn15an27a11 Ln15a11 Ln27a11 0.505455
Kn15an27a12 Ln15a12 Ln27a12 0.505455
Kn15an27a13 Ln15a13 Ln27a13 0.505455
Kn15an27a14 Ln15a14 Ln27a14 0.505455
Kn15an27a15 Ln15a15 Ln27a15 0.505455
Kn15an27a16 Ln15a16 Ln27a16 0.505455
Kn15an28a1 Ln15a1 Ln28a1 0.494887
Kn15an28a2 Ln15a2 Ln28a2 0.494887
Kn15an28a3 Ln15a3 Ln28a3 0.494887
Kn15an28a4 Ln15a4 Ln28a4 0.494887
Kn15an28a5 Ln15a5 Ln28a5 0.494887
Kn15an28a6 Ln15a6 Ln28a6 0.494887
Kn15an28a7 Ln15a7 Ln28a7 0.494887
Kn15an28a8 Ln15a8 Ln28a8 0.494887
Kn15an28a9 Ln15a9 Ln28a9 0.494887
Kn15an28a10 Ln15a10 Ln28a10 0.494887
Kn15an28a11 Ln15a11 Ln28a11 0.494887
Kn15an28a12 Ln15a12 Ln28a12 0.494887
Kn15an28a13 Ln15a13 Ln28a13 0.494887
Kn15an28a14 Ln15a14 Ln28a14 0.494887
Kn15an28a15 Ln15a15 Ln28a15 0.494887
Kn15an28a16 Ln15a16 Ln28a16 0.494887
Kn15an29a1 Ln15a1 Ln29a1 0.485771
Kn15an29a2 Ln15a2 Ln29a2 0.485771
Kn15an29a3 Ln15a3 Ln29a3 0.485771
Kn15an29a4 Ln15a4 Ln29a4 0.485771
Kn15an29a5 Ln15a5 Ln29a5 0.485771
Kn15an29a6 Ln15a6 Ln29a6 0.485771
Kn15an29a7 Ln15a7 Ln29a7 0.485771
Kn15an29a8 Ln15a8 Ln29a8 0.485771
Kn15an29a9 Ln15a9 Ln29a9 0.485771
Kn15an29a10 Ln15a10 Ln29a10 0.485771
Kn15an29a11 Ln15a11 Ln29a11 0.485771
Kn15an29a12 Ln15a12 Ln29a12 0.485771
Kn15an29a13 Ln15a13 Ln29a13 0.485771
Kn15an29a14 Ln15a14 Ln29a14 0.485771
Kn15an29a15 Ln15a15 Ln29a15 0.485771
Kn15an29a16 Ln15a16 Ln29a16 0.485771
Kn15an30a1 Ln15a1 Ln30a1 0.477226
Kn15an30a2 Ln15a2 Ln30a2 0.477226
Kn15an30a3 Ln15a3 Ln30a3 0.477226
Kn15an30a4 Ln15a4 Ln30a4 0.477226
Kn15an30a5 Ln15a5 Ln30a5 0.477226
Kn15an30a6 Ln15a6 Ln30a6 0.477226
Kn15an30a7 Ln15a7 Ln30a7 0.477226
Kn15an30a8 Ln15a8 Ln30a8 0.477226
Kn15an30a9 Ln15a9 Ln30a9 0.477226
Kn15an30a10 Ln15a10 Ln30a10 0.477226
Kn15an30a11 Ln15a11 Ln30a11 0.477226
Kn15an30a12 Ln15a12 Ln30a12 0.477226
Kn15an30a13 Ln15a13 Ln30a13 0.477226
Kn15an30a14 Ln15a14 Ln30a14 0.477226
Kn15an30a15 Ln15a15 Ln30a15 0.477226
Kn15an30a16 Ln15a16 Ln30a16 0.477226
Kn15an31a1 Ln15a1 Ln31a1 0.469680
Kn15an31a2 Ln15a2 Ln31a2 0.469680
Kn15an31a3 Ln15a3 Ln31a3 0.469680
Kn15an31a4 Ln15a4 Ln31a4 0.469680
Kn15an31a5 Ln15a5 Ln31a5 0.469680
Kn15an31a6 Ln15a6 Ln31a6 0.469680
Kn15an31a7 Ln15a7 Ln31a7 0.469680
Kn15an31a8 Ln15a8 Ln31a8 0.469680
Kn15an31a9 Ln15a9 Ln31a9 0.469680
Kn15an31a10 Ln15a10 Ln31a10 0.469680
Kn15an31a11 Ln15a11 Ln31a11 0.469680
Kn15an31a12 Ln15a12 Ln31a12 0.469680
Kn15an31a13 Ln15a13 Ln31a13 0.469680
Kn15an31a14 Ln15a14 Ln31a14 0.469680
Kn15an31a15 Ln15a15 Ln31a15 0.469680
Kn15an31a16 Ln15a16 Ln31a16 0.469680
Kn15an32a1 Ln15a1 Ln32a1 0.463523
Kn15an32a2 Ln15a2 Ln32a2 0.463523
Kn15an32a3 Ln15a3 Ln32a3 0.463523
Kn15an32a4 Ln15a4 Ln32a4 0.463523
Kn15an32a5 Ln15a5 Ln32a5 0.463523
Kn15an32a6 Ln15a6 Ln32a6 0.463523
Kn15an32a7 Ln15a7 Ln32a7 0.463523
Kn15an32a8 Ln15a8 Ln32a8 0.463523
Kn15an32a9 Ln15a9 Ln32a9 0.463523
Kn15an32a10 Ln15a10 Ln32a10 0.463523
Kn15an32a11 Ln15a11 Ln32a11 0.463523
Kn15an32a12 Ln15a12 Ln32a12 0.463523
Kn15an32a13 Ln15a13 Ln32a13 0.463523
Kn15an32a14 Ln15a14 Ln32a14 0.463523
Kn15an32a15 Ln15a15 Ln32a15 0.463523
Kn15an32a16 Ln15a16 Ln32a16 0.463523
Kn15anva1 Ln15a1 Lnva1 0.458074
Kn15anva2 Ln15a2 Lnva2 0.458074
Kn15anva3 Ln15a3 Lnva3 0.458074
Kn15anva4 Ln15a4 Lnva4 0.458074
Kn15anva5 Ln15a5 Lnva5 0.458074
Kn15anva6 Ln15a6 Lnva6 0.458074
Kn15anva7 Ln15a7 Lnva7 0.458074
Kn15anva8 Ln15a8 Lnva8 0.458074
Kn15anva9 Ln15a9 Lnva9 0.458074
Kn15anva10 Ln15a10 Lnva10 0.458074
Kn15anva11 Ln15a11 Lnva11 0.458074
Kn15anva12 Ln15a12 Lnva12 0.458074
Kn15anva13 Ln15a13 Lnva13 0.458074
Kn15anva14 Ln15a14 Lnva14 0.458074
Kn15anva15 Ln15a15 Lnva15 0.458074
Kn15anva16 Ln15a16 Lnva16 0.458074
Kn16an17a1 Ln16a1 Ln17a1 0.805155
Kn16an17a2 Ln16a2 Ln17a2 0.805155
Kn16an17a3 Ln16a3 Ln17a3 0.805155
Kn16an17a4 Ln16a4 Ln17a4 0.805155
Kn16an17a5 Ln16a5 Ln17a5 0.805155
Kn16an17a6 Ln16a6 Ln17a6 0.805155
Kn16an17a7 Ln16a7 Ln17a7 0.805155
Kn16an17a8 Ln16a8 Ln17a8 0.805155
Kn16an17a9 Ln16a9 Ln17a9 0.805155
Kn16an17a10 Ln16a10 Ln17a10 0.805155
Kn16an17a11 Ln16a11 Ln17a11 0.805155
Kn16an17a12 Ln16a12 Ln17a12 0.805155
Kn16an17a13 Ln16a13 Ln17a13 0.805155
Kn16an17a14 Ln16a14 Ln17a14 0.805155
Kn16an17a15 Ln16a15 Ln17a15 0.805155
Kn16an17a16 Ln16a16 Ln17a16 0.805155
Kn16an18a1 Ln16a1 Ln18a1 0.723730
Kn16an18a2 Ln16a2 Ln18a2 0.723730
Kn16an18a3 Ln16a3 Ln18a3 0.723730
Kn16an18a4 Ln16a4 Ln18a4 0.723730
Kn16an18a5 Ln16a5 Ln18a5 0.723730
Kn16an18a6 Ln16a6 Ln18a6 0.723730
Kn16an18a7 Ln16a7 Ln18a7 0.723730
Kn16an18a8 Ln16a8 Ln18a8 0.723730
Kn16an18a9 Ln16a9 Ln18a9 0.723730
Kn16an18a10 Ln16a10 Ln18a10 0.723730
Kn16an18a11 Ln16a11 Ln18a11 0.723730
Kn16an18a12 Ln16a12 Ln18a12 0.723730
Kn16an18a13 Ln16a13 Ln18a13 0.723730
Kn16an18a14 Ln16a14 Ln18a14 0.723730
Kn16an18a15 Ln16a15 Ln18a15 0.723730
Kn16an18a16 Ln16a16 Ln18a16 0.723730
Kn16an19a1 Ln16a1 Ln19a1 0.675208
Kn16an19a2 Ln16a2 Ln19a2 0.675208
Kn16an19a3 Ln16a3 Ln19a3 0.675208
Kn16an19a4 Ln16a4 Ln19a4 0.675208
Kn16an19a5 Ln16a5 Ln19a5 0.675208
Kn16an19a6 Ln16a6 Ln19a6 0.675208
Kn16an19a7 Ln16a7 Ln19a7 0.675208
Kn16an19a8 Ln16a8 Ln19a8 0.675208
Kn16an19a9 Ln16a9 Ln19a9 0.675208
Kn16an19a10 Ln16a10 Ln19a10 0.675208
Kn16an19a11 Ln16a11 Ln19a11 0.675208
Kn16an19a12 Ln16a12 Ln19a12 0.675208
Kn16an19a13 Ln16a13 Ln19a13 0.675208
Kn16an19a14 Ln16a14 Ln19a14 0.675208
Kn16an19a15 Ln16a15 Ln19a15 0.675208
Kn16an19a16 Ln16a16 Ln19a16 0.675208
Kn16an20a1 Ln16a1 Ln20a1 0.640637
Kn16an20a2 Ln16a2 Ln20a2 0.640637
Kn16an20a3 Ln16a3 Ln20a3 0.640637
Kn16an20a4 Ln16a4 Ln20a4 0.640637
Kn16an20a5 Ln16a5 Ln20a5 0.640637
Kn16an20a6 Ln16a6 Ln20a6 0.640637
Kn16an20a7 Ln16a7 Ln20a7 0.640637
Kn16an20a8 Ln16a8 Ln20a8 0.640637
Kn16an20a9 Ln16a9 Ln20a9 0.640637
Kn16an20a10 Ln16a10 Ln20a10 0.640637
Kn16an20a11 Ln16a11 Ln20a11 0.640637
Kn16an20a12 Ln16a12 Ln20a12 0.640637
Kn16an20a13 Ln16a13 Ln20a13 0.640637
Kn16an20a14 Ln16a14 Ln20a14 0.640637
Kn16an20a15 Ln16a15 Ln20a15 0.640637
Kn16an20a16 Ln16a16 Ln20a16 0.640637
Kn16an21a1 Ln16a1 Ln21a1 0.613723
Kn16an21a2 Ln16a2 Ln21a2 0.613723
Kn16an21a3 Ln16a3 Ln21a3 0.613723
Kn16an21a4 Ln16a4 Ln21a4 0.613723
Kn16an21a5 Ln16a5 Ln21a5 0.613723
Kn16an21a6 Ln16a6 Ln21a6 0.613723
Kn16an21a7 Ln16a7 Ln21a7 0.613723
Kn16an21a8 Ln16a8 Ln21a8 0.613723
Kn16an21a9 Ln16a9 Ln21a9 0.613723
Kn16an21a10 Ln16a10 Ln21a10 0.613723
Kn16an21a11 Ln16a11 Ln21a11 0.613723
Kn16an21a12 Ln16a12 Ln21a12 0.613723
Kn16an21a13 Ln16a13 Ln21a13 0.613723
Kn16an21a14 Ln16a14 Ln21a14 0.613723
Kn16an21a15 Ln16a15 Ln21a15 0.613723
Kn16an21a16 Ln16a16 Ln21a16 0.613723
Kn16an22a1 Ln16a1 Ln22a1 0.591812
Kn16an22a2 Ln16a2 Ln22a2 0.591812
Kn16an22a3 Ln16a3 Ln22a3 0.591812
Kn16an22a4 Ln16a4 Ln22a4 0.591812
Kn16an22a5 Ln16a5 Ln22a5 0.591812
Kn16an22a6 Ln16a6 Ln22a6 0.591812
Kn16an22a7 Ln16a7 Ln22a7 0.591812
Kn16an22a8 Ln16a8 Ln22a8 0.591812
Kn16an22a9 Ln16a9 Ln22a9 0.591812
Kn16an22a10 Ln16a10 Ln22a10 0.591812
Kn16an22a11 Ln16a11 Ln22a11 0.591812
Kn16an22a12 Ln16a12 Ln22a12 0.591812
Kn16an22a13 Ln16a13 Ln22a13 0.591812
Kn16an22a14 Ln16a14 Ln22a14 0.591812
Kn16an22a15 Ln16a15 Ln22a15 0.591812
Kn16an22a16 Ln16a16 Ln22a16 0.591812
Kn16an23a1 Ln16a1 Ln23a1 0.573237
Kn16an23a2 Ln16a2 Ln23a2 0.573237
Kn16an23a3 Ln16a3 Ln23a3 0.573237
Kn16an23a4 Ln16a4 Ln23a4 0.573237
Kn16an23a5 Ln16a5 Ln23a5 0.573237
Kn16an23a6 Ln16a6 Ln23a6 0.573237
Kn16an23a7 Ln16a7 Ln23a7 0.573237
Kn16an23a8 Ln16a8 Ln23a8 0.573237
Kn16an23a9 Ln16a9 Ln23a9 0.573237
Kn16an23a10 Ln16a10 Ln23a10 0.573237
Kn16an23a11 Ln16a11 Ln23a11 0.573237
Kn16an23a12 Ln16a12 Ln23a12 0.573237
Kn16an23a13 Ln16a13 Ln23a13 0.573237
Kn16an23a14 Ln16a14 Ln23a14 0.573237
Kn16an23a15 Ln16a15 Ln23a15 0.573237
Kn16an23a16 Ln16a16 Ln23a16 0.573237
Kn16an24a1 Ln16a1 Ln24a1 0.557165
Kn16an24a2 Ln16a2 Ln24a2 0.557165
Kn16an24a3 Ln16a3 Ln24a3 0.557165
Kn16an24a4 Ln16a4 Ln24a4 0.557165
Kn16an24a5 Ln16a5 Ln24a5 0.557165
Kn16an24a6 Ln16a6 Ln24a6 0.557165
Kn16an24a7 Ln16a7 Ln24a7 0.557165
Kn16an24a8 Ln16a8 Ln24a8 0.557165
Kn16an24a9 Ln16a9 Ln24a9 0.557165
Kn16an24a10 Ln16a10 Ln24a10 0.557165
Kn16an24a11 Ln16a11 Ln24a11 0.557165
Kn16an24a12 Ln16a12 Ln24a12 0.557165
Kn16an24a13 Ln16a13 Ln24a13 0.557165
Kn16an24a14 Ln16a14 Ln24a14 0.557165
Kn16an24a15 Ln16a15 Ln24a15 0.557165
Kn16an24a16 Ln16a16 Ln24a16 0.557165
Kn16an25a1 Ln16a1 Ln25a1 0.542987
Kn16an25a2 Ln16a2 Ln25a2 0.542987
Kn16an25a3 Ln16a3 Ln25a3 0.542987
Kn16an25a4 Ln16a4 Ln25a4 0.542987
Kn16an25a5 Ln16a5 Ln25a5 0.542987
Kn16an25a6 Ln16a6 Ln25a6 0.542987
Kn16an25a7 Ln16a7 Ln25a7 0.542987
Kn16an25a8 Ln16a8 Ln25a8 0.542987
Kn16an25a9 Ln16a9 Ln25a9 0.542987
Kn16an25a10 Ln16a10 Ln25a10 0.542987
Kn16an25a11 Ln16a11 Ln25a11 0.542987
Kn16an25a12 Ln16a12 Ln25a12 0.542987
Kn16an25a13 Ln16a13 Ln25a13 0.542987
Kn16an25a14 Ln16a14 Ln25a14 0.542987
Kn16an25a15 Ln16a15 Ln25a15 0.542987
Kn16an25a16 Ln16a16 Ln25a16 0.542987
Kn16an26a1 Ln16a1 Ln26a1 0.529400
Kn16an26a2 Ln16a2 Ln26a2 0.529400
Kn16an26a3 Ln16a3 Ln26a3 0.529400
Kn16an26a4 Ln16a4 Ln26a4 0.529400
Kn16an26a5 Ln16a5 Ln26a5 0.529400
Kn16an26a6 Ln16a6 Ln26a6 0.529400
Kn16an26a7 Ln16a7 Ln26a7 0.529400
Kn16an26a8 Ln16a8 Ln26a8 0.529400
Kn16an26a9 Ln16a9 Ln26a9 0.529400
Kn16an26a10 Ln16a10 Ln26a10 0.529400
Kn16an26a11 Ln16a11 Ln26a11 0.529400
Kn16an26a12 Ln16a12 Ln26a12 0.529400
Kn16an26a13 Ln16a13 Ln26a13 0.529400
Kn16an26a14 Ln16a14 Ln26a14 0.529400
Kn16an26a15 Ln16a15 Ln26a15 0.529400
Kn16an26a16 Ln16a16 Ln26a16 0.529400
Kn16an27a1 Ln16a1 Ln27a1 0.516943
Kn16an27a2 Ln16a2 Ln27a2 0.516943
Kn16an27a3 Ln16a3 Ln27a3 0.516943
Kn16an27a4 Ln16a4 Ln27a4 0.516943
Kn16an27a5 Ln16a5 Ln27a5 0.516943
Kn16an27a6 Ln16a6 Ln27a6 0.516943
Kn16an27a7 Ln16a7 Ln27a7 0.516943
Kn16an27a8 Ln16a8 Ln27a8 0.516943
Kn16an27a9 Ln16a9 Ln27a9 0.516943
Kn16an27a10 Ln16a10 Ln27a10 0.516943
Kn16an27a11 Ln16a11 Ln27a11 0.516943
Kn16an27a12 Ln16a12 Ln27a12 0.516943
Kn16an27a13 Ln16a13 Ln27a13 0.516943
Kn16an27a14 Ln16a14 Ln27a14 0.516943
Kn16an27a15 Ln16a15 Ln27a15 0.516943
Kn16an27a16 Ln16a16 Ln27a16 0.516943
Kn16an28a1 Ln16a1 Ln28a1 0.505455
Kn16an28a2 Ln16a2 Ln28a2 0.505455
Kn16an28a3 Ln16a3 Ln28a3 0.505455
Kn16an28a4 Ln16a4 Ln28a4 0.505455
Kn16an28a5 Ln16a5 Ln28a5 0.505455
Kn16an28a6 Ln16a6 Ln28a6 0.505455
Kn16an28a7 Ln16a7 Ln28a7 0.505455
Kn16an28a8 Ln16a8 Ln28a8 0.505455
Kn16an28a9 Ln16a9 Ln28a9 0.505455
Kn16an28a10 Ln16a10 Ln28a10 0.505455
Kn16an28a11 Ln16a11 Ln28a11 0.505455
Kn16an28a12 Ln16a12 Ln28a12 0.505455
Kn16an28a13 Ln16a13 Ln28a13 0.505455
Kn16an28a14 Ln16a14 Ln28a14 0.505455
Kn16an28a15 Ln16a15 Ln28a15 0.505455
Kn16an28a16 Ln16a16 Ln28a16 0.505455
Kn16an29a1 Ln16a1 Ln29a1 0.494887
Kn16an29a2 Ln16a2 Ln29a2 0.494887
Kn16an29a3 Ln16a3 Ln29a3 0.494887
Kn16an29a4 Ln16a4 Ln29a4 0.494887
Kn16an29a5 Ln16a5 Ln29a5 0.494887
Kn16an29a6 Ln16a6 Ln29a6 0.494887
Kn16an29a7 Ln16a7 Ln29a7 0.494887
Kn16an29a8 Ln16a8 Ln29a8 0.494887
Kn16an29a9 Ln16a9 Ln29a9 0.494887
Kn16an29a10 Ln16a10 Ln29a10 0.494887
Kn16an29a11 Ln16a11 Ln29a11 0.494887
Kn16an29a12 Ln16a12 Ln29a12 0.494887
Kn16an29a13 Ln16a13 Ln29a13 0.494887
Kn16an29a14 Ln16a14 Ln29a14 0.494887
Kn16an29a15 Ln16a15 Ln29a15 0.494887
Kn16an29a16 Ln16a16 Ln29a16 0.494887
Kn16an30a1 Ln16a1 Ln30a1 0.485771
Kn16an30a2 Ln16a2 Ln30a2 0.485771
Kn16an30a3 Ln16a3 Ln30a3 0.485771
Kn16an30a4 Ln16a4 Ln30a4 0.485771
Kn16an30a5 Ln16a5 Ln30a5 0.485771
Kn16an30a6 Ln16a6 Ln30a6 0.485771
Kn16an30a7 Ln16a7 Ln30a7 0.485771
Kn16an30a8 Ln16a8 Ln30a8 0.485771
Kn16an30a9 Ln16a9 Ln30a9 0.485771
Kn16an30a10 Ln16a10 Ln30a10 0.485771
Kn16an30a11 Ln16a11 Ln30a11 0.485771
Kn16an30a12 Ln16a12 Ln30a12 0.485771
Kn16an30a13 Ln16a13 Ln30a13 0.485771
Kn16an30a14 Ln16a14 Ln30a14 0.485771
Kn16an30a15 Ln16a15 Ln30a15 0.485771
Kn16an30a16 Ln16a16 Ln30a16 0.485771
Kn16an31a1 Ln16a1 Ln31a1 0.477226
Kn16an31a2 Ln16a2 Ln31a2 0.477226
Kn16an31a3 Ln16a3 Ln31a3 0.477226
Kn16an31a4 Ln16a4 Ln31a4 0.477226
Kn16an31a5 Ln16a5 Ln31a5 0.477226
Kn16an31a6 Ln16a6 Ln31a6 0.477226
Kn16an31a7 Ln16a7 Ln31a7 0.477226
Kn16an31a8 Ln16a8 Ln31a8 0.477226
Kn16an31a9 Ln16a9 Ln31a9 0.477226
Kn16an31a10 Ln16a10 Ln31a10 0.477226
Kn16an31a11 Ln16a11 Ln31a11 0.477226
Kn16an31a12 Ln16a12 Ln31a12 0.477226
Kn16an31a13 Ln16a13 Ln31a13 0.477226
Kn16an31a14 Ln16a14 Ln31a14 0.477226
Kn16an31a15 Ln16a15 Ln31a15 0.477226
Kn16an31a16 Ln16a16 Ln31a16 0.477226
Kn16an32a1 Ln16a1 Ln32a1 0.469680
Kn16an32a2 Ln16a2 Ln32a2 0.469680
Kn16an32a3 Ln16a3 Ln32a3 0.469680
Kn16an32a4 Ln16a4 Ln32a4 0.469680
Kn16an32a5 Ln16a5 Ln32a5 0.469680
Kn16an32a6 Ln16a6 Ln32a6 0.469680
Kn16an32a7 Ln16a7 Ln32a7 0.469680
Kn16an32a8 Ln16a8 Ln32a8 0.469680
Kn16an32a9 Ln16a9 Ln32a9 0.469680
Kn16an32a10 Ln16a10 Ln32a10 0.469680
Kn16an32a11 Ln16a11 Ln32a11 0.469680
Kn16an32a12 Ln16a12 Ln32a12 0.469680
Kn16an32a13 Ln16a13 Ln32a13 0.469680
Kn16an32a14 Ln16a14 Ln32a14 0.469680
Kn16an32a15 Ln16a15 Ln32a15 0.469680
Kn16an32a16 Ln16a16 Ln32a16 0.469680
Kn16anva1 Ln16a1 Lnva1 0.463523
Kn16anva2 Ln16a2 Lnva2 0.463523
Kn16anva3 Ln16a3 Lnva3 0.463523
Kn16anva4 Ln16a4 Lnva4 0.463523
Kn16anva5 Ln16a5 Lnva5 0.463523
Kn16anva6 Ln16a6 Lnva6 0.463523
Kn16anva7 Ln16a7 Lnva7 0.463523
Kn16anva8 Ln16a8 Lnva8 0.463523
Kn16anva9 Ln16a9 Lnva9 0.463523
Kn16anva10 Ln16a10 Lnva10 0.463523
Kn16anva11 Ln16a11 Lnva11 0.463523
Kn16anva12 Ln16a12 Lnva12 0.463523
Kn16anva13 Ln16a13 Lnva13 0.463523
Kn16anva14 Ln16a14 Lnva14 0.463523
Kn16anva15 Ln16a15 Lnva15 0.463523
Kn16anva16 Ln16a16 Lnva16 0.463523
Kn17an18a1 Ln17a1 Ln18a1 0.805155
Kn17an18a2 Ln17a2 Ln18a2 0.805155
Kn17an18a3 Ln17a3 Ln18a3 0.805155
Kn17an18a4 Ln17a4 Ln18a4 0.805155
Kn17an18a5 Ln17a5 Ln18a5 0.805155
Kn17an18a6 Ln17a6 Ln18a6 0.805155
Kn17an18a7 Ln17a7 Ln18a7 0.805155
Kn17an18a8 Ln17a8 Ln18a8 0.805155
Kn17an18a9 Ln17a9 Ln18a9 0.805155
Kn17an18a10 Ln17a10 Ln18a10 0.805155
Kn17an18a11 Ln17a11 Ln18a11 0.805155
Kn17an18a12 Ln17a12 Ln18a12 0.805155
Kn17an18a13 Ln17a13 Ln18a13 0.805155
Kn17an18a14 Ln17a14 Ln18a14 0.805155
Kn17an18a15 Ln17a15 Ln18a15 0.805155
Kn17an18a16 Ln17a16 Ln18a16 0.805155
Kn17an19a1 Ln17a1 Ln19a1 0.723730
Kn17an19a2 Ln17a2 Ln19a2 0.723730
Kn17an19a3 Ln17a3 Ln19a3 0.723730
Kn17an19a4 Ln17a4 Ln19a4 0.723730
Kn17an19a5 Ln17a5 Ln19a5 0.723730
Kn17an19a6 Ln17a6 Ln19a6 0.723730
Kn17an19a7 Ln17a7 Ln19a7 0.723730
Kn17an19a8 Ln17a8 Ln19a8 0.723730
Kn17an19a9 Ln17a9 Ln19a9 0.723730
Kn17an19a10 Ln17a10 Ln19a10 0.723730
Kn17an19a11 Ln17a11 Ln19a11 0.723730
Kn17an19a12 Ln17a12 Ln19a12 0.723730
Kn17an19a13 Ln17a13 Ln19a13 0.723730
Kn17an19a14 Ln17a14 Ln19a14 0.723730
Kn17an19a15 Ln17a15 Ln19a15 0.723730
Kn17an19a16 Ln17a16 Ln19a16 0.723730
Kn17an20a1 Ln17a1 Ln20a1 0.675208
Kn17an20a2 Ln17a2 Ln20a2 0.675208
Kn17an20a3 Ln17a3 Ln20a3 0.675208
Kn17an20a4 Ln17a4 Ln20a4 0.675208
Kn17an20a5 Ln17a5 Ln20a5 0.675208
Kn17an20a6 Ln17a6 Ln20a6 0.675208
Kn17an20a7 Ln17a7 Ln20a7 0.675208
Kn17an20a8 Ln17a8 Ln20a8 0.675208
Kn17an20a9 Ln17a9 Ln20a9 0.675208
Kn17an20a10 Ln17a10 Ln20a10 0.675208
Kn17an20a11 Ln17a11 Ln20a11 0.675208
Kn17an20a12 Ln17a12 Ln20a12 0.675208
Kn17an20a13 Ln17a13 Ln20a13 0.675208
Kn17an20a14 Ln17a14 Ln20a14 0.675208
Kn17an20a15 Ln17a15 Ln20a15 0.675208
Kn17an20a16 Ln17a16 Ln20a16 0.675208
Kn17an21a1 Ln17a1 Ln21a1 0.640637
Kn17an21a2 Ln17a2 Ln21a2 0.640637
Kn17an21a3 Ln17a3 Ln21a3 0.640637
Kn17an21a4 Ln17a4 Ln21a4 0.640637
Kn17an21a5 Ln17a5 Ln21a5 0.640637
Kn17an21a6 Ln17a6 Ln21a6 0.640637
Kn17an21a7 Ln17a7 Ln21a7 0.640637
Kn17an21a8 Ln17a8 Ln21a8 0.640637
Kn17an21a9 Ln17a9 Ln21a9 0.640637
Kn17an21a10 Ln17a10 Ln21a10 0.640637
Kn17an21a11 Ln17a11 Ln21a11 0.640637
Kn17an21a12 Ln17a12 Ln21a12 0.640637
Kn17an21a13 Ln17a13 Ln21a13 0.640637
Kn17an21a14 Ln17a14 Ln21a14 0.640637
Kn17an21a15 Ln17a15 Ln21a15 0.640637
Kn17an21a16 Ln17a16 Ln21a16 0.640637
Kn17an22a1 Ln17a1 Ln22a1 0.613723
Kn17an22a2 Ln17a2 Ln22a2 0.613723
Kn17an22a3 Ln17a3 Ln22a3 0.613723
Kn17an22a4 Ln17a4 Ln22a4 0.613723
Kn17an22a5 Ln17a5 Ln22a5 0.613723
Kn17an22a6 Ln17a6 Ln22a6 0.613723
Kn17an22a7 Ln17a7 Ln22a7 0.613723
Kn17an22a8 Ln17a8 Ln22a8 0.613723
Kn17an22a9 Ln17a9 Ln22a9 0.613723
Kn17an22a10 Ln17a10 Ln22a10 0.613723
Kn17an22a11 Ln17a11 Ln22a11 0.613723
Kn17an22a12 Ln17a12 Ln22a12 0.613723
Kn17an22a13 Ln17a13 Ln22a13 0.613723
Kn17an22a14 Ln17a14 Ln22a14 0.613723
Kn17an22a15 Ln17a15 Ln22a15 0.613723
Kn17an22a16 Ln17a16 Ln22a16 0.613723
Kn17an23a1 Ln17a1 Ln23a1 0.591812
Kn17an23a2 Ln17a2 Ln23a2 0.591812
Kn17an23a3 Ln17a3 Ln23a3 0.591812
Kn17an23a4 Ln17a4 Ln23a4 0.591812
Kn17an23a5 Ln17a5 Ln23a5 0.591812
Kn17an23a6 Ln17a6 Ln23a6 0.591812
Kn17an23a7 Ln17a7 Ln23a7 0.591812
Kn17an23a8 Ln17a8 Ln23a8 0.591812
Kn17an23a9 Ln17a9 Ln23a9 0.591812
Kn17an23a10 Ln17a10 Ln23a10 0.591812
Kn17an23a11 Ln17a11 Ln23a11 0.591812
Kn17an23a12 Ln17a12 Ln23a12 0.591812
Kn17an23a13 Ln17a13 Ln23a13 0.591812
Kn17an23a14 Ln17a14 Ln23a14 0.591812
Kn17an23a15 Ln17a15 Ln23a15 0.591812
Kn17an23a16 Ln17a16 Ln23a16 0.591812
Kn17an24a1 Ln17a1 Ln24a1 0.573237
Kn17an24a2 Ln17a2 Ln24a2 0.573237
Kn17an24a3 Ln17a3 Ln24a3 0.573237
Kn17an24a4 Ln17a4 Ln24a4 0.573237
Kn17an24a5 Ln17a5 Ln24a5 0.573237
Kn17an24a6 Ln17a6 Ln24a6 0.573237
Kn17an24a7 Ln17a7 Ln24a7 0.573237
Kn17an24a8 Ln17a8 Ln24a8 0.573237
Kn17an24a9 Ln17a9 Ln24a9 0.573237
Kn17an24a10 Ln17a10 Ln24a10 0.573237
Kn17an24a11 Ln17a11 Ln24a11 0.573237
Kn17an24a12 Ln17a12 Ln24a12 0.573237
Kn17an24a13 Ln17a13 Ln24a13 0.573237
Kn17an24a14 Ln17a14 Ln24a14 0.573237
Kn17an24a15 Ln17a15 Ln24a15 0.573237
Kn17an24a16 Ln17a16 Ln24a16 0.573237
Kn17an25a1 Ln17a1 Ln25a1 0.557165
Kn17an25a2 Ln17a2 Ln25a2 0.557165
Kn17an25a3 Ln17a3 Ln25a3 0.557165
Kn17an25a4 Ln17a4 Ln25a4 0.557165
Kn17an25a5 Ln17a5 Ln25a5 0.557165
Kn17an25a6 Ln17a6 Ln25a6 0.557165
Kn17an25a7 Ln17a7 Ln25a7 0.557165
Kn17an25a8 Ln17a8 Ln25a8 0.557165
Kn17an25a9 Ln17a9 Ln25a9 0.557165
Kn17an25a10 Ln17a10 Ln25a10 0.557165
Kn17an25a11 Ln17a11 Ln25a11 0.557165
Kn17an25a12 Ln17a12 Ln25a12 0.557165
Kn17an25a13 Ln17a13 Ln25a13 0.557165
Kn17an25a14 Ln17a14 Ln25a14 0.557165
Kn17an25a15 Ln17a15 Ln25a15 0.557165
Kn17an25a16 Ln17a16 Ln25a16 0.557165
Kn17an26a1 Ln17a1 Ln26a1 0.542987
Kn17an26a2 Ln17a2 Ln26a2 0.542987
Kn17an26a3 Ln17a3 Ln26a3 0.542987
Kn17an26a4 Ln17a4 Ln26a4 0.542987
Kn17an26a5 Ln17a5 Ln26a5 0.542987
Kn17an26a6 Ln17a6 Ln26a6 0.542987
Kn17an26a7 Ln17a7 Ln26a7 0.542987
Kn17an26a8 Ln17a8 Ln26a8 0.542987
Kn17an26a9 Ln17a9 Ln26a9 0.542987
Kn17an26a10 Ln17a10 Ln26a10 0.542987
Kn17an26a11 Ln17a11 Ln26a11 0.542987
Kn17an26a12 Ln17a12 Ln26a12 0.542987
Kn17an26a13 Ln17a13 Ln26a13 0.542987
Kn17an26a14 Ln17a14 Ln26a14 0.542987
Kn17an26a15 Ln17a15 Ln26a15 0.542987
Kn17an26a16 Ln17a16 Ln26a16 0.542987
Kn17an27a1 Ln17a1 Ln27a1 0.529400
Kn17an27a2 Ln17a2 Ln27a2 0.529400
Kn17an27a3 Ln17a3 Ln27a3 0.529400
Kn17an27a4 Ln17a4 Ln27a4 0.529400
Kn17an27a5 Ln17a5 Ln27a5 0.529400
Kn17an27a6 Ln17a6 Ln27a6 0.529400
Kn17an27a7 Ln17a7 Ln27a7 0.529400
Kn17an27a8 Ln17a8 Ln27a8 0.529400
Kn17an27a9 Ln17a9 Ln27a9 0.529400
Kn17an27a10 Ln17a10 Ln27a10 0.529400
Kn17an27a11 Ln17a11 Ln27a11 0.529400
Kn17an27a12 Ln17a12 Ln27a12 0.529400
Kn17an27a13 Ln17a13 Ln27a13 0.529400
Kn17an27a14 Ln17a14 Ln27a14 0.529400
Kn17an27a15 Ln17a15 Ln27a15 0.529400
Kn17an27a16 Ln17a16 Ln27a16 0.529400
Kn17an28a1 Ln17a1 Ln28a1 0.516943
Kn17an28a2 Ln17a2 Ln28a2 0.516943
Kn17an28a3 Ln17a3 Ln28a3 0.516943
Kn17an28a4 Ln17a4 Ln28a4 0.516943
Kn17an28a5 Ln17a5 Ln28a5 0.516943
Kn17an28a6 Ln17a6 Ln28a6 0.516943
Kn17an28a7 Ln17a7 Ln28a7 0.516943
Kn17an28a8 Ln17a8 Ln28a8 0.516943
Kn17an28a9 Ln17a9 Ln28a9 0.516943
Kn17an28a10 Ln17a10 Ln28a10 0.516943
Kn17an28a11 Ln17a11 Ln28a11 0.516943
Kn17an28a12 Ln17a12 Ln28a12 0.516943
Kn17an28a13 Ln17a13 Ln28a13 0.516943
Kn17an28a14 Ln17a14 Ln28a14 0.516943
Kn17an28a15 Ln17a15 Ln28a15 0.516943
Kn17an28a16 Ln17a16 Ln28a16 0.516943
Kn17an29a1 Ln17a1 Ln29a1 0.505455
Kn17an29a2 Ln17a2 Ln29a2 0.505455
Kn17an29a3 Ln17a3 Ln29a3 0.505455
Kn17an29a4 Ln17a4 Ln29a4 0.505455
Kn17an29a5 Ln17a5 Ln29a5 0.505455
Kn17an29a6 Ln17a6 Ln29a6 0.505455
Kn17an29a7 Ln17a7 Ln29a7 0.505455
Kn17an29a8 Ln17a8 Ln29a8 0.505455
Kn17an29a9 Ln17a9 Ln29a9 0.505455
Kn17an29a10 Ln17a10 Ln29a10 0.505455
Kn17an29a11 Ln17a11 Ln29a11 0.505455
Kn17an29a12 Ln17a12 Ln29a12 0.505455
Kn17an29a13 Ln17a13 Ln29a13 0.505455
Kn17an29a14 Ln17a14 Ln29a14 0.505455
Kn17an29a15 Ln17a15 Ln29a15 0.505455
Kn17an29a16 Ln17a16 Ln29a16 0.505455
Kn17an30a1 Ln17a1 Ln30a1 0.494887
Kn17an30a2 Ln17a2 Ln30a2 0.494887
Kn17an30a3 Ln17a3 Ln30a3 0.494887
Kn17an30a4 Ln17a4 Ln30a4 0.494887
Kn17an30a5 Ln17a5 Ln30a5 0.494887
Kn17an30a6 Ln17a6 Ln30a6 0.494887
Kn17an30a7 Ln17a7 Ln30a7 0.494887
Kn17an30a8 Ln17a8 Ln30a8 0.494887
Kn17an30a9 Ln17a9 Ln30a9 0.494887
Kn17an30a10 Ln17a10 Ln30a10 0.494887
Kn17an30a11 Ln17a11 Ln30a11 0.494887
Kn17an30a12 Ln17a12 Ln30a12 0.494887
Kn17an30a13 Ln17a13 Ln30a13 0.494887
Kn17an30a14 Ln17a14 Ln30a14 0.494887
Kn17an30a15 Ln17a15 Ln30a15 0.494887
Kn17an30a16 Ln17a16 Ln30a16 0.494887
Kn17an31a1 Ln17a1 Ln31a1 0.485771
Kn17an31a2 Ln17a2 Ln31a2 0.485771
Kn17an31a3 Ln17a3 Ln31a3 0.485771
Kn17an31a4 Ln17a4 Ln31a4 0.485771
Kn17an31a5 Ln17a5 Ln31a5 0.485771
Kn17an31a6 Ln17a6 Ln31a6 0.485771
Kn17an31a7 Ln17a7 Ln31a7 0.485771
Kn17an31a8 Ln17a8 Ln31a8 0.485771
Kn17an31a9 Ln17a9 Ln31a9 0.485771
Kn17an31a10 Ln17a10 Ln31a10 0.485771
Kn17an31a11 Ln17a11 Ln31a11 0.485771
Kn17an31a12 Ln17a12 Ln31a12 0.485771
Kn17an31a13 Ln17a13 Ln31a13 0.485771
Kn17an31a14 Ln17a14 Ln31a14 0.485771
Kn17an31a15 Ln17a15 Ln31a15 0.485771
Kn17an31a16 Ln17a16 Ln31a16 0.485771
Kn17an32a1 Ln17a1 Ln32a1 0.477226
Kn17an32a2 Ln17a2 Ln32a2 0.477226
Kn17an32a3 Ln17a3 Ln32a3 0.477226
Kn17an32a4 Ln17a4 Ln32a4 0.477226
Kn17an32a5 Ln17a5 Ln32a5 0.477226
Kn17an32a6 Ln17a6 Ln32a6 0.477226
Kn17an32a7 Ln17a7 Ln32a7 0.477226
Kn17an32a8 Ln17a8 Ln32a8 0.477226
Kn17an32a9 Ln17a9 Ln32a9 0.477226
Kn17an32a10 Ln17a10 Ln32a10 0.477226
Kn17an32a11 Ln17a11 Ln32a11 0.477226
Kn17an32a12 Ln17a12 Ln32a12 0.477226
Kn17an32a13 Ln17a13 Ln32a13 0.477226
Kn17an32a14 Ln17a14 Ln32a14 0.477226
Kn17an32a15 Ln17a15 Ln32a15 0.477226
Kn17an32a16 Ln17a16 Ln32a16 0.477226
Kn17anva1 Ln17a1 Lnva1 0.469680
Kn17anva2 Ln17a2 Lnva2 0.469680
Kn17anva3 Ln17a3 Lnva3 0.469680
Kn17anva4 Ln17a4 Lnva4 0.469680
Kn17anva5 Ln17a5 Lnva5 0.469680
Kn17anva6 Ln17a6 Lnva6 0.469680
Kn17anva7 Ln17a7 Lnva7 0.469680
Kn17anva8 Ln17a8 Lnva8 0.469680
Kn17anva9 Ln17a9 Lnva9 0.469680
Kn17anva10 Ln17a10 Lnva10 0.469680
Kn17anva11 Ln17a11 Lnva11 0.469680
Kn17anva12 Ln17a12 Lnva12 0.469680
Kn17anva13 Ln17a13 Lnva13 0.469680
Kn17anva14 Ln17a14 Lnva14 0.469680
Kn17anva15 Ln17a15 Lnva15 0.469680
Kn17anva16 Ln17a16 Lnva16 0.469680
Kn18an19a1 Ln18a1 Ln19a1 0.805155
Kn18an19a2 Ln18a2 Ln19a2 0.805155
Kn18an19a3 Ln18a3 Ln19a3 0.805155
Kn18an19a4 Ln18a4 Ln19a4 0.805155
Kn18an19a5 Ln18a5 Ln19a5 0.805155
Kn18an19a6 Ln18a6 Ln19a6 0.805155
Kn18an19a7 Ln18a7 Ln19a7 0.805155
Kn18an19a8 Ln18a8 Ln19a8 0.805155
Kn18an19a9 Ln18a9 Ln19a9 0.805155
Kn18an19a10 Ln18a10 Ln19a10 0.805155
Kn18an19a11 Ln18a11 Ln19a11 0.805155
Kn18an19a12 Ln18a12 Ln19a12 0.805155
Kn18an19a13 Ln18a13 Ln19a13 0.805155
Kn18an19a14 Ln18a14 Ln19a14 0.805155
Kn18an19a15 Ln18a15 Ln19a15 0.805155
Kn18an19a16 Ln18a16 Ln19a16 0.805155
Kn18an20a1 Ln18a1 Ln20a1 0.723730
Kn18an20a2 Ln18a2 Ln20a2 0.723730
Kn18an20a3 Ln18a3 Ln20a3 0.723730
Kn18an20a4 Ln18a4 Ln20a4 0.723730
Kn18an20a5 Ln18a5 Ln20a5 0.723730
Kn18an20a6 Ln18a6 Ln20a6 0.723730
Kn18an20a7 Ln18a7 Ln20a7 0.723730
Kn18an20a8 Ln18a8 Ln20a8 0.723730
Kn18an20a9 Ln18a9 Ln20a9 0.723730
Kn18an20a10 Ln18a10 Ln20a10 0.723730
Kn18an20a11 Ln18a11 Ln20a11 0.723730
Kn18an20a12 Ln18a12 Ln20a12 0.723730
Kn18an20a13 Ln18a13 Ln20a13 0.723730
Kn18an20a14 Ln18a14 Ln20a14 0.723730
Kn18an20a15 Ln18a15 Ln20a15 0.723730
Kn18an20a16 Ln18a16 Ln20a16 0.723730
Kn18an21a1 Ln18a1 Ln21a1 0.675208
Kn18an21a2 Ln18a2 Ln21a2 0.675208
Kn18an21a3 Ln18a3 Ln21a3 0.675208
Kn18an21a4 Ln18a4 Ln21a4 0.675208
Kn18an21a5 Ln18a5 Ln21a5 0.675208
Kn18an21a6 Ln18a6 Ln21a6 0.675208
Kn18an21a7 Ln18a7 Ln21a7 0.675208
Kn18an21a8 Ln18a8 Ln21a8 0.675208
Kn18an21a9 Ln18a9 Ln21a9 0.675208
Kn18an21a10 Ln18a10 Ln21a10 0.675208
Kn18an21a11 Ln18a11 Ln21a11 0.675208
Kn18an21a12 Ln18a12 Ln21a12 0.675208
Kn18an21a13 Ln18a13 Ln21a13 0.675208
Kn18an21a14 Ln18a14 Ln21a14 0.675208
Kn18an21a15 Ln18a15 Ln21a15 0.675208
Kn18an21a16 Ln18a16 Ln21a16 0.675208
Kn18an22a1 Ln18a1 Ln22a1 0.640637
Kn18an22a2 Ln18a2 Ln22a2 0.640637
Kn18an22a3 Ln18a3 Ln22a3 0.640637
Kn18an22a4 Ln18a4 Ln22a4 0.640637
Kn18an22a5 Ln18a5 Ln22a5 0.640637
Kn18an22a6 Ln18a6 Ln22a6 0.640637
Kn18an22a7 Ln18a7 Ln22a7 0.640637
Kn18an22a8 Ln18a8 Ln22a8 0.640637
Kn18an22a9 Ln18a9 Ln22a9 0.640637
Kn18an22a10 Ln18a10 Ln22a10 0.640637
Kn18an22a11 Ln18a11 Ln22a11 0.640637
Kn18an22a12 Ln18a12 Ln22a12 0.640637
Kn18an22a13 Ln18a13 Ln22a13 0.640637
Kn18an22a14 Ln18a14 Ln22a14 0.640637
Kn18an22a15 Ln18a15 Ln22a15 0.640637
Kn18an22a16 Ln18a16 Ln22a16 0.640637
Kn18an23a1 Ln18a1 Ln23a1 0.613723
Kn18an23a2 Ln18a2 Ln23a2 0.613723
Kn18an23a3 Ln18a3 Ln23a3 0.613723
Kn18an23a4 Ln18a4 Ln23a4 0.613723
Kn18an23a5 Ln18a5 Ln23a5 0.613723
Kn18an23a6 Ln18a6 Ln23a6 0.613723
Kn18an23a7 Ln18a7 Ln23a7 0.613723
Kn18an23a8 Ln18a8 Ln23a8 0.613723
Kn18an23a9 Ln18a9 Ln23a9 0.613723
Kn18an23a10 Ln18a10 Ln23a10 0.613723
Kn18an23a11 Ln18a11 Ln23a11 0.613723
Kn18an23a12 Ln18a12 Ln23a12 0.613723
Kn18an23a13 Ln18a13 Ln23a13 0.613723
Kn18an23a14 Ln18a14 Ln23a14 0.613723
Kn18an23a15 Ln18a15 Ln23a15 0.613723
Kn18an23a16 Ln18a16 Ln23a16 0.613723
Kn18an24a1 Ln18a1 Ln24a1 0.591812
Kn18an24a2 Ln18a2 Ln24a2 0.591812
Kn18an24a3 Ln18a3 Ln24a3 0.591812
Kn18an24a4 Ln18a4 Ln24a4 0.591812
Kn18an24a5 Ln18a5 Ln24a5 0.591812
Kn18an24a6 Ln18a6 Ln24a6 0.591812
Kn18an24a7 Ln18a7 Ln24a7 0.591812
Kn18an24a8 Ln18a8 Ln24a8 0.591812
Kn18an24a9 Ln18a9 Ln24a9 0.591812
Kn18an24a10 Ln18a10 Ln24a10 0.591812
Kn18an24a11 Ln18a11 Ln24a11 0.591812
Kn18an24a12 Ln18a12 Ln24a12 0.591812
Kn18an24a13 Ln18a13 Ln24a13 0.591812
Kn18an24a14 Ln18a14 Ln24a14 0.591812
Kn18an24a15 Ln18a15 Ln24a15 0.591812
Kn18an24a16 Ln18a16 Ln24a16 0.591812
Kn18an25a1 Ln18a1 Ln25a1 0.573237
Kn18an25a2 Ln18a2 Ln25a2 0.573237
Kn18an25a3 Ln18a3 Ln25a3 0.573237
Kn18an25a4 Ln18a4 Ln25a4 0.573237
Kn18an25a5 Ln18a5 Ln25a5 0.573237
Kn18an25a6 Ln18a6 Ln25a6 0.573237
Kn18an25a7 Ln18a7 Ln25a7 0.573237
Kn18an25a8 Ln18a8 Ln25a8 0.573237
Kn18an25a9 Ln18a9 Ln25a9 0.573237
Kn18an25a10 Ln18a10 Ln25a10 0.573237
Kn18an25a11 Ln18a11 Ln25a11 0.573237
Kn18an25a12 Ln18a12 Ln25a12 0.573237
Kn18an25a13 Ln18a13 Ln25a13 0.573237
Kn18an25a14 Ln18a14 Ln25a14 0.573237
Kn18an25a15 Ln18a15 Ln25a15 0.573237
Kn18an25a16 Ln18a16 Ln25a16 0.573237
Kn18an26a1 Ln18a1 Ln26a1 0.557165
Kn18an26a2 Ln18a2 Ln26a2 0.557165
Kn18an26a3 Ln18a3 Ln26a3 0.557165
Kn18an26a4 Ln18a4 Ln26a4 0.557165
Kn18an26a5 Ln18a5 Ln26a5 0.557165
Kn18an26a6 Ln18a6 Ln26a6 0.557165
Kn18an26a7 Ln18a7 Ln26a7 0.557165
Kn18an26a8 Ln18a8 Ln26a8 0.557165
Kn18an26a9 Ln18a9 Ln26a9 0.557165
Kn18an26a10 Ln18a10 Ln26a10 0.557165
Kn18an26a11 Ln18a11 Ln26a11 0.557165
Kn18an26a12 Ln18a12 Ln26a12 0.557165
Kn18an26a13 Ln18a13 Ln26a13 0.557165
Kn18an26a14 Ln18a14 Ln26a14 0.557165
Kn18an26a15 Ln18a15 Ln26a15 0.557165
Kn18an26a16 Ln18a16 Ln26a16 0.557165
Kn18an27a1 Ln18a1 Ln27a1 0.542987
Kn18an27a2 Ln18a2 Ln27a2 0.542987
Kn18an27a3 Ln18a3 Ln27a3 0.542987
Kn18an27a4 Ln18a4 Ln27a4 0.542987
Kn18an27a5 Ln18a5 Ln27a5 0.542987
Kn18an27a6 Ln18a6 Ln27a6 0.542987
Kn18an27a7 Ln18a7 Ln27a7 0.542987
Kn18an27a8 Ln18a8 Ln27a8 0.542987
Kn18an27a9 Ln18a9 Ln27a9 0.542987
Kn18an27a10 Ln18a10 Ln27a10 0.542987
Kn18an27a11 Ln18a11 Ln27a11 0.542987
Kn18an27a12 Ln18a12 Ln27a12 0.542987
Kn18an27a13 Ln18a13 Ln27a13 0.542987
Kn18an27a14 Ln18a14 Ln27a14 0.542987
Kn18an27a15 Ln18a15 Ln27a15 0.542987
Kn18an27a16 Ln18a16 Ln27a16 0.542987
Kn18an28a1 Ln18a1 Ln28a1 0.529400
Kn18an28a2 Ln18a2 Ln28a2 0.529400
Kn18an28a3 Ln18a3 Ln28a3 0.529400
Kn18an28a4 Ln18a4 Ln28a4 0.529400
Kn18an28a5 Ln18a5 Ln28a5 0.529400
Kn18an28a6 Ln18a6 Ln28a6 0.529400
Kn18an28a7 Ln18a7 Ln28a7 0.529400
Kn18an28a8 Ln18a8 Ln28a8 0.529400
Kn18an28a9 Ln18a9 Ln28a9 0.529400
Kn18an28a10 Ln18a10 Ln28a10 0.529400
Kn18an28a11 Ln18a11 Ln28a11 0.529400
Kn18an28a12 Ln18a12 Ln28a12 0.529400
Kn18an28a13 Ln18a13 Ln28a13 0.529400
Kn18an28a14 Ln18a14 Ln28a14 0.529400
Kn18an28a15 Ln18a15 Ln28a15 0.529400
Kn18an28a16 Ln18a16 Ln28a16 0.529400
Kn18an29a1 Ln18a1 Ln29a1 0.516943
Kn18an29a2 Ln18a2 Ln29a2 0.516943
Kn18an29a3 Ln18a3 Ln29a3 0.516943
Kn18an29a4 Ln18a4 Ln29a4 0.516943
Kn18an29a5 Ln18a5 Ln29a5 0.516943
Kn18an29a6 Ln18a6 Ln29a6 0.516943
Kn18an29a7 Ln18a7 Ln29a7 0.516943
Kn18an29a8 Ln18a8 Ln29a8 0.516943
Kn18an29a9 Ln18a9 Ln29a9 0.516943
Kn18an29a10 Ln18a10 Ln29a10 0.516943
Kn18an29a11 Ln18a11 Ln29a11 0.516943
Kn18an29a12 Ln18a12 Ln29a12 0.516943
Kn18an29a13 Ln18a13 Ln29a13 0.516943
Kn18an29a14 Ln18a14 Ln29a14 0.516943
Kn18an29a15 Ln18a15 Ln29a15 0.516943
Kn18an29a16 Ln18a16 Ln29a16 0.516943
Kn18an30a1 Ln18a1 Ln30a1 0.505455
Kn18an30a2 Ln18a2 Ln30a2 0.505455
Kn18an30a3 Ln18a3 Ln30a3 0.505455
Kn18an30a4 Ln18a4 Ln30a4 0.505455
Kn18an30a5 Ln18a5 Ln30a5 0.505455
Kn18an30a6 Ln18a6 Ln30a6 0.505455
Kn18an30a7 Ln18a7 Ln30a7 0.505455
Kn18an30a8 Ln18a8 Ln30a8 0.505455
Kn18an30a9 Ln18a9 Ln30a9 0.505455
Kn18an30a10 Ln18a10 Ln30a10 0.505455
Kn18an30a11 Ln18a11 Ln30a11 0.505455
Kn18an30a12 Ln18a12 Ln30a12 0.505455
Kn18an30a13 Ln18a13 Ln30a13 0.505455
Kn18an30a14 Ln18a14 Ln30a14 0.505455
Kn18an30a15 Ln18a15 Ln30a15 0.505455
Kn18an30a16 Ln18a16 Ln30a16 0.505455
Kn18an31a1 Ln18a1 Ln31a1 0.494887
Kn18an31a2 Ln18a2 Ln31a2 0.494887
Kn18an31a3 Ln18a3 Ln31a3 0.494887
Kn18an31a4 Ln18a4 Ln31a4 0.494887
Kn18an31a5 Ln18a5 Ln31a5 0.494887
Kn18an31a6 Ln18a6 Ln31a6 0.494887
Kn18an31a7 Ln18a7 Ln31a7 0.494887
Kn18an31a8 Ln18a8 Ln31a8 0.494887
Kn18an31a9 Ln18a9 Ln31a9 0.494887
Kn18an31a10 Ln18a10 Ln31a10 0.494887
Kn18an31a11 Ln18a11 Ln31a11 0.494887
Kn18an31a12 Ln18a12 Ln31a12 0.494887
Kn18an31a13 Ln18a13 Ln31a13 0.494887
Kn18an31a14 Ln18a14 Ln31a14 0.494887
Kn18an31a15 Ln18a15 Ln31a15 0.494887
Kn18an31a16 Ln18a16 Ln31a16 0.494887
Kn18an32a1 Ln18a1 Ln32a1 0.485771
Kn18an32a2 Ln18a2 Ln32a2 0.485771
Kn18an32a3 Ln18a3 Ln32a3 0.485771
Kn18an32a4 Ln18a4 Ln32a4 0.485771
Kn18an32a5 Ln18a5 Ln32a5 0.485771
Kn18an32a6 Ln18a6 Ln32a6 0.485771
Kn18an32a7 Ln18a7 Ln32a7 0.485771
Kn18an32a8 Ln18a8 Ln32a8 0.485771
Kn18an32a9 Ln18a9 Ln32a9 0.485771
Kn18an32a10 Ln18a10 Ln32a10 0.485771
Kn18an32a11 Ln18a11 Ln32a11 0.485771
Kn18an32a12 Ln18a12 Ln32a12 0.485771
Kn18an32a13 Ln18a13 Ln32a13 0.485771
Kn18an32a14 Ln18a14 Ln32a14 0.485771
Kn18an32a15 Ln18a15 Ln32a15 0.485771
Kn18an32a16 Ln18a16 Ln32a16 0.485771
Kn18anva1 Ln18a1 Lnva1 0.477226
Kn18anva2 Ln18a2 Lnva2 0.477226
Kn18anva3 Ln18a3 Lnva3 0.477226
Kn18anva4 Ln18a4 Lnva4 0.477226
Kn18anva5 Ln18a5 Lnva5 0.477226
Kn18anva6 Ln18a6 Lnva6 0.477226
Kn18anva7 Ln18a7 Lnva7 0.477226
Kn18anva8 Ln18a8 Lnva8 0.477226
Kn18anva9 Ln18a9 Lnva9 0.477226
Kn18anva10 Ln18a10 Lnva10 0.477226
Kn18anva11 Ln18a11 Lnva11 0.477226
Kn18anva12 Ln18a12 Lnva12 0.477226
Kn18anva13 Ln18a13 Lnva13 0.477226
Kn18anva14 Ln18a14 Lnva14 0.477226
Kn18anva15 Ln18a15 Lnva15 0.477226
Kn18anva16 Ln18a16 Lnva16 0.477226
Kn19an20a1 Ln19a1 Ln20a1 0.805155
Kn19an20a2 Ln19a2 Ln20a2 0.805155
Kn19an20a3 Ln19a3 Ln20a3 0.805155
Kn19an20a4 Ln19a4 Ln20a4 0.805155
Kn19an20a5 Ln19a5 Ln20a5 0.805155
Kn19an20a6 Ln19a6 Ln20a6 0.805155
Kn19an20a7 Ln19a7 Ln20a7 0.805155
Kn19an20a8 Ln19a8 Ln20a8 0.805155
Kn19an20a9 Ln19a9 Ln20a9 0.805155
Kn19an20a10 Ln19a10 Ln20a10 0.805155
Kn19an20a11 Ln19a11 Ln20a11 0.805155
Kn19an20a12 Ln19a12 Ln20a12 0.805155
Kn19an20a13 Ln19a13 Ln20a13 0.805155
Kn19an20a14 Ln19a14 Ln20a14 0.805155
Kn19an20a15 Ln19a15 Ln20a15 0.805155
Kn19an20a16 Ln19a16 Ln20a16 0.805155
Kn19an21a1 Ln19a1 Ln21a1 0.723730
Kn19an21a2 Ln19a2 Ln21a2 0.723730
Kn19an21a3 Ln19a3 Ln21a3 0.723730
Kn19an21a4 Ln19a4 Ln21a4 0.723730
Kn19an21a5 Ln19a5 Ln21a5 0.723730
Kn19an21a6 Ln19a6 Ln21a6 0.723730
Kn19an21a7 Ln19a7 Ln21a7 0.723730
Kn19an21a8 Ln19a8 Ln21a8 0.723730
Kn19an21a9 Ln19a9 Ln21a9 0.723730
Kn19an21a10 Ln19a10 Ln21a10 0.723730
Kn19an21a11 Ln19a11 Ln21a11 0.723730
Kn19an21a12 Ln19a12 Ln21a12 0.723730
Kn19an21a13 Ln19a13 Ln21a13 0.723730
Kn19an21a14 Ln19a14 Ln21a14 0.723730
Kn19an21a15 Ln19a15 Ln21a15 0.723730
Kn19an21a16 Ln19a16 Ln21a16 0.723730
Kn19an22a1 Ln19a1 Ln22a1 0.675208
Kn19an22a2 Ln19a2 Ln22a2 0.675208
Kn19an22a3 Ln19a3 Ln22a3 0.675208
Kn19an22a4 Ln19a4 Ln22a4 0.675208
Kn19an22a5 Ln19a5 Ln22a5 0.675208
Kn19an22a6 Ln19a6 Ln22a6 0.675208
Kn19an22a7 Ln19a7 Ln22a7 0.675208
Kn19an22a8 Ln19a8 Ln22a8 0.675208
Kn19an22a9 Ln19a9 Ln22a9 0.675208
Kn19an22a10 Ln19a10 Ln22a10 0.675208
Kn19an22a11 Ln19a11 Ln22a11 0.675208
Kn19an22a12 Ln19a12 Ln22a12 0.675208
Kn19an22a13 Ln19a13 Ln22a13 0.675208
Kn19an22a14 Ln19a14 Ln22a14 0.675208
Kn19an22a15 Ln19a15 Ln22a15 0.675208
Kn19an22a16 Ln19a16 Ln22a16 0.675208
Kn19an23a1 Ln19a1 Ln23a1 0.640637
Kn19an23a2 Ln19a2 Ln23a2 0.640637
Kn19an23a3 Ln19a3 Ln23a3 0.640637
Kn19an23a4 Ln19a4 Ln23a4 0.640637
Kn19an23a5 Ln19a5 Ln23a5 0.640637
Kn19an23a6 Ln19a6 Ln23a6 0.640637
Kn19an23a7 Ln19a7 Ln23a7 0.640637
Kn19an23a8 Ln19a8 Ln23a8 0.640637
Kn19an23a9 Ln19a9 Ln23a9 0.640637
Kn19an23a10 Ln19a10 Ln23a10 0.640637
Kn19an23a11 Ln19a11 Ln23a11 0.640637
Kn19an23a12 Ln19a12 Ln23a12 0.640637
Kn19an23a13 Ln19a13 Ln23a13 0.640637
Kn19an23a14 Ln19a14 Ln23a14 0.640637
Kn19an23a15 Ln19a15 Ln23a15 0.640637
Kn19an23a16 Ln19a16 Ln23a16 0.640637
Kn19an24a1 Ln19a1 Ln24a1 0.613723
Kn19an24a2 Ln19a2 Ln24a2 0.613723
Kn19an24a3 Ln19a3 Ln24a3 0.613723
Kn19an24a4 Ln19a4 Ln24a4 0.613723
Kn19an24a5 Ln19a5 Ln24a5 0.613723
Kn19an24a6 Ln19a6 Ln24a6 0.613723
Kn19an24a7 Ln19a7 Ln24a7 0.613723
Kn19an24a8 Ln19a8 Ln24a8 0.613723
Kn19an24a9 Ln19a9 Ln24a9 0.613723
Kn19an24a10 Ln19a10 Ln24a10 0.613723
Kn19an24a11 Ln19a11 Ln24a11 0.613723
Kn19an24a12 Ln19a12 Ln24a12 0.613723
Kn19an24a13 Ln19a13 Ln24a13 0.613723
Kn19an24a14 Ln19a14 Ln24a14 0.613723
Kn19an24a15 Ln19a15 Ln24a15 0.613723
Kn19an24a16 Ln19a16 Ln24a16 0.613723
Kn19an25a1 Ln19a1 Ln25a1 0.591812
Kn19an25a2 Ln19a2 Ln25a2 0.591812
Kn19an25a3 Ln19a3 Ln25a3 0.591812
Kn19an25a4 Ln19a4 Ln25a4 0.591812
Kn19an25a5 Ln19a5 Ln25a5 0.591812
Kn19an25a6 Ln19a6 Ln25a6 0.591812
Kn19an25a7 Ln19a7 Ln25a7 0.591812
Kn19an25a8 Ln19a8 Ln25a8 0.591812
Kn19an25a9 Ln19a9 Ln25a9 0.591812
Kn19an25a10 Ln19a10 Ln25a10 0.591812
Kn19an25a11 Ln19a11 Ln25a11 0.591812
Kn19an25a12 Ln19a12 Ln25a12 0.591812
Kn19an25a13 Ln19a13 Ln25a13 0.591812
Kn19an25a14 Ln19a14 Ln25a14 0.591812
Kn19an25a15 Ln19a15 Ln25a15 0.591812
Kn19an25a16 Ln19a16 Ln25a16 0.591812
Kn19an26a1 Ln19a1 Ln26a1 0.573237
Kn19an26a2 Ln19a2 Ln26a2 0.573237
Kn19an26a3 Ln19a3 Ln26a3 0.573237
Kn19an26a4 Ln19a4 Ln26a4 0.573237
Kn19an26a5 Ln19a5 Ln26a5 0.573237
Kn19an26a6 Ln19a6 Ln26a6 0.573237
Kn19an26a7 Ln19a7 Ln26a7 0.573237
Kn19an26a8 Ln19a8 Ln26a8 0.573237
Kn19an26a9 Ln19a9 Ln26a9 0.573237
Kn19an26a10 Ln19a10 Ln26a10 0.573237
Kn19an26a11 Ln19a11 Ln26a11 0.573237
Kn19an26a12 Ln19a12 Ln26a12 0.573237
Kn19an26a13 Ln19a13 Ln26a13 0.573237
Kn19an26a14 Ln19a14 Ln26a14 0.573237
Kn19an26a15 Ln19a15 Ln26a15 0.573237
Kn19an26a16 Ln19a16 Ln26a16 0.573237
Kn19an27a1 Ln19a1 Ln27a1 0.557165
Kn19an27a2 Ln19a2 Ln27a2 0.557165
Kn19an27a3 Ln19a3 Ln27a3 0.557165
Kn19an27a4 Ln19a4 Ln27a4 0.557165
Kn19an27a5 Ln19a5 Ln27a5 0.557165
Kn19an27a6 Ln19a6 Ln27a6 0.557165
Kn19an27a7 Ln19a7 Ln27a7 0.557165
Kn19an27a8 Ln19a8 Ln27a8 0.557165
Kn19an27a9 Ln19a9 Ln27a9 0.557165
Kn19an27a10 Ln19a10 Ln27a10 0.557165
Kn19an27a11 Ln19a11 Ln27a11 0.557165
Kn19an27a12 Ln19a12 Ln27a12 0.557165
Kn19an27a13 Ln19a13 Ln27a13 0.557165
Kn19an27a14 Ln19a14 Ln27a14 0.557165
Kn19an27a15 Ln19a15 Ln27a15 0.557165
Kn19an27a16 Ln19a16 Ln27a16 0.557165
Kn19an28a1 Ln19a1 Ln28a1 0.542987
Kn19an28a2 Ln19a2 Ln28a2 0.542987
Kn19an28a3 Ln19a3 Ln28a3 0.542987
Kn19an28a4 Ln19a4 Ln28a4 0.542987
Kn19an28a5 Ln19a5 Ln28a5 0.542987
Kn19an28a6 Ln19a6 Ln28a6 0.542987
Kn19an28a7 Ln19a7 Ln28a7 0.542987
Kn19an28a8 Ln19a8 Ln28a8 0.542987
Kn19an28a9 Ln19a9 Ln28a9 0.542987
Kn19an28a10 Ln19a10 Ln28a10 0.542987
Kn19an28a11 Ln19a11 Ln28a11 0.542987
Kn19an28a12 Ln19a12 Ln28a12 0.542987
Kn19an28a13 Ln19a13 Ln28a13 0.542987
Kn19an28a14 Ln19a14 Ln28a14 0.542987
Kn19an28a15 Ln19a15 Ln28a15 0.542987
Kn19an28a16 Ln19a16 Ln28a16 0.542987
Kn19an29a1 Ln19a1 Ln29a1 0.529400
Kn19an29a2 Ln19a2 Ln29a2 0.529400
Kn19an29a3 Ln19a3 Ln29a3 0.529400
Kn19an29a4 Ln19a4 Ln29a4 0.529400
Kn19an29a5 Ln19a5 Ln29a5 0.529400
Kn19an29a6 Ln19a6 Ln29a6 0.529400
Kn19an29a7 Ln19a7 Ln29a7 0.529400
Kn19an29a8 Ln19a8 Ln29a8 0.529400
Kn19an29a9 Ln19a9 Ln29a9 0.529400
Kn19an29a10 Ln19a10 Ln29a10 0.529400
Kn19an29a11 Ln19a11 Ln29a11 0.529400
Kn19an29a12 Ln19a12 Ln29a12 0.529400
Kn19an29a13 Ln19a13 Ln29a13 0.529400
Kn19an29a14 Ln19a14 Ln29a14 0.529400
Kn19an29a15 Ln19a15 Ln29a15 0.529400
Kn19an29a16 Ln19a16 Ln29a16 0.529400
Kn19an30a1 Ln19a1 Ln30a1 0.516943
Kn19an30a2 Ln19a2 Ln30a2 0.516943
Kn19an30a3 Ln19a3 Ln30a3 0.516943
Kn19an30a4 Ln19a4 Ln30a4 0.516943
Kn19an30a5 Ln19a5 Ln30a5 0.516943
Kn19an30a6 Ln19a6 Ln30a6 0.516943
Kn19an30a7 Ln19a7 Ln30a7 0.516943
Kn19an30a8 Ln19a8 Ln30a8 0.516943
Kn19an30a9 Ln19a9 Ln30a9 0.516943
Kn19an30a10 Ln19a10 Ln30a10 0.516943
Kn19an30a11 Ln19a11 Ln30a11 0.516943
Kn19an30a12 Ln19a12 Ln30a12 0.516943
Kn19an30a13 Ln19a13 Ln30a13 0.516943
Kn19an30a14 Ln19a14 Ln30a14 0.516943
Kn19an30a15 Ln19a15 Ln30a15 0.516943
Kn19an30a16 Ln19a16 Ln30a16 0.516943
Kn19an31a1 Ln19a1 Ln31a1 0.505455
Kn19an31a2 Ln19a2 Ln31a2 0.505455
Kn19an31a3 Ln19a3 Ln31a3 0.505455
Kn19an31a4 Ln19a4 Ln31a4 0.505455
Kn19an31a5 Ln19a5 Ln31a5 0.505455
Kn19an31a6 Ln19a6 Ln31a6 0.505455
Kn19an31a7 Ln19a7 Ln31a7 0.505455
Kn19an31a8 Ln19a8 Ln31a8 0.505455
Kn19an31a9 Ln19a9 Ln31a9 0.505455
Kn19an31a10 Ln19a10 Ln31a10 0.505455
Kn19an31a11 Ln19a11 Ln31a11 0.505455
Kn19an31a12 Ln19a12 Ln31a12 0.505455
Kn19an31a13 Ln19a13 Ln31a13 0.505455
Kn19an31a14 Ln19a14 Ln31a14 0.505455
Kn19an31a15 Ln19a15 Ln31a15 0.505455
Kn19an31a16 Ln19a16 Ln31a16 0.505455
Kn19an32a1 Ln19a1 Ln32a1 0.494887
Kn19an32a2 Ln19a2 Ln32a2 0.494887
Kn19an32a3 Ln19a3 Ln32a3 0.494887
Kn19an32a4 Ln19a4 Ln32a4 0.494887
Kn19an32a5 Ln19a5 Ln32a5 0.494887
Kn19an32a6 Ln19a6 Ln32a6 0.494887
Kn19an32a7 Ln19a7 Ln32a7 0.494887
Kn19an32a8 Ln19a8 Ln32a8 0.494887
Kn19an32a9 Ln19a9 Ln32a9 0.494887
Kn19an32a10 Ln19a10 Ln32a10 0.494887
Kn19an32a11 Ln19a11 Ln32a11 0.494887
Kn19an32a12 Ln19a12 Ln32a12 0.494887
Kn19an32a13 Ln19a13 Ln32a13 0.494887
Kn19an32a14 Ln19a14 Ln32a14 0.494887
Kn19an32a15 Ln19a15 Ln32a15 0.494887
Kn19an32a16 Ln19a16 Ln32a16 0.494887
Kn19anva1 Ln19a1 Lnva1 0.485771
Kn19anva2 Ln19a2 Lnva2 0.485771
Kn19anva3 Ln19a3 Lnva3 0.485771
Kn19anva4 Ln19a4 Lnva4 0.485771
Kn19anva5 Ln19a5 Lnva5 0.485771
Kn19anva6 Ln19a6 Lnva6 0.485771
Kn19anva7 Ln19a7 Lnva7 0.485771
Kn19anva8 Ln19a8 Lnva8 0.485771
Kn19anva9 Ln19a9 Lnva9 0.485771
Kn19anva10 Ln19a10 Lnva10 0.485771
Kn19anva11 Ln19a11 Lnva11 0.485771
Kn19anva12 Ln19a12 Lnva12 0.485771
Kn19anva13 Ln19a13 Lnva13 0.485771
Kn19anva14 Ln19a14 Lnva14 0.485771
Kn19anva15 Ln19a15 Lnva15 0.485771
Kn19anva16 Ln19a16 Lnva16 0.485771
Kn20an21a1 Ln20a1 Ln21a1 0.805155
Kn20an21a2 Ln20a2 Ln21a2 0.805155
Kn20an21a3 Ln20a3 Ln21a3 0.805155
Kn20an21a4 Ln20a4 Ln21a4 0.805155
Kn20an21a5 Ln20a5 Ln21a5 0.805155
Kn20an21a6 Ln20a6 Ln21a6 0.805155
Kn20an21a7 Ln20a7 Ln21a7 0.805155
Kn20an21a8 Ln20a8 Ln21a8 0.805155
Kn20an21a9 Ln20a9 Ln21a9 0.805155
Kn20an21a10 Ln20a10 Ln21a10 0.805155
Kn20an21a11 Ln20a11 Ln21a11 0.805155
Kn20an21a12 Ln20a12 Ln21a12 0.805155
Kn20an21a13 Ln20a13 Ln21a13 0.805155
Kn20an21a14 Ln20a14 Ln21a14 0.805155
Kn20an21a15 Ln20a15 Ln21a15 0.805155
Kn20an21a16 Ln20a16 Ln21a16 0.805155
Kn20an22a1 Ln20a1 Ln22a1 0.723730
Kn20an22a2 Ln20a2 Ln22a2 0.723730
Kn20an22a3 Ln20a3 Ln22a3 0.723730
Kn20an22a4 Ln20a4 Ln22a4 0.723730
Kn20an22a5 Ln20a5 Ln22a5 0.723730
Kn20an22a6 Ln20a6 Ln22a6 0.723730
Kn20an22a7 Ln20a7 Ln22a7 0.723730
Kn20an22a8 Ln20a8 Ln22a8 0.723730
Kn20an22a9 Ln20a9 Ln22a9 0.723730
Kn20an22a10 Ln20a10 Ln22a10 0.723730
Kn20an22a11 Ln20a11 Ln22a11 0.723730
Kn20an22a12 Ln20a12 Ln22a12 0.723730
Kn20an22a13 Ln20a13 Ln22a13 0.723730
Kn20an22a14 Ln20a14 Ln22a14 0.723730
Kn20an22a15 Ln20a15 Ln22a15 0.723730
Kn20an22a16 Ln20a16 Ln22a16 0.723730
Kn20an23a1 Ln20a1 Ln23a1 0.675208
Kn20an23a2 Ln20a2 Ln23a2 0.675208
Kn20an23a3 Ln20a3 Ln23a3 0.675208
Kn20an23a4 Ln20a4 Ln23a4 0.675208
Kn20an23a5 Ln20a5 Ln23a5 0.675208
Kn20an23a6 Ln20a6 Ln23a6 0.675208
Kn20an23a7 Ln20a7 Ln23a7 0.675208
Kn20an23a8 Ln20a8 Ln23a8 0.675208
Kn20an23a9 Ln20a9 Ln23a9 0.675208
Kn20an23a10 Ln20a10 Ln23a10 0.675208
Kn20an23a11 Ln20a11 Ln23a11 0.675208
Kn20an23a12 Ln20a12 Ln23a12 0.675208
Kn20an23a13 Ln20a13 Ln23a13 0.675208
Kn20an23a14 Ln20a14 Ln23a14 0.675208
Kn20an23a15 Ln20a15 Ln23a15 0.675208
Kn20an23a16 Ln20a16 Ln23a16 0.675208
Kn20an24a1 Ln20a1 Ln24a1 0.640637
Kn20an24a2 Ln20a2 Ln24a2 0.640637
Kn20an24a3 Ln20a3 Ln24a3 0.640637
Kn20an24a4 Ln20a4 Ln24a4 0.640637
Kn20an24a5 Ln20a5 Ln24a5 0.640637
Kn20an24a6 Ln20a6 Ln24a6 0.640637
Kn20an24a7 Ln20a7 Ln24a7 0.640637
Kn20an24a8 Ln20a8 Ln24a8 0.640637
Kn20an24a9 Ln20a9 Ln24a9 0.640637
Kn20an24a10 Ln20a10 Ln24a10 0.640637
Kn20an24a11 Ln20a11 Ln24a11 0.640637
Kn20an24a12 Ln20a12 Ln24a12 0.640637
Kn20an24a13 Ln20a13 Ln24a13 0.640637
Kn20an24a14 Ln20a14 Ln24a14 0.640637
Kn20an24a15 Ln20a15 Ln24a15 0.640637
Kn20an24a16 Ln20a16 Ln24a16 0.640637
Kn20an25a1 Ln20a1 Ln25a1 0.613723
Kn20an25a2 Ln20a2 Ln25a2 0.613723
Kn20an25a3 Ln20a3 Ln25a3 0.613723
Kn20an25a4 Ln20a4 Ln25a4 0.613723
Kn20an25a5 Ln20a5 Ln25a5 0.613723
Kn20an25a6 Ln20a6 Ln25a6 0.613723
Kn20an25a7 Ln20a7 Ln25a7 0.613723
Kn20an25a8 Ln20a8 Ln25a8 0.613723
Kn20an25a9 Ln20a9 Ln25a9 0.613723
Kn20an25a10 Ln20a10 Ln25a10 0.613723
Kn20an25a11 Ln20a11 Ln25a11 0.613723
Kn20an25a12 Ln20a12 Ln25a12 0.613723
Kn20an25a13 Ln20a13 Ln25a13 0.613723
Kn20an25a14 Ln20a14 Ln25a14 0.613723
Kn20an25a15 Ln20a15 Ln25a15 0.613723
Kn20an25a16 Ln20a16 Ln25a16 0.613723
Kn20an26a1 Ln20a1 Ln26a1 0.591812
Kn20an26a2 Ln20a2 Ln26a2 0.591812
Kn20an26a3 Ln20a3 Ln26a3 0.591812
Kn20an26a4 Ln20a4 Ln26a4 0.591812
Kn20an26a5 Ln20a5 Ln26a5 0.591812
Kn20an26a6 Ln20a6 Ln26a6 0.591812
Kn20an26a7 Ln20a7 Ln26a7 0.591812
Kn20an26a8 Ln20a8 Ln26a8 0.591812
Kn20an26a9 Ln20a9 Ln26a9 0.591812
Kn20an26a10 Ln20a10 Ln26a10 0.591812
Kn20an26a11 Ln20a11 Ln26a11 0.591812
Kn20an26a12 Ln20a12 Ln26a12 0.591812
Kn20an26a13 Ln20a13 Ln26a13 0.591812
Kn20an26a14 Ln20a14 Ln26a14 0.591812
Kn20an26a15 Ln20a15 Ln26a15 0.591812
Kn20an26a16 Ln20a16 Ln26a16 0.591812
Kn20an27a1 Ln20a1 Ln27a1 0.573237
Kn20an27a2 Ln20a2 Ln27a2 0.573237
Kn20an27a3 Ln20a3 Ln27a3 0.573237
Kn20an27a4 Ln20a4 Ln27a4 0.573237
Kn20an27a5 Ln20a5 Ln27a5 0.573237
Kn20an27a6 Ln20a6 Ln27a6 0.573237
Kn20an27a7 Ln20a7 Ln27a7 0.573237
Kn20an27a8 Ln20a8 Ln27a8 0.573237
Kn20an27a9 Ln20a9 Ln27a9 0.573237
Kn20an27a10 Ln20a10 Ln27a10 0.573237
Kn20an27a11 Ln20a11 Ln27a11 0.573237
Kn20an27a12 Ln20a12 Ln27a12 0.573237
Kn20an27a13 Ln20a13 Ln27a13 0.573237
Kn20an27a14 Ln20a14 Ln27a14 0.573237
Kn20an27a15 Ln20a15 Ln27a15 0.573237
Kn20an27a16 Ln20a16 Ln27a16 0.573237
Kn20an28a1 Ln20a1 Ln28a1 0.557165
Kn20an28a2 Ln20a2 Ln28a2 0.557165
Kn20an28a3 Ln20a3 Ln28a3 0.557165
Kn20an28a4 Ln20a4 Ln28a4 0.557165
Kn20an28a5 Ln20a5 Ln28a5 0.557165
Kn20an28a6 Ln20a6 Ln28a6 0.557165
Kn20an28a7 Ln20a7 Ln28a7 0.557165
Kn20an28a8 Ln20a8 Ln28a8 0.557165
Kn20an28a9 Ln20a9 Ln28a9 0.557165
Kn20an28a10 Ln20a10 Ln28a10 0.557165
Kn20an28a11 Ln20a11 Ln28a11 0.557165
Kn20an28a12 Ln20a12 Ln28a12 0.557165
Kn20an28a13 Ln20a13 Ln28a13 0.557165
Kn20an28a14 Ln20a14 Ln28a14 0.557165
Kn20an28a15 Ln20a15 Ln28a15 0.557165
Kn20an28a16 Ln20a16 Ln28a16 0.557165
Kn20an29a1 Ln20a1 Ln29a1 0.542987
Kn20an29a2 Ln20a2 Ln29a2 0.542987
Kn20an29a3 Ln20a3 Ln29a3 0.542987
Kn20an29a4 Ln20a4 Ln29a4 0.542987
Kn20an29a5 Ln20a5 Ln29a5 0.542987
Kn20an29a6 Ln20a6 Ln29a6 0.542987
Kn20an29a7 Ln20a7 Ln29a7 0.542987
Kn20an29a8 Ln20a8 Ln29a8 0.542987
Kn20an29a9 Ln20a9 Ln29a9 0.542987
Kn20an29a10 Ln20a10 Ln29a10 0.542987
Kn20an29a11 Ln20a11 Ln29a11 0.542987
Kn20an29a12 Ln20a12 Ln29a12 0.542987
Kn20an29a13 Ln20a13 Ln29a13 0.542987
Kn20an29a14 Ln20a14 Ln29a14 0.542987
Kn20an29a15 Ln20a15 Ln29a15 0.542987
Kn20an29a16 Ln20a16 Ln29a16 0.542987
Kn20an30a1 Ln20a1 Ln30a1 0.529400
Kn20an30a2 Ln20a2 Ln30a2 0.529400
Kn20an30a3 Ln20a3 Ln30a3 0.529400
Kn20an30a4 Ln20a4 Ln30a4 0.529400
Kn20an30a5 Ln20a5 Ln30a5 0.529400
Kn20an30a6 Ln20a6 Ln30a6 0.529400
Kn20an30a7 Ln20a7 Ln30a7 0.529400
Kn20an30a8 Ln20a8 Ln30a8 0.529400
Kn20an30a9 Ln20a9 Ln30a9 0.529400
Kn20an30a10 Ln20a10 Ln30a10 0.529400
Kn20an30a11 Ln20a11 Ln30a11 0.529400
Kn20an30a12 Ln20a12 Ln30a12 0.529400
Kn20an30a13 Ln20a13 Ln30a13 0.529400
Kn20an30a14 Ln20a14 Ln30a14 0.529400
Kn20an30a15 Ln20a15 Ln30a15 0.529400
Kn20an30a16 Ln20a16 Ln30a16 0.529400
Kn20an31a1 Ln20a1 Ln31a1 0.516943
Kn20an31a2 Ln20a2 Ln31a2 0.516943
Kn20an31a3 Ln20a3 Ln31a3 0.516943
Kn20an31a4 Ln20a4 Ln31a4 0.516943
Kn20an31a5 Ln20a5 Ln31a5 0.516943
Kn20an31a6 Ln20a6 Ln31a6 0.516943
Kn20an31a7 Ln20a7 Ln31a7 0.516943
Kn20an31a8 Ln20a8 Ln31a8 0.516943
Kn20an31a9 Ln20a9 Ln31a9 0.516943
Kn20an31a10 Ln20a10 Ln31a10 0.516943
Kn20an31a11 Ln20a11 Ln31a11 0.516943
Kn20an31a12 Ln20a12 Ln31a12 0.516943
Kn20an31a13 Ln20a13 Ln31a13 0.516943
Kn20an31a14 Ln20a14 Ln31a14 0.516943
Kn20an31a15 Ln20a15 Ln31a15 0.516943
Kn20an31a16 Ln20a16 Ln31a16 0.516943
Kn20an32a1 Ln20a1 Ln32a1 0.505455
Kn20an32a2 Ln20a2 Ln32a2 0.505455
Kn20an32a3 Ln20a3 Ln32a3 0.505455
Kn20an32a4 Ln20a4 Ln32a4 0.505455
Kn20an32a5 Ln20a5 Ln32a5 0.505455
Kn20an32a6 Ln20a6 Ln32a6 0.505455
Kn20an32a7 Ln20a7 Ln32a7 0.505455
Kn20an32a8 Ln20a8 Ln32a8 0.505455
Kn20an32a9 Ln20a9 Ln32a9 0.505455
Kn20an32a10 Ln20a10 Ln32a10 0.505455
Kn20an32a11 Ln20a11 Ln32a11 0.505455
Kn20an32a12 Ln20a12 Ln32a12 0.505455
Kn20an32a13 Ln20a13 Ln32a13 0.505455
Kn20an32a14 Ln20a14 Ln32a14 0.505455
Kn20an32a15 Ln20a15 Ln32a15 0.505455
Kn20an32a16 Ln20a16 Ln32a16 0.505455
Kn20anva1 Ln20a1 Lnva1 0.494887
Kn20anva2 Ln20a2 Lnva2 0.494887
Kn20anva3 Ln20a3 Lnva3 0.494887
Kn20anva4 Ln20a4 Lnva4 0.494887
Kn20anva5 Ln20a5 Lnva5 0.494887
Kn20anva6 Ln20a6 Lnva6 0.494887
Kn20anva7 Ln20a7 Lnva7 0.494887
Kn20anva8 Ln20a8 Lnva8 0.494887
Kn20anva9 Ln20a9 Lnva9 0.494887
Kn20anva10 Ln20a10 Lnva10 0.494887
Kn20anva11 Ln20a11 Lnva11 0.494887
Kn20anva12 Ln20a12 Lnva12 0.494887
Kn20anva13 Ln20a13 Lnva13 0.494887
Kn20anva14 Ln20a14 Lnva14 0.494887
Kn20anva15 Ln20a15 Lnva15 0.494887
Kn20anva16 Ln20a16 Lnva16 0.494887
Kn21an22a1 Ln21a1 Ln22a1 0.805155
Kn21an22a2 Ln21a2 Ln22a2 0.805155
Kn21an22a3 Ln21a3 Ln22a3 0.805155
Kn21an22a4 Ln21a4 Ln22a4 0.805155
Kn21an22a5 Ln21a5 Ln22a5 0.805155
Kn21an22a6 Ln21a6 Ln22a6 0.805155
Kn21an22a7 Ln21a7 Ln22a7 0.805155
Kn21an22a8 Ln21a8 Ln22a8 0.805155
Kn21an22a9 Ln21a9 Ln22a9 0.805155
Kn21an22a10 Ln21a10 Ln22a10 0.805155
Kn21an22a11 Ln21a11 Ln22a11 0.805155
Kn21an22a12 Ln21a12 Ln22a12 0.805155
Kn21an22a13 Ln21a13 Ln22a13 0.805155
Kn21an22a14 Ln21a14 Ln22a14 0.805155
Kn21an22a15 Ln21a15 Ln22a15 0.805155
Kn21an22a16 Ln21a16 Ln22a16 0.805155
Kn21an23a1 Ln21a1 Ln23a1 0.723730
Kn21an23a2 Ln21a2 Ln23a2 0.723730
Kn21an23a3 Ln21a3 Ln23a3 0.723730
Kn21an23a4 Ln21a4 Ln23a4 0.723730
Kn21an23a5 Ln21a5 Ln23a5 0.723730
Kn21an23a6 Ln21a6 Ln23a6 0.723730
Kn21an23a7 Ln21a7 Ln23a7 0.723730
Kn21an23a8 Ln21a8 Ln23a8 0.723730
Kn21an23a9 Ln21a9 Ln23a9 0.723730
Kn21an23a10 Ln21a10 Ln23a10 0.723730
Kn21an23a11 Ln21a11 Ln23a11 0.723730
Kn21an23a12 Ln21a12 Ln23a12 0.723730
Kn21an23a13 Ln21a13 Ln23a13 0.723730
Kn21an23a14 Ln21a14 Ln23a14 0.723730
Kn21an23a15 Ln21a15 Ln23a15 0.723730
Kn21an23a16 Ln21a16 Ln23a16 0.723730
Kn21an24a1 Ln21a1 Ln24a1 0.675208
Kn21an24a2 Ln21a2 Ln24a2 0.675208
Kn21an24a3 Ln21a3 Ln24a3 0.675208
Kn21an24a4 Ln21a4 Ln24a4 0.675208
Kn21an24a5 Ln21a5 Ln24a5 0.675208
Kn21an24a6 Ln21a6 Ln24a6 0.675208
Kn21an24a7 Ln21a7 Ln24a7 0.675208
Kn21an24a8 Ln21a8 Ln24a8 0.675208
Kn21an24a9 Ln21a9 Ln24a9 0.675208
Kn21an24a10 Ln21a10 Ln24a10 0.675208
Kn21an24a11 Ln21a11 Ln24a11 0.675208
Kn21an24a12 Ln21a12 Ln24a12 0.675208
Kn21an24a13 Ln21a13 Ln24a13 0.675208
Kn21an24a14 Ln21a14 Ln24a14 0.675208
Kn21an24a15 Ln21a15 Ln24a15 0.675208
Kn21an24a16 Ln21a16 Ln24a16 0.675208
Kn21an25a1 Ln21a1 Ln25a1 0.640637
Kn21an25a2 Ln21a2 Ln25a2 0.640637
Kn21an25a3 Ln21a3 Ln25a3 0.640637
Kn21an25a4 Ln21a4 Ln25a4 0.640637
Kn21an25a5 Ln21a5 Ln25a5 0.640637
Kn21an25a6 Ln21a6 Ln25a6 0.640637
Kn21an25a7 Ln21a7 Ln25a7 0.640637
Kn21an25a8 Ln21a8 Ln25a8 0.640637
Kn21an25a9 Ln21a9 Ln25a9 0.640637
Kn21an25a10 Ln21a10 Ln25a10 0.640637
Kn21an25a11 Ln21a11 Ln25a11 0.640637
Kn21an25a12 Ln21a12 Ln25a12 0.640637
Kn21an25a13 Ln21a13 Ln25a13 0.640637
Kn21an25a14 Ln21a14 Ln25a14 0.640637
Kn21an25a15 Ln21a15 Ln25a15 0.640637
Kn21an25a16 Ln21a16 Ln25a16 0.640637
Kn21an26a1 Ln21a1 Ln26a1 0.613723
Kn21an26a2 Ln21a2 Ln26a2 0.613723
Kn21an26a3 Ln21a3 Ln26a3 0.613723
Kn21an26a4 Ln21a4 Ln26a4 0.613723
Kn21an26a5 Ln21a5 Ln26a5 0.613723
Kn21an26a6 Ln21a6 Ln26a6 0.613723
Kn21an26a7 Ln21a7 Ln26a7 0.613723
Kn21an26a8 Ln21a8 Ln26a8 0.613723
Kn21an26a9 Ln21a9 Ln26a9 0.613723
Kn21an26a10 Ln21a10 Ln26a10 0.613723
Kn21an26a11 Ln21a11 Ln26a11 0.613723
Kn21an26a12 Ln21a12 Ln26a12 0.613723
Kn21an26a13 Ln21a13 Ln26a13 0.613723
Kn21an26a14 Ln21a14 Ln26a14 0.613723
Kn21an26a15 Ln21a15 Ln26a15 0.613723
Kn21an26a16 Ln21a16 Ln26a16 0.613723
Kn21an27a1 Ln21a1 Ln27a1 0.591812
Kn21an27a2 Ln21a2 Ln27a2 0.591812
Kn21an27a3 Ln21a3 Ln27a3 0.591812
Kn21an27a4 Ln21a4 Ln27a4 0.591812
Kn21an27a5 Ln21a5 Ln27a5 0.591812
Kn21an27a6 Ln21a6 Ln27a6 0.591812
Kn21an27a7 Ln21a7 Ln27a7 0.591812
Kn21an27a8 Ln21a8 Ln27a8 0.591812
Kn21an27a9 Ln21a9 Ln27a9 0.591812
Kn21an27a10 Ln21a10 Ln27a10 0.591812
Kn21an27a11 Ln21a11 Ln27a11 0.591812
Kn21an27a12 Ln21a12 Ln27a12 0.591812
Kn21an27a13 Ln21a13 Ln27a13 0.591812
Kn21an27a14 Ln21a14 Ln27a14 0.591812
Kn21an27a15 Ln21a15 Ln27a15 0.591812
Kn21an27a16 Ln21a16 Ln27a16 0.591812
Kn21an28a1 Ln21a1 Ln28a1 0.573237
Kn21an28a2 Ln21a2 Ln28a2 0.573237
Kn21an28a3 Ln21a3 Ln28a3 0.573237
Kn21an28a4 Ln21a4 Ln28a4 0.573237
Kn21an28a5 Ln21a5 Ln28a5 0.573237
Kn21an28a6 Ln21a6 Ln28a6 0.573237
Kn21an28a7 Ln21a7 Ln28a7 0.573237
Kn21an28a8 Ln21a8 Ln28a8 0.573237
Kn21an28a9 Ln21a9 Ln28a9 0.573237
Kn21an28a10 Ln21a10 Ln28a10 0.573237
Kn21an28a11 Ln21a11 Ln28a11 0.573237
Kn21an28a12 Ln21a12 Ln28a12 0.573237
Kn21an28a13 Ln21a13 Ln28a13 0.573237
Kn21an28a14 Ln21a14 Ln28a14 0.573237
Kn21an28a15 Ln21a15 Ln28a15 0.573237
Kn21an28a16 Ln21a16 Ln28a16 0.573237
Kn21an29a1 Ln21a1 Ln29a1 0.557165
Kn21an29a2 Ln21a2 Ln29a2 0.557165
Kn21an29a3 Ln21a3 Ln29a3 0.557165
Kn21an29a4 Ln21a4 Ln29a4 0.557165
Kn21an29a5 Ln21a5 Ln29a5 0.557165
Kn21an29a6 Ln21a6 Ln29a6 0.557165
Kn21an29a7 Ln21a7 Ln29a7 0.557165
Kn21an29a8 Ln21a8 Ln29a8 0.557165
Kn21an29a9 Ln21a9 Ln29a9 0.557165
Kn21an29a10 Ln21a10 Ln29a10 0.557165
Kn21an29a11 Ln21a11 Ln29a11 0.557165
Kn21an29a12 Ln21a12 Ln29a12 0.557165
Kn21an29a13 Ln21a13 Ln29a13 0.557165
Kn21an29a14 Ln21a14 Ln29a14 0.557165
Kn21an29a15 Ln21a15 Ln29a15 0.557165
Kn21an29a16 Ln21a16 Ln29a16 0.557165
Kn21an30a1 Ln21a1 Ln30a1 0.542987
Kn21an30a2 Ln21a2 Ln30a2 0.542987
Kn21an30a3 Ln21a3 Ln30a3 0.542987
Kn21an30a4 Ln21a4 Ln30a4 0.542987
Kn21an30a5 Ln21a5 Ln30a5 0.542987
Kn21an30a6 Ln21a6 Ln30a6 0.542987
Kn21an30a7 Ln21a7 Ln30a7 0.542987
Kn21an30a8 Ln21a8 Ln30a8 0.542987
Kn21an30a9 Ln21a9 Ln30a9 0.542987
Kn21an30a10 Ln21a10 Ln30a10 0.542987
Kn21an30a11 Ln21a11 Ln30a11 0.542987
Kn21an30a12 Ln21a12 Ln30a12 0.542987
Kn21an30a13 Ln21a13 Ln30a13 0.542987
Kn21an30a14 Ln21a14 Ln30a14 0.542987
Kn21an30a15 Ln21a15 Ln30a15 0.542987
Kn21an30a16 Ln21a16 Ln30a16 0.542987
Kn21an31a1 Ln21a1 Ln31a1 0.529400
Kn21an31a2 Ln21a2 Ln31a2 0.529400
Kn21an31a3 Ln21a3 Ln31a3 0.529400
Kn21an31a4 Ln21a4 Ln31a4 0.529400
Kn21an31a5 Ln21a5 Ln31a5 0.529400
Kn21an31a6 Ln21a6 Ln31a6 0.529400
Kn21an31a7 Ln21a7 Ln31a7 0.529400
Kn21an31a8 Ln21a8 Ln31a8 0.529400
Kn21an31a9 Ln21a9 Ln31a9 0.529400
Kn21an31a10 Ln21a10 Ln31a10 0.529400
Kn21an31a11 Ln21a11 Ln31a11 0.529400
Kn21an31a12 Ln21a12 Ln31a12 0.529400
Kn21an31a13 Ln21a13 Ln31a13 0.529400
Kn21an31a14 Ln21a14 Ln31a14 0.529400
Kn21an31a15 Ln21a15 Ln31a15 0.529400
Kn21an31a16 Ln21a16 Ln31a16 0.529400
Kn21an32a1 Ln21a1 Ln32a1 0.516943
Kn21an32a2 Ln21a2 Ln32a2 0.516943
Kn21an32a3 Ln21a3 Ln32a3 0.516943
Kn21an32a4 Ln21a4 Ln32a4 0.516943
Kn21an32a5 Ln21a5 Ln32a5 0.516943
Kn21an32a6 Ln21a6 Ln32a6 0.516943
Kn21an32a7 Ln21a7 Ln32a7 0.516943
Kn21an32a8 Ln21a8 Ln32a8 0.516943
Kn21an32a9 Ln21a9 Ln32a9 0.516943
Kn21an32a10 Ln21a10 Ln32a10 0.516943
Kn21an32a11 Ln21a11 Ln32a11 0.516943
Kn21an32a12 Ln21a12 Ln32a12 0.516943
Kn21an32a13 Ln21a13 Ln32a13 0.516943
Kn21an32a14 Ln21a14 Ln32a14 0.516943
Kn21an32a15 Ln21a15 Ln32a15 0.516943
Kn21an32a16 Ln21a16 Ln32a16 0.516943
Kn21anva1 Ln21a1 Lnva1 0.505455
Kn21anva2 Ln21a2 Lnva2 0.505455
Kn21anva3 Ln21a3 Lnva3 0.505455
Kn21anva4 Ln21a4 Lnva4 0.505455
Kn21anva5 Ln21a5 Lnva5 0.505455
Kn21anva6 Ln21a6 Lnva6 0.505455
Kn21anva7 Ln21a7 Lnva7 0.505455
Kn21anva8 Ln21a8 Lnva8 0.505455
Kn21anva9 Ln21a9 Lnva9 0.505455
Kn21anva10 Ln21a10 Lnva10 0.505455
Kn21anva11 Ln21a11 Lnva11 0.505455
Kn21anva12 Ln21a12 Lnva12 0.505455
Kn21anva13 Ln21a13 Lnva13 0.505455
Kn21anva14 Ln21a14 Lnva14 0.505455
Kn21anva15 Ln21a15 Lnva15 0.505455
Kn21anva16 Ln21a16 Lnva16 0.505455
Kn22an23a1 Ln22a1 Ln23a1 0.805155
Kn22an23a2 Ln22a2 Ln23a2 0.805155
Kn22an23a3 Ln22a3 Ln23a3 0.805155
Kn22an23a4 Ln22a4 Ln23a4 0.805155
Kn22an23a5 Ln22a5 Ln23a5 0.805155
Kn22an23a6 Ln22a6 Ln23a6 0.805155
Kn22an23a7 Ln22a7 Ln23a7 0.805155
Kn22an23a8 Ln22a8 Ln23a8 0.805155
Kn22an23a9 Ln22a9 Ln23a9 0.805155
Kn22an23a10 Ln22a10 Ln23a10 0.805155
Kn22an23a11 Ln22a11 Ln23a11 0.805155
Kn22an23a12 Ln22a12 Ln23a12 0.805155
Kn22an23a13 Ln22a13 Ln23a13 0.805155
Kn22an23a14 Ln22a14 Ln23a14 0.805155
Kn22an23a15 Ln22a15 Ln23a15 0.805155
Kn22an23a16 Ln22a16 Ln23a16 0.805155
Kn22an24a1 Ln22a1 Ln24a1 0.723730
Kn22an24a2 Ln22a2 Ln24a2 0.723730
Kn22an24a3 Ln22a3 Ln24a3 0.723730
Kn22an24a4 Ln22a4 Ln24a4 0.723730
Kn22an24a5 Ln22a5 Ln24a5 0.723730
Kn22an24a6 Ln22a6 Ln24a6 0.723730
Kn22an24a7 Ln22a7 Ln24a7 0.723730
Kn22an24a8 Ln22a8 Ln24a8 0.723730
Kn22an24a9 Ln22a9 Ln24a9 0.723730
Kn22an24a10 Ln22a10 Ln24a10 0.723730
Kn22an24a11 Ln22a11 Ln24a11 0.723730
Kn22an24a12 Ln22a12 Ln24a12 0.723730
Kn22an24a13 Ln22a13 Ln24a13 0.723730
Kn22an24a14 Ln22a14 Ln24a14 0.723730
Kn22an24a15 Ln22a15 Ln24a15 0.723730
Kn22an24a16 Ln22a16 Ln24a16 0.723730
Kn22an25a1 Ln22a1 Ln25a1 0.675208
Kn22an25a2 Ln22a2 Ln25a2 0.675208
Kn22an25a3 Ln22a3 Ln25a3 0.675208
Kn22an25a4 Ln22a4 Ln25a4 0.675208
Kn22an25a5 Ln22a5 Ln25a5 0.675208
Kn22an25a6 Ln22a6 Ln25a6 0.675208
Kn22an25a7 Ln22a7 Ln25a7 0.675208
Kn22an25a8 Ln22a8 Ln25a8 0.675208
Kn22an25a9 Ln22a9 Ln25a9 0.675208
Kn22an25a10 Ln22a10 Ln25a10 0.675208
Kn22an25a11 Ln22a11 Ln25a11 0.675208
Kn22an25a12 Ln22a12 Ln25a12 0.675208
Kn22an25a13 Ln22a13 Ln25a13 0.675208
Kn22an25a14 Ln22a14 Ln25a14 0.675208
Kn22an25a15 Ln22a15 Ln25a15 0.675208
Kn22an25a16 Ln22a16 Ln25a16 0.675208
Kn22an26a1 Ln22a1 Ln26a1 0.640637
Kn22an26a2 Ln22a2 Ln26a2 0.640637
Kn22an26a3 Ln22a3 Ln26a3 0.640637
Kn22an26a4 Ln22a4 Ln26a4 0.640637
Kn22an26a5 Ln22a5 Ln26a5 0.640637
Kn22an26a6 Ln22a6 Ln26a6 0.640637
Kn22an26a7 Ln22a7 Ln26a7 0.640637
Kn22an26a8 Ln22a8 Ln26a8 0.640637
Kn22an26a9 Ln22a9 Ln26a9 0.640637
Kn22an26a10 Ln22a10 Ln26a10 0.640637
Kn22an26a11 Ln22a11 Ln26a11 0.640637
Kn22an26a12 Ln22a12 Ln26a12 0.640637
Kn22an26a13 Ln22a13 Ln26a13 0.640637
Kn22an26a14 Ln22a14 Ln26a14 0.640637
Kn22an26a15 Ln22a15 Ln26a15 0.640637
Kn22an26a16 Ln22a16 Ln26a16 0.640637
Kn22an27a1 Ln22a1 Ln27a1 0.613723
Kn22an27a2 Ln22a2 Ln27a2 0.613723
Kn22an27a3 Ln22a3 Ln27a3 0.613723
Kn22an27a4 Ln22a4 Ln27a4 0.613723
Kn22an27a5 Ln22a5 Ln27a5 0.613723
Kn22an27a6 Ln22a6 Ln27a6 0.613723
Kn22an27a7 Ln22a7 Ln27a7 0.613723
Kn22an27a8 Ln22a8 Ln27a8 0.613723
Kn22an27a9 Ln22a9 Ln27a9 0.613723
Kn22an27a10 Ln22a10 Ln27a10 0.613723
Kn22an27a11 Ln22a11 Ln27a11 0.613723
Kn22an27a12 Ln22a12 Ln27a12 0.613723
Kn22an27a13 Ln22a13 Ln27a13 0.613723
Kn22an27a14 Ln22a14 Ln27a14 0.613723
Kn22an27a15 Ln22a15 Ln27a15 0.613723
Kn22an27a16 Ln22a16 Ln27a16 0.613723
Kn22an28a1 Ln22a1 Ln28a1 0.591812
Kn22an28a2 Ln22a2 Ln28a2 0.591812
Kn22an28a3 Ln22a3 Ln28a3 0.591812
Kn22an28a4 Ln22a4 Ln28a4 0.591812
Kn22an28a5 Ln22a5 Ln28a5 0.591812
Kn22an28a6 Ln22a6 Ln28a6 0.591812
Kn22an28a7 Ln22a7 Ln28a7 0.591812
Kn22an28a8 Ln22a8 Ln28a8 0.591812
Kn22an28a9 Ln22a9 Ln28a9 0.591812
Kn22an28a10 Ln22a10 Ln28a10 0.591812
Kn22an28a11 Ln22a11 Ln28a11 0.591812
Kn22an28a12 Ln22a12 Ln28a12 0.591812
Kn22an28a13 Ln22a13 Ln28a13 0.591812
Kn22an28a14 Ln22a14 Ln28a14 0.591812
Kn22an28a15 Ln22a15 Ln28a15 0.591812
Kn22an28a16 Ln22a16 Ln28a16 0.591812
Kn22an29a1 Ln22a1 Ln29a1 0.573237
Kn22an29a2 Ln22a2 Ln29a2 0.573237
Kn22an29a3 Ln22a3 Ln29a3 0.573237
Kn22an29a4 Ln22a4 Ln29a4 0.573237
Kn22an29a5 Ln22a5 Ln29a5 0.573237
Kn22an29a6 Ln22a6 Ln29a6 0.573237
Kn22an29a7 Ln22a7 Ln29a7 0.573237
Kn22an29a8 Ln22a8 Ln29a8 0.573237
Kn22an29a9 Ln22a9 Ln29a9 0.573237
Kn22an29a10 Ln22a10 Ln29a10 0.573237
Kn22an29a11 Ln22a11 Ln29a11 0.573237
Kn22an29a12 Ln22a12 Ln29a12 0.573237
Kn22an29a13 Ln22a13 Ln29a13 0.573237
Kn22an29a14 Ln22a14 Ln29a14 0.573237
Kn22an29a15 Ln22a15 Ln29a15 0.573237
Kn22an29a16 Ln22a16 Ln29a16 0.573237
Kn22an30a1 Ln22a1 Ln30a1 0.557165
Kn22an30a2 Ln22a2 Ln30a2 0.557165
Kn22an30a3 Ln22a3 Ln30a3 0.557165
Kn22an30a4 Ln22a4 Ln30a4 0.557165
Kn22an30a5 Ln22a5 Ln30a5 0.557165
Kn22an30a6 Ln22a6 Ln30a6 0.557165
Kn22an30a7 Ln22a7 Ln30a7 0.557165
Kn22an30a8 Ln22a8 Ln30a8 0.557165
Kn22an30a9 Ln22a9 Ln30a9 0.557165
Kn22an30a10 Ln22a10 Ln30a10 0.557165
Kn22an30a11 Ln22a11 Ln30a11 0.557165
Kn22an30a12 Ln22a12 Ln30a12 0.557165
Kn22an30a13 Ln22a13 Ln30a13 0.557165
Kn22an30a14 Ln22a14 Ln30a14 0.557165
Kn22an30a15 Ln22a15 Ln30a15 0.557165
Kn22an30a16 Ln22a16 Ln30a16 0.557165
Kn22an31a1 Ln22a1 Ln31a1 0.542987
Kn22an31a2 Ln22a2 Ln31a2 0.542987
Kn22an31a3 Ln22a3 Ln31a3 0.542987
Kn22an31a4 Ln22a4 Ln31a4 0.542987
Kn22an31a5 Ln22a5 Ln31a5 0.542987
Kn22an31a6 Ln22a6 Ln31a6 0.542987
Kn22an31a7 Ln22a7 Ln31a7 0.542987
Kn22an31a8 Ln22a8 Ln31a8 0.542987
Kn22an31a9 Ln22a9 Ln31a9 0.542987
Kn22an31a10 Ln22a10 Ln31a10 0.542987
Kn22an31a11 Ln22a11 Ln31a11 0.542987
Kn22an31a12 Ln22a12 Ln31a12 0.542987
Kn22an31a13 Ln22a13 Ln31a13 0.542987
Kn22an31a14 Ln22a14 Ln31a14 0.542987
Kn22an31a15 Ln22a15 Ln31a15 0.542987
Kn22an31a16 Ln22a16 Ln31a16 0.542987
Kn22an32a1 Ln22a1 Ln32a1 0.529400
Kn22an32a2 Ln22a2 Ln32a2 0.529400
Kn22an32a3 Ln22a3 Ln32a3 0.529400
Kn22an32a4 Ln22a4 Ln32a4 0.529400
Kn22an32a5 Ln22a5 Ln32a5 0.529400
Kn22an32a6 Ln22a6 Ln32a6 0.529400
Kn22an32a7 Ln22a7 Ln32a7 0.529400
Kn22an32a8 Ln22a8 Ln32a8 0.529400
Kn22an32a9 Ln22a9 Ln32a9 0.529400
Kn22an32a10 Ln22a10 Ln32a10 0.529400
Kn22an32a11 Ln22a11 Ln32a11 0.529400
Kn22an32a12 Ln22a12 Ln32a12 0.529400
Kn22an32a13 Ln22a13 Ln32a13 0.529400
Kn22an32a14 Ln22a14 Ln32a14 0.529400
Kn22an32a15 Ln22a15 Ln32a15 0.529400
Kn22an32a16 Ln22a16 Ln32a16 0.529400
Kn22anva1 Ln22a1 Lnva1 0.516943
Kn22anva2 Ln22a2 Lnva2 0.516943
Kn22anva3 Ln22a3 Lnva3 0.516943
Kn22anva4 Ln22a4 Lnva4 0.516943
Kn22anva5 Ln22a5 Lnva5 0.516943
Kn22anva6 Ln22a6 Lnva6 0.516943
Kn22anva7 Ln22a7 Lnva7 0.516943
Kn22anva8 Ln22a8 Lnva8 0.516943
Kn22anva9 Ln22a9 Lnva9 0.516943
Kn22anva10 Ln22a10 Lnva10 0.516943
Kn22anva11 Ln22a11 Lnva11 0.516943
Kn22anva12 Ln22a12 Lnva12 0.516943
Kn22anva13 Ln22a13 Lnva13 0.516943
Kn22anva14 Ln22a14 Lnva14 0.516943
Kn22anva15 Ln22a15 Lnva15 0.516943
Kn22anva16 Ln22a16 Lnva16 0.516943
Kn23an24a1 Ln23a1 Ln24a1 0.805155
Kn23an24a2 Ln23a2 Ln24a2 0.805155
Kn23an24a3 Ln23a3 Ln24a3 0.805155
Kn23an24a4 Ln23a4 Ln24a4 0.805155
Kn23an24a5 Ln23a5 Ln24a5 0.805155
Kn23an24a6 Ln23a6 Ln24a6 0.805155
Kn23an24a7 Ln23a7 Ln24a7 0.805155
Kn23an24a8 Ln23a8 Ln24a8 0.805155
Kn23an24a9 Ln23a9 Ln24a9 0.805155
Kn23an24a10 Ln23a10 Ln24a10 0.805155
Kn23an24a11 Ln23a11 Ln24a11 0.805155
Kn23an24a12 Ln23a12 Ln24a12 0.805155
Kn23an24a13 Ln23a13 Ln24a13 0.805155
Kn23an24a14 Ln23a14 Ln24a14 0.805155
Kn23an24a15 Ln23a15 Ln24a15 0.805155
Kn23an24a16 Ln23a16 Ln24a16 0.805155
Kn23an25a1 Ln23a1 Ln25a1 0.723730
Kn23an25a2 Ln23a2 Ln25a2 0.723730
Kn23an25a3 Ln23a3 Ln25a3 0.723730
Kn23an25a4 Ln23a4 Ln25a4 0.723730
Kn23an25a5 Ln23a5 Ln25a5 0.723730
Kn23an25a6 Ln23a6 Ln25a6 0.723730
Kn23an25a7 Ln23a7 Ln25a7 0.723730
Kn23an25a8 Ln23a8 Ln25a8 0.723730
Kn23an25a9 Ln23a9 Ln25a9 0.723730
Kn23an25a10 Ln23a10 Ln25a10 0.723730
Kn23an25a11 Ln23a11 Ln25a11 0.723730
Kn23an25a12 Ln23a12 Ln25a12 0.723730
Kn23an25a13 Ln23a13 Ln25a13 0.723730
Kn23an25a14 Ln23a14 Ln25a14 0.723730
Kn23an25a15 Ln23a15 Ln25a15 0.723730
Kn23an25a16 Ln23a16 Ln25a16 0.723730
Kn23an26a1 Ln23a1 Ln26a1 0.675208
Kn23an26a2 Ln23a2 Ln26a2 0.675208
Kn23an26a3 Ln23a3 Ln26a3 0.675208
Kn23an26a4 Ln23a4 Ln26a4 0.675208
Kn23an26a5 Ln23a5 Ln26a5 0.675208
Kn23an26a6 Ln23a6 Ln26a6 0.675208
Kn23an26a7 Ln23a7 Ln26a7 0.675208
Kn23an26a8 Ln23a8 Ln26a8 0.675208
Kn23an26a9 Ln23a9 Ln26a9 0.675208
Kn23an26a10 Ln23a10 Ln26a10 0.675208
Kn23an26a11 Ln23a11 Ln26a11 0.675208
Kn23an26a12 Ln23a12 Ln26a12 0.675208
Kn23an26a13 Ln23a13 Ln26a13 0.675208
Kn23an26a14 Ln23a14 Ln26a14 0.675208
Kn23an26a15 Ln23a15 Ln26a15 0.675208
Kn23an26a16 Ln23a16 Ln26a16 0.675208
Kn23an27a1 Ln23a1 Ln27a1 0.640637
Kn23an27a2 Ln23a2 Ln27a2 0.640637
Kn23an27a3 Ln23a3 Ln27a3 0.640637
Kn23an27a4 Ln23a4 Ln27a4 0.640637
Kn23an27a5 Ln23a5 Ln27a5 0.640637
Kn23an27a6 Ln23a6 Ln27a6 0.640637
Kn23an27a7 Ln23a7 Ln27a7 0.640637
Kn23an27a8 Ln23a8 Ln27a8 0.640637
Kn23an27a9 Ln23a9 Ln27a9 0.640637
Kn23an27a10 Ln23a10 Ln27a10 0.640637
Kn23an27a11 Ln23a11 Ln27a11 0.640637
Kn23an27a12 Ln23a12 Ln27a12 0.640637
Kn23an27a13 Ln23a13 Ln27a13 0.640637
Kn23an27a14 Ln23a14 Ln27a14 0.640637
Kn23an27a15 Ln23a15 Ln27a15 0.640637
Kn23an27a16 Ln23a16 Ln27a16 0.640637
Kn23an28a1 Ln23a1 Ln28a1 0.613723
Kn23an28a2 Ln23a2 Ln28a2 0.613723
Kn23an28a3 Ln23a3 Ln28a3 0.613723
Kn23an28a4 Ln23a4 Ln28a4 0.613723
Kn23an28a5 Ln23a5 Ln28a5 0.613723
Kn23an28a6 Ln23a6 Ln28a6 0.613723
Kn23an28a7 Ln23a7 Ln28a7 0.613723
Kn23an28a8 Ln23a8 Ln28a8 0.613723
Kn23an28a9 Ln23a9 Ln28a9 0.613723
Kn23an28a10 Ln23a10 Ln28a10 0.613723
Kn23an28a11 Ln23a11 Ln28a11 0.613723
Kn23an28a12 Ln23a12 Ln28a12 0.613723
Kn23an28a13 Ln23a13 Ln28a13 0.613723
Kn23an28a14 Ln23a14 Ln28a14 0.613723
Kn23an28a15 Ln23a15 Ln28a15 0.613723
Kn23an28a16 Ln23a16 Ln28a16 0.613723
Kn23an29a1 Ln23a1 Ln29a1 0.591812
Kn23an29a2 Ln23a2 Ln29a2 0.591812
Kn23an29a3 Ln23a3 Ln29a3 0.591812
Kn23an29a4 Ln23a4 Ln29a4 0.591812
Kn23an29a5 Ln23a5 Ln29a5 0.591812
Kn23an29a6 Ln23a6 Ln29a6 0.591812
Kn23an29a7 Ln23a7 Ln29a7 0.591812
Kn23an29a8 Ln23a8 Ln29a8 0.591812
Kn23an29a9 Ln23a9 Ln29a9 0.591812
Kn23an29a10 Ln23a10 Ln29a10 0.591812
Kn23an29a11 Ln23a11 Ln29a11 0.591812
Kn23an29a12 Ln23a12 Ln29a12 0.591812
Kn23an29a13 Ln23a13 Ln29a13 0.591812
Kn23an29a14 Ln23a14 Ln29a14 0.591812
Kn23an29a15 Ln23a15 Ln29a15 0.591812
Kn23an29a16 Ln23a16 Ln29a16 0.591812
Kn23an30a1 Ln23a1 Ln30a1 0.573237
Kn23an30a2 Ln23a2 Ln30a2 0.573237
Kn23an30a3 Ln23a3 Ln30a3 0.573237
Kn23an30a4 Ln23a4 Ln30a4 0.573237
Kn23an30a5 Ln23a5 Ln30a5 0.573237
Kn23an30a6 Ln23a6 Ln30a6 0.573237
Kn23an30a7 Ln23a7 Ln30a7 0.573237
Kn23an30a8 Ln23a8 Ln30a8 0.573237
Kn23an30a9 Ln23a9 Ln30a9 0.573237
Kn23an30a10 Ln23a10 Ln30a10 0.573237
Kn23an30a11 Ln23a11 Ln30a11 0.573237
Kn23an30a12 Ln23a12 Ln30a12 0.573237
Kn23an30a13 Ln23a13 Ln30a13 0.573237
Kn23an30a14 Ln23a14 Ln30a14 0.573237
Kn23an30a15 Ln23a15 Ln30a15 0.573237
Kn23an30a16 Ln23a16 Ln30a16 0.573237
Kn23an31a1 Ln23a1 Ln31a1 0.557165
Kn23an31a2 Ln23a2 Ln31a2 0.557165
Kn23an31a3 Ln23a3 Ln31a3 0.557165
Kn23an31a4 Ln23a4 Ln31a4 0.557165
Kn23an31a5 Ln23a5 Ln31a5 0.557165
Kn23an31a6 Ln23a6 Ln31a6 0.557165
Kn23an31a7 Ln23a7 Ln31a7 0.557165
Kn23an31a8 Ln23a8 Ln31a8 0.557165
Kn23an31a9 Ln23a9 Ln31a9 0.557165
Kn23an31a10 Ln23a10 Ln31a10 0.557165
Kn23an31a11 Ln23a11 Ln31a11 0.557165
Kn23an31a12 Ln23a12 Ln31a12 0.557165
Kn23an31a13 Ln23a13 Ln31a13 0.557165
Kn23an31a14 Ln23a14 Ln31a14 0.557165
Kn23an31a15 Ln23a15 Ln31a15 0.557165
Kn23an31a16 Ln23a16 Ln31a16 0.557165
Kn23an32a1 Ln23a1 Ln32a1 0.542987
Kn23an32a2 Ln23a2 Ln32a2 0.542987
Kn23an32a3 Ln23a3 Ln32a3 0.542987
Kn23an32a4 Ln23a4 Ln32a4 0.542987
Kn23an32a5 Ln23a5 Ln32a5 0.542987
Kn23an32a6 Ln23a6 Ln32a6 0.542987
Kn23an32a7 Ln23a7 Ln32a7 0.542987
Kn23an32a8 Ln23a8 Ln32a8 0.542987
Kn23an32a9 Ln23a9 Ln32a9 0.542987
Kn23an32a10 Ln23a10 Ln32a10 0.542987
Kn23an32a11 Ln23a11 Ln32a11 0.542987
Kn23an32a12 Ln23a12 Ln32a12 0.542987
Kn23an32a13 Ln23a13 Ln32a13 0.542987
Kn23an32a14 Ln23a14 Ln32a14 0.542987
Kn23an32a15 Ln23a15 Ln32a15 0.542987
Kn23an32a16 Ln23a16 Ln32a16 0.542987
Kn23anva1 Ln23a1 Lnva1 0.529400
Kn23anva2 Ln23a2 Lnva2 0.529400
Kn23anva3 Ln23a3 Lnva3 0.529400
Kn23anva4 Ln23a4 Lnva4 0.529400
Kn23anva5 Ln23a5 Lnva5 0.529400
Kn23anva6 Ln23a6 Lnva6 0.529400
Kn23anva7 Ln23a7 Lnva7 0.529400
Kn23anva8 Ln23a8 Lnva8 0.529400
Kn23anva9 Ln23a9 Lnva9 0.529400
Kn23anva10 Ln23a10 Lnva10 0.529400
Kn23anva11 Ln23a11 Lnva11 0.529400
Kn23anva12 Ln23a12 Lnva12 0.529400
Kn23anva13 Ln23a13 Lnva13 0.529400
Kn23anva14 Ln23a14 Lnva14 0.529400
Kn23anva15 Ln23a15 Lnva15 0.529400
Kn23anva16 Ln23a16 Lnva16 0.529400
Kn24an25a1 Ln24a1 Ln25a1 0.805155
Kn24an25a2 Ln24a2 Ln25a2 0.805155
Kn24an25a3 Ln24a3 Ln25a3 0.805155
Kn24an25a4 Ln24a4 Ln25a4 0.805155
Kn24an25a5 Ln24a5 Ln25a5 0.805155
Kn24an25a6 Ln24a6 Ln25a6 0.805155
Kn24an25a7 Ln24a7 Ln25a7 0.805155
Kn24an25a8 Ln24a8 Ln25a8 0.805155
Kn24an25a9 Ln24a9 Ln25a9 0.805155
Kn24an25a10 Ln24a10 Ln25a10 0.805155
Kn24an25a11 Ln24a11 Ln25a11 0.805155
Kn24an25a12 Ln24a12 Ln25a12 0.805155
Kn24an25a13 Ln24a13 Ln25a13 0.805155
Kn24an25a14 Ln24a14 Ln25a14 0.805155
Kn24an25a15 Ln24a15 Ln25a15 0.805155
Kn24an25a16 Ln24a16 Ln25a16 0.805155
Kn24an26a1 Ln24a1 Ln26a1 0.723730
Kn24an26a2 Ln24a2 Ln26a2 0.723730
Kn24an26a3 Ln24a3 Ln26a3 0.723730
Kn24an26a4 Ln24a4 Ln26a4 0.723730
Kn24an26a5 Ln24a5 Ln26a5 0.723730
Kn24an26a6 Ln24a6 Ln26a6 0.723730
Kn24an26a7 Ln24a7 Ln26a7 0.723730
Kn24an26a8 Ln24a8 Ln26a8 0.723730
Kn24an26a9 Ln24a9 Ln26a9 0.723730
Kn24an26a10 Ln24a10 Ln26a10 0.723730
Kn24an26a11 Ln24a11 Ln26a11 0.723730
Kn24an26a12 Ln24a12 Ln26a12 0.723730
Kn24an26a13 Ln24a13 Ln26a13 0.723730
Kn24an26a14 Ln24a14 Ln26a14 0.723730
Kn24an26a15 Ln24a15 Ln26a15 0.723730
Kn24an26a16 Ln24a16 Ln26a16 0.723730
Kn24an27a1 Ln24a1 Ln27a1 0.675208
Kn24an27a2 Ln24a2 Ln27a2 0.675208
Kn24an27a3 Ln24a3 Ln27a3 0.675208
Kn24an27a4 Ln24a4 Ln27a4 0.675208
Kn24an27a5 Ln24a5 Ln27a5 0.675208
Kn24an27a6 Ln24a6 Ln27a6 0.675208
Kn24an27a7 Ln24a7 Ln27a7 0.675208
Kn24an27a8 Ln24a8 Ln27a8 0.675208
Kn24an27a9 Ln24a9 Ln27a9 0.675208
Kn24an27a10 Ln24a10 Ln27a10 0.675208
Kn24an27a11 Ln24a11 Ln27a11 0.675208
Kn24an27a12 Ln24a12 Ln27a12 0.675208
Kn24an27a13 Ln24a13 Ln27a13 0.675208
Kn24an27a14 Ln24a14 Ln27a14 0.675208
Kn24an27a15 Ln24a15 Ln27a15 0.675208
Kn24an27a16 Ln24a16 Ln27a16 0.675208
Kn24an28a1 Ln24a1 Ln28a1 0.640637
Kn24an28a2 Ln24a2 Ln28a2 0.640637
Kn24an28a3 Ln24a3 Ln28a3 0.640637
Kn24an28a4 Ln24a4 Ln28a4 0.640637
Kn24an28a5 Ln24a5 Ln28a5 0.640637
Kn24an28a6 Ln24a6 Ln28a6 0.640637
Kn24an28a7 Ln24a7 Ln28a7 0.640637
Kn24an28a8 Ln24a8 Ln28a8 0.640637
Kn24an28a9 Ln24a9 Ln28a9 0.640637
Kn24an28a10 Ln24a10 Ln28a10 0.640637
Kn24an28a11 Ln24a11 Ln28a11 0.640637
Kn24an28a12 Ln24a12 Ln28a12 0.640637
Kn24an28a13 Ln24a13 Ln28a13 0.640637
Kn24an28a14 Ln24a14 Ln28a14 0.640637
Kn24an28a15 Ln24a15 Ln28a15 0.640637
Kn24an28a16 Ln24a16 Ln28a16 0.640637
Kn24an29a1 Ln24a1 Ln29a1 0.613723
Kn24an29a2 Ln24a2 Ln29a2 0.613723
Kn24an29a3 Ln24a3 Ln29a3 0.613723
Kn24an29a4 Ln24a4 Ln29a4 0.613723
Kn24an29a5 Ln24a5 Ln29a5 0.613723
Kn24an29a6 Ln24a6 Ln29a6 0.613723
Kn24an29a7 Ln24a7 Ln29a7 0.613723
Kn24an29a8 Ln24a8 Ln29a8 0.613723
Kn24an29a9 Ln24a9 Ln29a9 0.613723
Kn24an29a10 Ln24a10 Ln29a10 0.613723
Kn24an29a11 Ln24a11 Ln29a11 0.613723
Kn24an29a12 Ln24a12 Ln29a12 0.613723
Kn24an29a13 Ln24a13 Ln29a13 0.613723
Kn24an29a14 Ln24a14 Ln29a14 0.613723
Kn24an29a15 Ln24a15 Ln29a15 0.613723
Kn24an29a16 Ln24a16 Ln29a16 0.613723
Kn24an30a1 Ln24a1 Ln30a1 0.591812
Kn24an30a2 Ln24a2 Ln30a2 0.591812
Kn24an30a3 Ln24a3 Ln30a3 0.591812
Kn24an30a4 Ln24a4 Ln30a4 0.591812
Kn24an30a5 Ln24a5 Ln30a5 0.591812
Kn24an30a6 Ln24a6 Ln30a6 0.591812
Kn24an30a7 Ln24a7 Ln30a7 0.591812
Kn24an30a8 Ln24a8 Ln30a8 0.591812
Kn24an30a9 Ln24a9 Ln30a9 0.591812
Kn24an30a10 Ln24a10 Ln30a10 0.591812
Kn24an30a11 Ln24a11 Ln30a11 0.591812
Kn24an30a12 Ln24a12 Ln30a12 0.591812
Kn24an30a13 Ln24a13 Ln30a13 0.591812
Kn24an30a14 Ln24a14 Ln30a14 0.591812
Kn24an30a15 Ln24a15 Ln30a15 0.591812
Kn24an30a16 Ln24a16 Ln30a16 0.591812
Kn24an31a1 Ln24a1 Ln31a1 0.573237
Kn24an31a2 Ln24a2 Ln31a2 0.573237
Kn24an31a3 Ln24a3 Ln31a3 0.573237
Kn24an31a4 Ln24a4 Ln31a4 0.573237
Kn24an31a5 Ln24a5 Ln31a5 0.573237
Kn24an31a6 Ln24a6 Ln31a6 0.573237
Kn24an31a7 Ln24a7 Ln31a7 0.573237
Kn24an31a8 Ln24a8 Ln31a8 0.573237
Kn24an31a9 Ln24a9 Ln31a9 0.573237
Kn24an31a10 Ln24a10 Ln31a10 0.573237
Kn24an31a11 Ln24a11 Ln31a11 0.573237
Kn24an31a12 Ln24a12 Ln31a12 0.573237
Kn24an31a13 Ln24a13 Ln31a13 0.573237
Kn24an31a14 Ln24a14 Ln31a14 0.573237
Kn24an31a15 Ln24a15 Ln31a15 0.573237
Kn24an31a16 Ln24a16 Ln31a16 0.573237
Kn24an32a1 Ln24a1 Ln32a1 0.557165
Kn24an32a2 Ln24a2 Ln32a2 0.557165
Kn24an32a3 Ln24a3 Ln32a3 0.557165
Kn24an32a4 Ln24a4 Ln32a4 0.557165
Kn24an32a5 Ln24a5 Ln32a5 0.557165
Kn24an32a6 Ln24a6 Ln32a6 0.557165
Kn24an32a7 Ln24a7 Ln32a7 0.557165
Kn24an32a8 Ln24a8 Ln32a8 0.557165
Kn24an32a9 Ln24a9 Ln32a9 0.557165
Kn24an32a10 Ln24a10 Ln32a10 0.557165
Kn24an32a11 Ln24a11 Ln32a11 0.557165
Kn24an32a12 Ln24a12 Ln32a12 0.557165
Kn24an32a13 Ln24a13 Ln32a13 0.557165
Kn24an32a14 Ln24a14 Ln32a14 0.557165
Kn24an32a15 Ln24a15 Ln32a15 0.557165
Kn24an32a16 Ln24a16 Ln32a16 0.557165
Kn24anva1 Ln24a1 Lnva1 0.542987
Kn24anva2 Ln24a2 Lnva2 0.542987
Kn24anva3 Ln24a3 Lnva3 0.542987
Kn24anva4 Ln24a4 Lnva4 0.542987
Kn24anva5 Ln24a5 Lnva5 0.542987
Kn24anva6 Ln24a6 Lnva6 0.542987
Kn24anva7 Ln24a7 Lnva7 0.542987
Kn24anva8 Ln24a8 Lnva8 0.542987
Kn24anva9 Ln24a9 Lnva9 0.542987
Kn24anva10 Ln24a10 Lnva10 0.542987
Kn24anva11 Ln24a11 Lnva11 0.542987
Kn24anva12 Ln24a12 Lnva12 0.542987
Kn24anva13 Ln24a13 Lnva13 0.542987
Kn24anva14 Ln24a14 Lnva14 0.542987
Kn24anva15 Ln24a15 Lnva15 0.542987
Kn24anva16 Ln24a16 Lnva16 0.542987
Kn25an26a1 Ln25a1 Ln26a1 0.805155
Kn25an26a2 Ln25a2 Ln26a2 0.805155
Kn25an26a3 Ln25a3 Ln26a3 0.805155
Kn25an26a4 Ln25a4 Ln26a4 0.805155
Kn25an26a5 Ln25a5 Ln26a5 0.805155
Kn25an26a6 Ln25a6 Ln26a6 0.805155
Kn25an26a7 Ln25a7 Ln26a7 0.805155
Kn25an26a8 Ln25a8 Ln26a8 0.805155
Kn25an26a9 Ln25a9 Ln26a9 0.805155
Kn25an26a10 Ln25a10 Ln26a10 0.805155
Kn25an26a11 Ln25a11 Ln26a11 0.805155
Kn25an26a12 Ln25a12 Ln26a12 0.805155
Kn25an26a13 Ln25a13 Ln26a13 0.805155
Kn25an26a14 Ln25a14 Ln26a14 0.805155
Kn25an26a15 Ln25a15 Ln26a15 0.805155
Kn25an26a16 Ln25a16 Ln26a16 0.805155
Kn25an27a1 Ln25a1 Ln27a1 0.723730
Kn25an27a2 Ln25a2 Ln27a2 0.723730
Kn25an27a3 Ln25a3 Ln27a3 0.723730
Kn25an27a4 Ln25a4 Ln27a4 0.723730
Kn25an27a5 Ln25a5 Ln27a5 0.723730
Kn25an27a6 Ln25a6 Ln27a6 0.723730
Kn25an27a7 Ln25a7 Ln27a7 0.723730
Kn25an27a8 Ln25a8 Ln27a8 0.723730
Kn25an27a9 Ln25a9 Ln27a9 0.723730
Kn25an27a10 Ln25a10 Ln27a10 0.723730
Kn25an27a11 Ln25a11 Ln27a11 0.723730
Kn25an27a12 Ln25a12 Ln27a12 0.723730
Kn25an27a13 Ln25a13 Ln27a13 0.723730
Kn25an27a14 Ln25a14 Ln27a14 0.723730
Kn25an27a15 Ln25a15 Ln27a15 0.723730
Kn25an27a16 Ln25a16 Ln27a16 0.723730
Kn25an28a1 Ln25a1 Ln28a1 0.675208
Kn25an28a2 Ln25a2 Ln28a2 0.675208
Kn25an28a3 Ln25a3 Ln28a3 0.675208
Kn25an28a4 Ln25a4 Ln28a4 0.675208
Kn25an28a5 Ln25a5 Ln28a5 0.675208
Kn25an28a6 Ln25a6 Ln28a6 0.675208
Kn25an28a7 Ln25a7 Ln28a7 0.675208
Kn25an28a8 Ln25a8 Ln28a8 0.675208
Kn25an28a9 Ln25a9 Ln28a9 0.675208
Kn25an28a10 Ln25a10 Ln28a10 0.675208
Kn25an28a11 Ln25a11 Ln28a11 0.675208
Kn25an28a12 Ln25a12 Ln28a12 0.675208
Kn25an28a13 Ln25a13 Ln28a13 0.675208
Kn25an28a14 Ln25a14 Ln28a14 0.675208
Kn25an28a15 Ln25a15 Ln28a15 0.675208
Kn25an28a16 Ln25a16 Ln28a16 0.675208
Kn25an29a1 Ln25a1 Ln29a1 0.640637
Kn25an29a2 Ln25a2 Ln29a2 0.640637
Kn25an29a3 Ln25a3 Ln29a3 0.640637
Kn25an29a4 Ln25a4 Ln29a4 0.640637
Kn25an29a5 Ln25a5 Ln29a5 0.640637
Kn25an29a6 Ln25a6 Ln29a6 0.640637
Kn25an29a7 Ln25a7 Ln29a7 0.640637
Kn25an29a8 Ln25a8 Ln29a8 0.640637
Kn25an29a9 Ln25a9 Ln29a9 0.640637
Kn25an29a10 Ln25a10 Ln29a10 0.640637
Kn25an29a11 Ln25a11 Ln29a11 0.640637
Kn25an29a12 Ln25a12 Ln29a12 0.640637
Kn25an29a13 Ln25a13 Ln29a13 0.640637
Kn25an29a14 Ln25a14 Ln29a14 0.640637
Kn25an29a15 Ln25a15 Ln29a15 0.640637
Kn25an29a16 Ln25a16 Ln29a16 0.640637
Kn25an30a1 Ln25a1 Ln30a1 0.613723
Kn25an30a2 Ln25a2 Ln30a2 0.613723
Kn25an30a3 Ln25a3 Ln30a3 0.613723
Kn25an30a4 Ln25a4 Ln30a4 0.613723
Kn25an30a5 Ln25a5 Ln30a5 0.613723
Kn25an30a6 Ln25a6 Ln30a6 0.613723
Kn25an30a7 Ln25a7 Ln30a7 0.613723
Kn25an30a8 Ln25a8 Ln30a8 0.613723
Kn25an30a9 Ln25a9 Ln30a9 0.613723
Kn25an30a10 Ln25a10 Ln30a10 0.613723
Kn25an30a11 Ln25a11 Ln30a11 0.613723
Kn25an30a12 Ln25a12 Ln30a12 0.613723
Kn25an30a13 Ln25a13 Ln30a13 0.613723
Kn25an30a14 Ln25a14 Ln30a14 0.613723
Kn25an30a15 Ln25a15 Ln30a15 0.613723
Kn25an30a16 Ln25a16 Ln30a16 0.613723
Kn25an31a1 Ln25a1 Ln31a1 0.591812
Kn25an31a2 Ln25a2 Ln31a2 0.591812
Kn25an31a3 Ln25a3 Ln31a3 0.591812
Kn25an31a4 Ln25a4 Ln31a4 0.591812
Kn25an31a5 Ln25a5 Ln31a5 0.591812
Kn25an31a6 Ln25a6 Ln31a6 0.591812
Kn25an31a7 Ln25a7 Ln31a7 0.591812
Kn25an31a8 Ln25a8 Ln31a8 0.591812
Kn25an31a9 Ln25a9 Ln31a9 0.591812
Kn25an31a10 Ln25a10 Ln31a10 0.591812
Kn25an31a11 Ln25a11 Ln31a11 0.591812
Kn25an31a12 Ln25a12 Ln31a12 0.591812
Kn25an31a13 Ln25a13 Ln31a13 0.591812
Kn25an31a14 Ln25a14 Ln31a14 0.591812
Kn25an31a15 Ln25a15 Ln31a15 0.591812
Kn25an31a16 Ln25a16 Ln31a16 0.591812
Kn25an32a1 Ln25a1 Ln32a1 0.573237
Kn25an32a2 Ln25a2 Ln32a2 0.573237
Kn25an32a3 Ln25a3 Ln32a3 0.573237
Kn25an32a4 Ln25a4 Ln32a4 0.573237
Kn25an32a5 Ln25a5 Ln32a5 0.573237
Kn25an32a6 Ln25a6 Ln32a6 0.573237
Kn25an32a7 Ln25a7 Ln32a7 0.573237
Kn25an32a8 Ln25a8 Ln32a8 0.573237
Kn25an32a9 Ln25a9 Ln32a9 0.573237
Kn25an32a10 Ln25a10 Ln32a10 0.573237
Kn25an32a11 Ln25a11 Ln32a11 0.573237
Kn25an32a12 Ln25a12 Ln32a12 0.573237
Kn25an32a13 Ln25a13 Ln32a13 0.573237
Kn25an32a14 Ln25a14 Ln32a14 0.573237
Kn25an32a15 Ln25a15 Ln32a15 0.573237
Kn25an32a16 Ln25a16 Ln32a16 0.573237
Kn25anva1 Ln25a1 Lnva1 0.557165
Kn25anva2 Ln25a2 Lnva2 0.557165
Kn25anva3 Ln25a3 Lnva3 0.557165
Kn25anva4 Ln25a4 Lnva4 0.557165
Kn25anva5 Ln25a5 Lnva5 0.557165
Kn25anva6 Ln25a6 Lnva6 0.557165
Kn25anva7 Ln25a7 Lnva7 0.557165
Kn25anva8 Ln25a8 Lnva8 0.557165
Kn25anva9 Ln25a9 Lnva9 0.557165
Kn25anva10 Ln25a10 Lnva10 0.557165
Kn25anva11 Ln25a11 Lnva11 0.557165
Kn25anva12 Ln25a12 Lnva12 0.557165
Kn25anva13 Ln25a13 Lnva13 0.557165
Kn25anva14 Ln25a14 Lnva14 0.557165
Kn25anva15 Ln25a15 Lnva15 0.557165
Kn25anva16 Ln25a16 Lnva16 0.557165
Kn26an27a1 Ln26a1 Ln27a1 0.805155
Kn26an27a2 Ln26a2 Ln27a2 0.805155
Kn26an27a3 Ln26a3 Ln27a3 0.805155
Kn26an27a4 Ln26a4 Ln27a4 0.805155
Kn26an27a5 Ln26a5 Ln27a5 0.805155
Kn26an27a6 Ln26a6 Ln27a6 0.805155
Kn26an27a7 Ln26a7 Ln27a7 0.805155
Kn26an27a8 Ln26a8 Ln27a8 0.805155
Kn26an27a9 Ln26a9 Ln27a9 0.805155
Kn26an27a10 Ln26a10 Ln27a10 0.805155
Kn26an27a11 Ln26a11 Ln27a11 0.805155
Kn26an27a12 Ln26a12 Ln27a12 0.805155
Kn26an27a13 Ln26a13 Ln27a13 0.805155
Kn26an27a14 Ln26a14 Ln27a14 0.805155
Kn26an27a15 Ln26a15 Ln27a15 0.805155
Kn26an27a16 Ln26a16 Ln27a16 0.805155
Kn26an28a1 Ln26a1 Ln28a1 0.723730
Kn26an28a2 Ln26a2 Ln28a2 0.723730
Kn26an28a3 Ln26a3 Ln28a3 0.723730
Kn26an28a4 Ln26a4 Ln28a4 0.723730
Kn26an28a5 Ln26a5 Ln28a5 0.723730
Kn26an28a6 Ln26a6 Ln28a6 0.723730
Kn26an28a7 Ln26a7 Ln28a7 0.723730
Kn26an28a8 Ln26a8 Ln28a8 0.723730
Kn26an28a9 Ln26a9 Ln28a9 0.723730
Kn26an28a10 Ln26a10 Ln28a10 0.723730
Kn26an28a11 Ln26a11 Ln28a11 0.723730
Kn26an28a12 Ln26a12 Ln28a12 0.723730
Kn26an28a13 Ln26a13 Ln28a13 0.723730
Kn26an28a14 Ln26a14 Ln28a14 0.723730
Kn26an28a15 Ln26a15 Ln28a15 0.723730
Kn26an28a16 Ln26a16 Ln28a16 0.723730
Kn26an29a1 Ln26a1 Ln29a1 0.675208
Kn26an29a2 Ln26a2 Ln29a2 0.675208
Kn26an29a3 Ln26a3 Ln29a3 0.675208
Kn26an29a4 Ln26a4 Ln29a4 0.675208
Kn26an29a5 Ln26a5 Ln29a5 0.675208
Kn26an29a6 Ln26a6 Ln29a6 0.675208
Kn26an29a7 Ln26a7 Ln29a7 0.675208
Kn26an29a8 Ln26a8 Ln29a8 0.675208
Kn26an29a9 Ln26a9 Ln29a9 0.675208
Kn26an29a10 Ln26a10 Ln29a10 0.675208
Kn26an29a11 Ln26a11 Ln29a11 0.675208
Kn26an29a12 Ln26a12 Ln29a12 0.675208
Kn26an29a13 Ln26a13 Ln29a13 0.675208
Kn26an29a14 Ln26a14 Ln29a14 0.675208
Kn26an29a15 Ln26a15 Ln29a15 0.675208
Kn26an29a16 Ln26a16 Ln29a16 0.675208
Kn26an30a1 Ln26a1 Ln30a1 0.640637
Kn26an30a2 Ln26a2 Ln30a2 0.640637
Kn26an30a3 Ln26a3 Ln30a3 0.640637
Kn26an30a4 Ln26a4 Ln30a4 0.640637
Kn26an30a5 Ln26a5 Ln30a5 0.640637
Kn26an30a6 Ln26a6 Ln30a6 0.640637
Kn26an30a7 Ln26a7 Ln30a7 0.640637
Kn26an30a8 Ln26a8 Ln30a8 0.640637
Kn26an30a9 Ln26a9 Ln30a9 0.640637
Kn26an30a10 Ln26a10 Ln30a10 0.640637
Kn26an30a11 Ln26a11 Ln30a11 0.640637
Kn26an30a12 Ln26a12 Ln30a12 0.640637
Kn26an30a13 Ln26a13 Ln30a13 0.640637
Kn26an30a14 Ln26a14 Ln30a14 0.640637
Kn26an30a15 Ln26a15 Ln30a15 0.640637
Kn26an30a16 Ln26a16 Ln30a16 0.640637
Kn26an31a1 Ln26a1 Ln31a1 0.613723
Kn26an31a2 Ln26a2 Ln31a2 0.613723
Kn26an31a3 Ln26a3 Ln31a3 0.613723
Kn26an31a4 Ln26a4 Ln31a4 0.613723
Kn26an31a5 Ln26a5 Ln31a5 0.613723
Kn26an31a6 Ln26a6 Ln31a6 0.613723
Kn26an31a7 Ln26a7 Ln31a7 0.613723
Kn26an31a8 Ln26a8 Ln31a8 0.613723
Kn26an31a9 Ln26a9 Ln31a9 0.613723
Kn26an31a10 Ln26a10 Ln31a10 0.613723
Kn26an31a11 Ln26a11 Ln31a11 0.613723
Kn26an31a12 Ln26a12 Ln31a12 0.613723
Kn26an31a13 Ln26a13 Ln31a13 0.613723
Kn26an31a14 Ln26a14 Ln31a14 0.613723
Kn26an31a15 Ln26a15 Ln31a15 0.613723
Kn26an31a16 Ln26a16 Ln31a16 0.613723
Kn26an32a1 Ln26a1 Ln32a1 0.591812
Kn26an32a2 Ln26a2 Ln32a2 0.591812
Kn26an32a3 Ln26a3 Ln32a3 0.591812
Kn26an32a4 Ln26a4 Ln32a4 0.591812
Kn26an32a5 Ln26a5 Ln32a5 0.591812
Kn26an32a6 Ln26a6 Ln32a6 0.591812
Kn26an32a7 Ln26a7 Ln32a7 0.591812
Kn26an32a8 Ln26a8 Ln32a8 0.591812
Kn26an32a9 Ln26a9 Ln32a9 0.591812
Kn26an32a10 Ln26a10 Ln32a10 0.591812
Kn26an32a11 Ln26a11 Ln32a11 0.591812
Kn26an32a12 Ln26a12 Ln32a12 0.591812
Kn26an32a13 Ln26a13 Ln32a13 0.591812
Kn26an32a14 Ln26a14 Ln32a14 0.591812
Kn26an32a15 Ln26a15 Ln32a15 0.591812
Kn26an32a16 Ln26a16 Ln32a16 0.591812
Kn26anva1 Ln26a1 Lnva1 0.573237
Kn26anva2 Ln26a2 Lnva2 0.573237
Kn26anva3 Ln26a3 Lnva3 0.573237
Kn26anva4 Ln26a4 Lnva4 0.573237
Kn26anva5 Ln26a5 Lnva5 0.573237
Kn26anva6 Ln26a6 Lnva6 0.573237
Kn26anva7 Ln26a7 Lnva7 0.573237
Kn26anva8 Ln26a8 Lnva8 0.573237
Kn26anva9 Ln26a9 Lnva9 0.573237
Kn26anva10 Ln26a10 Lnva10 0.573237
Kn26anva11 Ln26a11 Lnva11 0.573237
Kn26anva12 Ln26a12 Lnva12 0.573237
Kn26anva13 Ln26a13 Lnva13 0.573237
Kn26anva14 Ln26a14 Lnva14 0.573237
Kn26anva15 Ln26a15 Lnva15 0.573237
Kn26anva16 Ln26a16 Lnva16 0.573237
Kn27an28a1 Ln27a1 Ln28a1 0.805155
Kn27an28a2 Ln27a2 Ln28a2 0.805155
Kn27an28a3 Ln27a3 Ln28a3 0.805155
Kn27an28a4 Ln27a4 Ln28a4 0.805155
Kn27an28a5 Ln27a5 Ln28a5 0.805155
Kn27an28a6 Ln27a6 Ln28a6 0.805155
Kn27an28a7 Ln27a7 Ln28a7 0.805155
Kn27an28a8 Ln27a8 Ln28a8 0.805155
Kn27an28a9 Ln27a9 Ln28a9 0.805155
Kn27an28a10 Ln27a10 Ln28a10 0.805155
Kn27an28a11 Ln27a11 Ln28a11 0.805155
Kn27an28a12 Ln27a12 Ln28a12 0.805155
Kn27an28a13 Ln27a13 Ln28a13 0.805155
Kn27an28a14 Ln27a14 Ln28a14 0.805155
Kn27an28a15 Ln27a15 Ln28a15 0.805155
Kn27an28a16 Ln27a16 Ln28a16 0.805155
Kn27an29a1 Ln27a1 Ln29a1 0.723730
Kn27an29a2 Ln27a2 Ln29a2 0.723730
Kn27an29a3 Ln27a3 Ln29a3 0.723730
Kn27an29a4 Ln27a4 Ln29a4 0.723730
Kn27an29a5 Ln27a5 Ln29a5 0.723730
Kn27an29a6 Ln27a6 Ln29a6 0.723730
Kn27an29a7 Ln27a7 Ln29a7 0.723730
Kn27an29a8 Ln27a8 Ln29a8 0.723730
Kn27an29a9 Ln27a9 Ln29a9 0.723730
Kn27an29a10 Ln27a10 Ln29a10 0.723730
Kn27an29a11 Ln27a11 Ln29a11 0.723730
Kn27an29a12 Ln27a12 Ln29a12 0.723730
Kn27an29a13 Ln27a13 Ln29a13 0.723730
Kn27an29a14 Ln27a14 Ln29a14 0.723730
Kn27an29a15 Ln27a15 Ln29a15 0.723730
Kn27an29a16 Ln27a16 Ln29a16 0.723730
Kn27an30a1 Ln27a1 Ln30a1 0.675208
Kn27an30a2 Ln27a2 Ln30a2 0.675208
Kn27an30a3 Ln27a3 Ln30a3 0.675208
Kn27an30a4 Ln27a4 Ln30a4 0.675208
Kn27an30a5 Ln27a5 Ln30a5 0.675208
Kn27an30a6 Ln27a6 Ln30a6 0.675208
Kn27an30a7 Ln27a7 Ln30a7 0.675208
Kn27an30a8 Ln27a8 Ln30a8 0.675208
Kn27an30a9 Ln27a9 Ln30a9 0.675208
Kn27an30a10 Ln27a10 Ln30a10 0.675208
Kn27an30a11 Ln27a11 Ln30a11 0.675208
Kn27an30a12 Ln27a12 Ln30a12 0.675208
Kn27an30a13 Ln27a13 Ln30a13 0.675208
Kn27an30a14 Ln27a14 Ln30a14 0.675208
Kn27an30a15 Ln27a15 Ln30a15 0.675208
Kn27an30a16 Ln27a16 Ln30a16 0.675208
Kn27an31a1 Ln27a1 Ln31a1 0.640637
Kn27an31a2 Ln27a2 Ln31a2 0.640637
Kn27an31a3 Ln27a3 Ln31a3 0.640637
Kn27an31a4 Ln27a4 Ln31a4 0.640637
Kn27an31a5 Ln27a5 Ln31a5 0.640637
Kn27an31a6 Ln27a6 Ln31a6 0.640637
Kn27an31a7 Ln27a7 Ln31a7 0.640637
Kn27an31a8 Ln27a8 Ln31a8 0.640637
Kn27an31a9 Ln27a9 Ln31a9 0.640637
Kn27an31a10 Ln27a10 Ln31a10 0.640637
Kn27an31a11 Ln27a11 Ln31a11 0.640637
Kn27an31a12 Ln27a12 Ln31a12 0.640637
Kn27an31a13 Ln27a13 Ln31a13 0.640637
Kn27an31a14 Ln27a14 Ln31a14 0.640637
Kn27an31a15 Ln27a15 Ln31a15 0.640637
Kn27an31a16 Ln27a16 Ln31a16 0.640637
Kn27an32a1 Ln27a1 Ln32a1 0.613723
Kn27an32a2 Ln27a2 Ln32a2 0.613723
Kn27an32a3 Ln27a3 Ln32a3 0.613723
Kn27an32a4 Ln27a4 Ln32a4 0.613723
Kn27an32a5 Ln27a5 Ln32a5 0.613723
Kn27an32a6 Ln27a6 Ln32a6 0.613723
Kn27an32a7 Ln27a7 Ln32a7 0.613723
Kn27an32a8 Ln27a8 Ln32a8 0.613723
Kn27an32a9 Ln27a9 Ln32a9 0.613723
Kn27an32a10 Ln27a10 Ln32a10 0.613723
Kn27an32a11 Ln27a11 Ln32a11 0.613723
Kn27an32a12 Ln27a12 Ln32a12 0.613723
Kn27an32a13 Ln27a13 Ln32a13 0.613723
Kn27an32a14 Ln27a14 Ln32a14 0.613723
Kn27an32a15 Ln27a15 Ln32a15 0.613723
Kn27an32a16 Ln27a16 Ln32a16 0.613723
Kn27anva1 Ln27a1 Lnva1 0.591812
Kn27anva2 Ln27a2 Lnva2 0.591812
Kn27anva3 Ln27a3 Lnva3 0.591812
Kn27anva4 Ln27a4 Lnva4 0.591812
Kn27anva5 Ln27a5 Lnva5 0.591812
Kn27anva6 Ln27a6 Lnva6 0.591812
Kn27anva7 Ln27a7 Lnva7 0.591812
Kn27anva8 Ln27a8 Lnva8 0.591812
Kn27anva9 Ln27a9 Lnva9 0.591812
Kn27anva10 Ln27a10 Lnva10 0.591812
Kn27anva11 Ln27a11 Lnva11 0.591812
Kn27anva12 Ln27a12 Lnva12 0.591812
Kn27anva13 Ln27a13 Lnva13 0.591812
Kn27anva14 Ln27a14 Lnva14 0.591812
Kn27anva15 Ln27a15 Lnva15 0.591812
Kn27anva16 Ln27a16 Lnva16 0.591812
Kn28an29a1 Ln28a1 Ln29a1 0.805155
Kn28an29a2 Ln28a2 Ln29a2 0.805155
Kn28an29a3 Ln28a3 Ln29a3 0.805155
Kn28an29a4 Ln28a4 Ln29a4 0.805155
Kn28an29a5 Ln28a5 Ln29a5 0.805155
Kn28an29a6 Ln28a6 Ln29a6 0.805155
Kn28an29a7 Ln28a7 Ln29a7 0.805155
Kn28an29a8 Ln28a8 Ln29a8 0.805155
Kn28an29a9 Ln28a9 Ln29a9 0.805155
Kn28an29a10 Ln28a10 Ln29a10 0.805155
Kn28an29a11 Ln28a11 Ln29a11 0.805155
Kn28an29a12 Ln28a12 Ln29a12 0.805155
Kn28an29a13 Ln28a13 Ln29a13 0.805155
Kn28an29a14 Ln28a14 Ln29a14 0.805155
Kn28an29a15 Ln28a15 Ln29a15 0.805155
Kn28an29a16 Ln28a16 Ln29a16 0.805155
Kn28an30a1 Ln28a1 Ln30a1 0.723730
Kn28an30a2 Ln28a2 Ln30a2 0.723730
Kn28an30a3 Ln28a3 Ln30a3 0.723730
Kn28an30a4 Ln28a4 Ln30a4 0.723730
Kn28an30a5 Ln28a5 Ln30a5 0.723730
Kn28an30a6 Ln28a6 Ln30a6 0.723730
Kn28an30a7 Ln28a7 Ln30a7 0.723730
Kn28an30a8 Ln28a8 Ln30a8 0.723730
Kn28an30a9 Ln28a9 Ln30a9 0.723730
Kn28an30a10 Ln28a10 Ln30a10 0.723730
Kn28an30a11 Ln28a11 Ln30a11 0.723730
Kn28an30a12 Ln28a12 Ln30a12 0.723730
Kn28an30a13 Ln28a13 Ln30a13 0.723730
Kn28an30a14 Ln28a14 Ln30a14 0.723730
Kn28an30a15 Ln28a15 Ln30a15 0.723730
Kn28an30a16 Ln28a16 Ln30a16 0.723730
Kn28an31a1 Ln28a1 Ln31a1 0.675208
Kn28an31a2 Ln28a2 Ln31a2 0.675208
Kn28an31a3 Ln28a3 Ln31a3 0.675208
Kn28an31a4 Ln28a4 Ln31a4 0.675208
Kn28an31a5 Ln28a5 Ln31a5 0.675208
Kn28an31a6 Ln28a6 Ln31a6 0.675208
Kn28an31a7 Ln28a7 Ln31a7 0.675208
Kn28an31a8 Ln28a8 Ln31a8 0.675208
Kn28an31a9 Ln28a9 Ln31a9 0.675208
Kn28an31a10 Ln28a10 Ln31a10 0.675208
Kn28an31a11 Ln28a11 Ln31a11 0.675208
Kn28an31a12 Ln28a12 Ln31a12 0.675208
Kn28an31a13 Ln28a13 Ln31a13 0.675208
Kn28an31a14 Ln28a14 Ln31a14 0.675208
Kn28an31a15 Ln28a15 Ln31a15 0.675208
Kn28an31a16 Ln28a16 Ln31a16 0.675208
Kn28an32a1 Ln28a1 Ln32a1 0.640637
Kn28an32a2 Ln28a2 Ln32a2 0.640637
Kn28an32a3 Ln28a3 Ln32a3 0.640637
Kn28an32a4 Ln28a4 Ln32a4 0.640637
Kn28an32a5 Ln28a5 Ln32a5 0.640637
Kn28an32a6 Ln28a6 Ln32a6 0.640637
Kn28an32a7 Ln28a7 Ln32a7 0.640637
Kn28an32a8 Ln28a8 Ln32a8 0.640637
Kn28an32a9 Ln28a9 Ln32a9 0.640637
Kn28an32a10 Ln28a10 Ln32a10 0.640637
Kn28an32a11 Ln28a11 Ln32a11 0.640637
Kn28an32a12 Ln28a12 Ln32a12 0.640637
Kn28an32a13 Ln28a13 Ln32a13 0.640637
Kn28an32a14 Ln28a14 Ln32a14 0.640637
Kn28an32a15 Ln28a15 Ln32a15 0.640637
Kn28an32a16 Ln28a16 Ln32a16 0.640637
Kn28anva1 Ln28a1 Lnva1 0.613723
Kn28anva2 Ln28a2 Lnva2 0.613723
Kn28anva3 Ln28a3 Lnva3 0.613723
Kn28anva4 Ln28a4 Lnva4 0.613723
Kn28anva5 Ln28a5 Lnva5 0.613723
Kn28anva6 Ln28a6 Lnva6 0.613723
Kn28anva7 Ln28a7 Lnva7 0.613723
Kn28anva8 Ln28a8 Lnva8 0.613723
Kn28anva9 Ln28a9 Lnva9 0.613723
Kn28anva10 Ln28a10 Lnva10 0.613723
Kn28anva11 Ln28a11 Lnva11 0.613723
Kn28anva12 Ln28a12 Lnva12 0.613723
Kn28anva13 Ln28a13 Lnva13 0.613723
Kn28anva14 Ln28a14 Lnva14 0.613723
Kn28anva15 Ln28a15 Lnva15 0.613723
Kn28anva16 Ln28a16 Lnva16 0.613723
Kn29an30a1 Ln29a1 Ln30a1 0.805155
Kn29an30a2 Ln29a2 Ln30a2 0.805155
Kn29an30a3 Ln29a3 Ln30a3 0.805155
Kn29an30a4 Ln29a4 Ln30a4 0.805155
Kn29an30a5 Ln29a5 Ln30a5 0.805155
Kn29an30a6 Ln29a6 Ln30a6 0.805155
Kn29an30a7 Ln29a7 Ln30a7 0.805155
Kn29an30a8 Ln29a8 Ln30a8 0.805155
Kn29an30a9 Ln29a9 Ln30a9 0.805155
Kn29an30a10 Ln29a10 Ln30a10 0.805155
Kn29an30a11 Ln29a11 Ln30a11 0.805155
Kn29an30a12 Ln29a12 Ln30a12 0.805155
Kn29an30a13 Ln29a13 Ln30a13 0.805155
Kn29an30a14 Ln29a14 Ln30a14 0.805155
Kn29an30a15 Ln29a15 Ln30a15 0.805155
Kn29an30a16 Ln29a16 Ln30a16 0.805155
Kn29an31a1 Ln29a1 Ln31a1 0.723730
Kn29an31a2 Ln29a2 Ln31a2 0.723730
Kn29an31a3 Ln29a3 Ln31a3 0.723730
Kn29an31a4 Ln29a4 Ln31a4 0.723730
Kn29an31a5 Ln29a5 Ln31a5 0.723730
Kn29an31a6 Ln29a6 Ln31a6 0.723730
Kn29an31a7 Ln29a7 Ln31a7 0.723730
Kn29an31a8 Ln29a8 Ln31a8 0.723730
Kn29an31a9 Ln29a9 Ln31a9 0.723730
Kn29an31a10 Ln29a10 Ln31a10 0.723730
Kn29an31a11 Ln29a11 Ln31a11 0.723730
Kn29an31a12 Ln29a12 Ln31a12 0.723730
Kn29an31a13 Ln29a13 Ln31a13 0.723730
Kn29an31a14 Ln29a14 Ln31a14 0.723730
Kn29an31a15 Ln29a15 Ln31a15 0.723730
Kn29an31a16 Ln29a16 Ln31a16 0.723730
Kn29an32a1 Ln29a1 Ln32a1 0.675208
Kn29an32a2 Ln29a2 Ln32a2 0.675208
Kn29an32a3 Ln29a3 Ln32a3 0.675208
Kn29an32a4 Ln29a4 Ln32a4 0.675208
Kn29an32a5 Ln29a5 Ln32a5 0.675208
Kn29an32a6 Ln29a6 Ln32a6 0.675208
Kn29an32a7 Ln29a7 Ln32a7 0.675208
Kn29an32a8 Ln29a8 Ln32a8 0.675208
Kn29an32a9 Ln29a9 Ln32a9 0.675208
Kn29an32a10 Ln29a10 Ln32a10 0.675208
Kn29an32a11 Ln29a11 Ln32a11 0.675208
Kn29an32a12 Ln29a12 Ln32a12 0.675208
Kn29an32a13 Ln29a13 Ln32a13 0.675208
Kn29an32a14 Ln29a14 Ln32a14 0.675208
Kn29an32a15 Ln29a15 Ln32a15 0.675208
Kn29an32a16 Ln29a16 Ln32a16 0.675208
Kn29anva1 Ln29a1 Lnva1 0.640637
Kn29anva2 Ln29a2 Lnva2 0.640637
Kn29anva3 Ln29a3 Lnva3 0.640637
Kn29anva4 Ln29a4 Lnva4 0.640637
Kn29anva5 Ln29a5 Lnva5 0.640637
Kn29anva6 Ln29a6 Lnva6 0.640637
Kn29anva7 Ln29a7 Lnva7 0.640637
Kn29anva8 Ln29a8 Lnva8 0.640637
Kn29anva9 Ln29a9 Lnva9 0.640637
Kn29anva10 Ln29a10 Lnva10 0.640637
Kn29anva11 Ln29a11 Lnva11 0.640637
Kn29anva12 Ln29a12 Lnva12 0.640637
Kn29anva13 Ln29a13 Lnva13 0.640637
Kn29anva14 Ln29a14 Lnva14 0.640637
Kn29anva15 Ln29a15 Lnva15 0.640637
Kn29anva16 Ln29a16 Lnva16 0.640637
Kn30an31a1 Ln30a1 Ln31a1 0.805155
Kn30an31a2 Ln30a2 Ln31a2 0.805155
Kn30an31a3 Ln30a3 Ln31a3 0.805155
Kn30an31a4 Ln30a4 Ln31a4 0.805155
Kn30an31a5 Ln30a5 Ln31a5 0.805155
Kn30an31a6 Ln30a6 Ln31a6 0.805155
Kn30an31a7 Ln30a7 Ln31a7 0.805155
Kn30an31a8 Ln30a8 Ln31a8 0.805155
Kn30an31a9 Ln30a9 Ln31a9 0.805155
Kn30an31a10 Ln30a10 Ln31a10 0.805155
Kn30an31a11 Ln30a11 Ln31a11 0.805155
Kn30an31a12 Ln30a12 Ln31a12 0.805155
Kn30an31a13 Ln30a13 Ln31a13 0.805155
Kn30an31a14 Ln30a14 Ln31a14 0.805155
Kn30an31a15 Ln30a15 Ln31a15 0.805155
Kn30an31a16 Ln30a16 Ln31a16 0.805155
Kn30an32a1 Ln30a1 Ln32a1 0.723730
Kn30an32a2 Ln30a2 Ln32a2 0.723730
Kn30an32a3 Ln30a3 Ln32a3 0.723730
Kn30an32a4 Ln30a4 Ln32a4 0.723730
Kn30an32a5 Ln30a5 Ln32a5 0.723730
Kn30an32a6 Ln30a6 Ln32a6 0.723730
Kn30an32a7 Ln30a7 Ln32a7 0.723730
Kn30an32a8 Ln30a8 Ln32a8 0.723730
Kn30an32a9 Ln30a9 Ln32a9 0.723730
Kn30an32a10 Ln30a10 Ln32a10 0.723730
Kn30an32a11 Ln30a11 Ln32a11 0.723730
Kn30an32a12 Ln30a12 Ln32a12 0.723730
Kn30an32a13 Ln30a13 Ln32a13 0.723730
Kn30an32a14 Ln30a14 Ln32a14 0.723730
Kn30an32a15 Ln30a15 Ln32a15 0.723730
Kn30an32a16 Ln30a16 Ln32a16 0.723730
Kn30anva1 Ln30a1 Lnva1 0.675208
Kn30anva2 Ln30a2 Lnva2 0.675208
Kn30anva3 Ln30a3 Lnva3 0.675208
Kn30anva4 Ln30a4 Lnva4 0.675208
Kn30anva5 Ln30a5 Lnva5 0.675208
Kn30anva6 Ln30a6 Lnva6 0.675208
Kn30anva7 Ln30a7 Lnva7 0.675208
Kn30anva8 Ln30a8 Lnva8 0.675208
Kn30anva9 Ln30a9 Lnva9 0.675208
Kn30anva10 Ln30a10 Lnva10 0.675208
Kn30anva11 Ln30a11 Lnva11 0.675208
Kn30anva12 Ln30a12 Lnva12 0.675208
Kn30anva13 Ln30a13 Lnva13 0.675208
Kn30anva14 Ln30a14 Lnva14 0.675208
Kn30anva15 Ln30a15 Lnva15 0.675208
Kn30anva16 Ln30a16 Lnva16 0.675208
Kn31an32a1 Ln31a1 Ln32a1 0.805155
Kn31an32a2 Ln31a2 Ln32a2 0.805155
Kn31an32a3 Ln31a3 Ln32a3 0.805155
Kn31an32a4 Ln31a4 Ln32a4 0.805155
Kn31an32a5 Ln31a5 Ln32a5 0.805155
Kn31an32a6 Ln31a6 Ln32a6 0.805155
Kn31an32a7 Ln31a7 Ln32a7 0.805155
Kn31an32a8 Ln31a8 Ln32a8 0.805155
Kn31an32a9 Ln31a9 Ln32a9 0.805155
Kn31an32a10 Ln31a10 Ln32a10 0.805155
Kn31an32a11 Ln31a11 Ln32a11 0.805155
Kn31an32a12 Ln31a12 Ln32a12 0.805155
Kn31an32a13 Ln31a13 Ln32a13 0.805155
Kn31an32a14 Ln31a14 Ln32a14 0.805155
Kn31an32a15 Ln31a15 Ln32a15 0.805155
Kn31an32a16 Ln31a16 Ln32a16 0.805155
Kn31anva1 Ln31a1 Lnva1 0.723730
Kn31anva2 Ln31a2 Lnva2 0.723730
Kn31anva3 Ln31a3 Lnva3 0.723730
Kn31anva4 Ln31a4 Lnva4 0.723730
Kn31anva5 Ln31a5 Lnva5 0.723730
Kn31anva6 Ln31a6 Lnva6 0.723730
Kn31anva7 Ln31a7 Lnva7 0.723730
Kn31anva8 Ln31a8 Lnva8 0.723730
Kn31anva9 Ln31a9 Lnva9 0.723730
Kn31anva10 Ln31a10 Lnva10 0.723730
Kn31anva11 Ln31a11 Lnva11 0.723730
Kn31anva12 Ln31a12 Lnva12 0.723730
Kn31anva13 Ln31a13 Lnva13 0.723730
Kn31anva14 Ln31a14 Lnva14 0.723730
Kn31anva15 Ln31a15 Lnva15 0.723730
Kn31anva16 Ln31a16 Lnva16 0.723730
Kn32anva1 Ln32a1 Lnva1 0.805155
Kn32anva2 Ln32a2 Lnva2 0.805155
Kn32anva3 Ln32a3 Lnva3 0.805155
Kn32anva4 Ln32a4 Lnva4 0.805155
Kn32anva5 Ln32a5 Lnva5 0.805155
Kn32anva6 Ln32a6 Lnva6 0.805155
Kn32anva7 Ln32a7 Lnva7 0.805155
Kn32anva8 Ln32a8 Lnva8 0.805155
Kn32anva9 Ln32a9 Lnva9 0.805155
Kn32anva10 Ln32a10 Lnva10 0.805155
Kn32anva11 Ln32a11 Lnva11 0.805155
Kn32anva12 Ln32a12 Lnva12 0.805155
Kn32anva13 Ln32a13 Lnva13 0.805155
Kn32anva14 Ln32a14 Lnva14 0.805155
Kn32anva15 Ln32a15 Lnva15 0.805155
Kn32anva16 Ln32a16 Lnva16 0.805155
Cngan1a1 TDnga1 TDn1a1 1.694350e-014
Cngan1a2 TDnga3 TDn1a3 3.388710e-014
Cngan1a3 TDnga5 TDn1a5 3.388710e-014
Cngan1a4 TDnga7 TDn1a7 3.388710e-014
Cngan1a5 TDnga9 TDn1a9 3.388710e-014
Cngan1a6 TDnga11 TDn1a11 3.388710e-014
Cngan1a7 TDnga13 TDn1a13 3.388710e-014
Cngan1a8 TDnga15 TDn1a15 3.388710e-014
Cngan1a9 TDnga17 TDn1a17 3.388710e-014
Cngan1a10 TDnga19 TDn1a19 3.388710e-014
Cngan1a11 TDnga21 TDn1a21 3.388710e-014
Cngan1a12 TDnga23 TDn1a23 3.388710e-014
Cngan1a13 TDnga25 TDn1a25 3.388710e-014
Cngan1a14 TDnga27 TDn1a27 3.388710e-014
Cngan1a15 TDnga29 TDn1a29 3.388710e-014
Cngan1a16 TDnga31 TDn1a31 3.388710e-014
Cngan1a17 TDnga33 TDn1a33 1.694350e-014
Cngan2a1 TDnga1 TDn2a1 6.546790e-015
Cngan2a2 TDnga3 TDn2a3 1.309360e-014
Cngan2a3 TDnga5 TDn2a5 1.309360e-014
Cngan2a4 TDnga7 TDn2a7 1.309360e-014
Cngan2a5 TDnga9 TDn2a9 1.309360e-014
Cngan2a6 TDnga11 TDn2a11 1.309360e-014
Cngan2a7 TDnga13 TDn2a13 1.309360e-014
Cngan2a8 TDnga15 TDn2a15 1.309360e-014
Cngan2a9 TDnga17 TDn2a17 1.309360e-014
Cngan2a10 TDnga19 TDn2a19 1.309360e-014
Cngan2a11 TDnga21 TDn2a21 1.309360e-014
Cngan2a12 TDnga23 TDn2a23 1.309360e-014
Cngan2a13 TDnga25 TDn2a25 1.309360e-014
Cngan2a14 TDnga27 TDn2a27 1.309360e-014
Cngan2a15 TDnga29 TDn2a29 1.309360e-014
Cngan2a16 TDnga31 TDn2a31 1.309360e-014
Cngan2a17 TDnga33 TDn2a33 6.546790e-015
Cngan3a1 TDnga1 TDn3a1 6.009140e-015
Cngan3a2 TDnga3 TDn3a3 1.201830e-014
Cngan3a3 TDnga5 TDn3a5 1.201830e-014
Cngan3a4 TDnga7 TDn3a7 1.201830e-014
Cngan3a5 TDnga9 TDn3a9 1.201830e-014
Cngan3a6 TDnga11 TDn3a11 1.201830e-014
Cngan3a7 TDnga13 TDn3a13 1.201830e-014
Cngan3a8 TDnga15 TDn3a15 1.201830e-014
Cngan3a9 TDnga17 TDn3a17 1.201830e-014
Cngan3a10 TDnga19 TDn3a19 1.201830e-014
Cngan3a11 TDnga21 TDn3a21 1.201830e-014
Cngan3a12 TDnga23 TDn3a23 1.201830e-014
Cngan3a13 TDnga25 TDn3a25 1.201830e-014
Cngan3a14 TDnga27 TDn3a27 1.201830e-014
Cngan3a15 TDnga29 TDn3a29 1.201830e-014
Cngan3a16 TDnga31 TDn3a31 1.201830e-014
Cngan3a17 TDnga33 TDn3a33 6.009140e-015
Cngan4a1 TDnga1 TDn4a1 5.850980e-015
Cngan4a2 TDnga3 TDn4a3 1.170200e-014
Cngan4a3 TDnga5 TDn4a5 1.170200e-014
Cngan4a4 TDnga7 TDn4a7 1.170200e-014
Cngan4a5 TDnga9 TDn4a9 1.170200e-014
Cngan4a6 TDnga11 TDn4a11 1.170200e-014
Cngan4a7 TDnga13 TDn4a13 1.170200e-014
Cngan4a8 TDnga15 TDn4a15 1.170200e-014
Cngan4a9 TDnga17 TDn4a17 1.170200e-014
Cngan4a10 TDnga19 TDn4a19 1.170200e-014
Cngan4a11 TDnga21 TDn4a21 1.170200e-014
Cngan4a12 TDnga23 TDn4a23 1.170200e-014
Cngan4a13 TDnga25 TDn4a25 1.170200e-014
Cngan4a14 TDnga27 TDn4a27 1.170200e-014
Cngan4a15 TDnga29 TDn4a29 1.170200e-014
Cngan4a16 TDnga31 TDn4a31 1.170200e-014
Cngan4a17 TDnga33 TDn4a33 5.850980e-015
Cngan5a1 TDnga1 TDn5a1 5.758530e-015
Cngan5a2 TDnga3 TDn5a3 1.151710e-014
Cngan5a3 TDnga5 TDn5a5 1.151710e-014
Cngan5a4 TDnga7 TDn5a7 1.151710e-014
Cngan5a5 TDnga9 TDn5a9 1.151710e-014
Cngan5a6 TDnga11 TDn5a11 1.151710e-014
Cngan5a7 TDnga13 TDn5a13 1.151710e-014
Cngan5a8 TDnga15 TDn5a15 1.151710e-014
Cngan5a9 TDnga17 TDn5a17 1.151710e-014
Cngan5a10 TDnga19 TDn5a19 1.151710e-014
Cngan5a11 TDnga21 TDn5a21 1.151710e-014
Cngan5a12 TDnga23 TDn5a23 1.151710e-014
Cngan5a13 TDnga25 TDn5a25 1.151710e-014
Cngan5a14 TDnga27 TDn5a27 1.151710e-014
Cngan5a15 TDnga29 TDn5a29 1.151710e-014
Cngan5a16 TDnga31 TDn5a31 1.151710e-014
Cngan5a17 TDnga33 TDn5a33 5.758530e-015
Cngan6a1 TDnga1 TDn6a1 5.724210e-015
Cngan6a2 TDnga3 TDn6a3 1.144840e-014
Cngan6a3 TDnga5 TDn6a5 1.144840e-014
Cngan6a4 TDnga7 TDn6a7 1.144840e-014
Cngan6a5 TDnga9 TDn6a9 1.144840e-014
Cngan6a6 TDnga11 TDn6a11 1.144840e-014
Cngan6a7 TDnga13 TDn6a13 1.144840e-014
Cngan6a8 TDnga15 TDn6a15 1.144840e-014
Cngan6a9 TDnga17 TDn6a17 1.144840e-014
Cngan6a10 TDnga19 TDn6a19 1.144840e-014
Cngan6a11 TDnga21 TDn6a21 1.144840e-014
Cngan6a12 TDnga23 TDn6a23 1.144840e-014
Cngan6a13 TDnga25 TDn6a25 1.144840e-014
Cngan6a14 TDnga27 TDn6a27 1.144840e-014
Cngan6a15 TDnga29 TDn6a29 1.144840e-014
Cngan6a16 TDnga31 TDn6a31 1.144840e-014
Cngan6a17 TDnga33 TDn6a33 5.724210e-015
Cngan7a1 TDnga1 TDn7a1 5.734420e-015
Cngan7a2 TDnga3 TDn7a3 1.146880e-014
Cngan7a3 TDnga5 TDn7a5 1.146880e-014
Cngan7a4 TDnga7 TDn7a7 1.146880e-014
Cngan7a5 TDnga9 TDn7a9 1.146880e-014
Cngan7a6 TDnga11 TDn7a11 1.146880e-014
Cngan7a7 TDnga13 TDn7a13 1.146880e-014
Cngan7a8 TDnga15 TDn7a15 1.146880e-014
Cngan7a9 TDnga17 TDn7a17 1.146880e-014
Cngan7a10 TDnga19 TDn7a19 1.146880e-014
Cngan7a11 TDnga21 TDn7a21 1.146880e-014
Cngan7a12 TDnga23 TDn7a23 1.146880e-014
Cngan7a13 TDnga25 TDn7a25 1.146880e-014
Cngan7a14 TDnga27 TDn7a27 1.146880e-014
Cngan7a15 TDnga29 TDn7a29 1.146880e-014
Cngan7a16 TDnga31 TDn7a31 1.146880e-014
Cngan7a17 TDnga33 TDn7a33 5.734420e-015
Cngan8a1 TDnga1 TDn8a1 5.773050e-015
Cngan8a2 TDnga3 TDn8a3 1.154610e-014
Cngan8a3 TDnga5 TDn8a5 1.154610e-014
Cngan8a4 TDnga7 TDn8a7 1.154610e-014
Cngan8a5 TDnga9 TDn8a9 1.154610e-014
Cngan8a6 TDnga11 TDn8a11 1.154610e-014
Cngan8a7 TDnga13 TDn8a13 1.154610e-014
Cngan8a8 TDnga15 TDn8a15 1.154610e-014
Cngan8a9 TDnga17 TDn8a17 1.154610e-014
Cngan8a10 TDnga19 TDn8a19 1.154610e-014
Cngan8a11 TDnga21 TDn8a21 1.154610e-014
Cngan8a12 TDnga23 TDn8a23 1.154610e-014
Cngan8a13 TDnga25 TDn8a25 1.154610e-014
Cngan8a14 TDnga27 TDn8a27 1.154610e-014
Cngan8a15 TDnga29 TDn8a29 1.154610e-014
Cngan8a16 TDnga31 TDn8a31 1.154610e-014
Cngan8a17 TDnga33 TDn8a33 5.773050e-015
Cngan9a1 TDnga1 TDn9a1 6.592280e-015
Cngan9a2 TDnga3 TDn9a3 1.318460e-014
Cngan9a3 TDnga5 TDn9a5 1.318460e-014
Cngan9a4 TDnga7 TDn9a7 1.318460e-014
Cngan9a5 TDnga9 TDn9a9 1.318460e-014
Cngan9a6 TDnga11 TDn9a11 1.318460e-014
Cngan9a7 TDnga13 TDn9a13 1.318460e-014
Cngan9a8 TDnga15 TDn9a15 1.318460e-014
Cngan9a9 TDnga17 TDn9a17 1.318460e-014
Cngan9a10 TDnga19 TDn9a19 1.318460e-014
Cngan9a11 TDnga21 TDn9a21 1.318460e-014
Cngan9a12 TDnga23 TDn9a23 1.318460e-014
Cngan9a13 TDnga25 TDn9a25 1.318460e-014
Cngan9a14 TDnga27 TDn9a27 1.318460e-014
Cngan9a15 TDnga29 TDn9a29 1.318460e-014
Cngan9a16 TDnga31 TDn9a31 1.318460e-014
Cngan9a17 TDnga33 TDn9a33 6.592280e-015
Cngan10a1 TDnga1 TDn10a1 1.690880e-014
Cngan10a2 TDnga3 TDn10a3 1.302320e-014
Cngan10a3 TDnga5 TDn10a5 1.302320e-014
Cngan10a4 TDnga7 TDn10a7 1.302320e-014
Cngan10a5 TDnga9 TDn10a9 1.302320e-014
Cngan10a6 TDnga11 TDn10a11 1.302320e-014
Cngan10a7 TDnga13 TDn10a13 1.302320e-014
Cngan10a8 TDnga15 TDn10a15 1.302320e-014
Cngan10a9 TDnga17 TDn10a17 1.302320e-014
Cngan10a10 TDnga19 TDn10a19 1.302320e-014
Cngan10a11 TDnga21 TDn10a21 1.302320e-014
Cngan10a12 TDnga23 TDn10a23 1.302320e-014
Cngan10a13 TDnga25 TDn10a25 1.302320e-014
Cngan10a14 TDnga27 TDn10a27 1.302320e-014
Cngan10a15 TDnga29 TDn10a29 1.302320e-014
Cngan10a16 TDnga31 TDn10a31 1.302320e-014
Cngan10a17 TDnga33 TDn10a33 1.690880e-014
Cngan11a1 TDnga1 TDn11a1 1.690880e-014
Cngan11a2 TDnga3 TDn11a3 1.302320e-014
Cngan11a3 TDnga5 TDn11a5 1.302320e-014
Cngan11a4 TDnga7 TDn11a7 1.302320e-014
Cngan11a5 TDnga9 TDn11a9 1.302320e-014
Cngan11a6 TDnga11 TDn11a11 1.302320e-014
Cngan11a7 TDnga13 TDn11a13 1.302320e-014
Cngan11a8 TDnga15 TDn11a15 1.302320e-014
Cngan11a9 TDnga17 TDn11a17 1.302320e-014
Cngan11a10 TDnga19 TDn11a19 1.302320e-014
Cngan11a11 TDnga21 TDn11a21 1.302320e-014
Cngan11a12 TDnga23 TDn11a23 1.302320e-014
Cngan11a13 TDnga25 TDn11a25 1.302320e-014
Cngan11a14 TDnga27 TDn11a27 1.302320e-014
Cngan11a15 TDnga29 TDn11a29 1.302320e-014
Cngan11a16 TDnga31 TDn11a31 1.302320e-014
Cngan11a17 TDnga33 TDn11a33 1.690880e-014
Cngan12a1 TDnga1 TDn12a1 1.690880e-014
Cngan12a2 TDnga3 TDn12a3 1.302320e-014
Cngan12a3 TDnga5 TDn12a5 1.302320e-014
Cngan12a4 TDnga7 TDn12a7 1.302320e-014
Cngan12a5 TDnga9 TDn12a9 1.302320e-014
Cngan12a6 TDnga11 TDn12a11 1.302320e-014
Cngan12a7 TDnga13 TDn12a13 1.302320e-014
Cngan12a8 TDnga15 TDn12a15 1.302320e-014
Cngan12a9 TDnga17 TDn12a17 1.302320e-014
Cngan12a10 TDnga19 TDn12a19 1.302320e-014
Cngan12a11 TDnga21 TDn12a21 1.302320e-014
Cngan12a12 TDnga23 TDn12a23 1.302320e-014
Cngan12a13 TDnga25 TDn12a25 1.302320e-014
Cngan12a14 TDnga27 TDn12a27 1.302320e-014
Cngan12a15 TDnga29 TDn12a29 1.302320e-014
Cngan12a16 TDnga31 TDn12a31 1.302320e-014
Cngan12a17 TDnga33 TDn12a33 1.690880e-014
Cngan13a1 TDnga1 TDn13a1 1.690880e-014
Cngan13a2 TDnga3 TDn13a3 1.302320e-014
Cngan13a3 TDnga5 TDn13a5 1.302320e-014
Cngan13a4 TDnga7 TDn13a7 1.302320e-014
Cngan13a5 TDnga9 TDn13a9 1.302320e-014
Cngan13a6 TDnga11 TDn13a11 1.302320e-014
Cngan13a7 TDnga13 TDn13a13 1.302320e-014
Cngan13a8 TDnga15 TDn13a15 1.302320e-014
Cngan13a9 TDnga17 TDn13a17 1.302320e-014
Cngan13a10 TDnga19 TDn13a19 1.302320e-014
Cngan13a11 TDnga21 TDn13a21 1.302320e-014
Cngan13a12 TDnga23 TDn13a23 1.302320e-014
Cngan13a13 TDnga25 TDn13a25 1.302320e-014
Cngan13a14 TDnga27 TDn13a27 1.302320e-014
Cngan13a15 TDnga29 TDn13a29 1.302320e-014
Cngan13a16 TDnga31 TDn13a31 1.302320e-014
Cngan13a17 TDnga33 TDn13a33 1.690880e-014
Cngan14a1 TDnga1 TDn14a1 1.690880e-014
Cngan14a2 TDnga3 TDn14a3 1.302320e-014
Cngan14a3 TDnga5 TDn14a5 1.302320e-014
Cngan14a4 TDnga7 TDn14a7 1.302320e-014
Cngan14a5 TDnga9 TDn14a9 1.302320e-014
Cngan14a6 TDnga11 TDn14a11 1.302320e-014
Cngan14a7 TDnga13 TDn14a13 1.302320e-014
Cngan14a8 TDnga15 TDn14a15 1.302320e-014
Cngan14a9 TDnga17 TDn14a17 1.302320e-014
Cngan14a10 TDnga19 TDn14a19 1.302320e-014
Cngan14a11 TDnga21 TDn14a21 1.302320e-014
Cngan14a12 TDnga23 TDn14a23 1.302320e-014
Cngan14a13 TDnga25 TDn14a25 1.302320e-014
Cngan14a14 TDnga27 TDn14a27 1.302320e-014
Cngan14a15 TDnga29 TDn14a29 1.302320e-014
Cngan14a16 TDnga31 TDn14a31 1.302320e-014
Cngan14a17 TDnga33 TDn14a33 1.690880e-014
Cngan15a1 TDnga1 TDn15a1 1.690880e-014
Cngan15a2 TDnga3 TDn15a3 1.302320e-014
Cngan15a3 TDnga5 TDn15a5 1.302320e-014
Cngan15a4 TDnga7 TDn15a7 1.302320e-014
Cngan15a5 TDnga9 TDn15a9 1.302320e-014
Cngan15a6 TDnga11 TDn15a11 1.302320e-014
Cngan15a7 TDnga13 TDn15a13 1.302320e-014
Cngan15a8 TDnga15 TDn15a15 1.302320e-014
Cngan15a9 TDnga17 TDn15a17 1.302320e-014
Cngan15a10 TDnga19 TDn15a19 1.302320e-014
Cngan15a11 TDnga21 TDn15a21 1.302320e-014
Cngan15a12 TDnga23 TDn15a23 1.302320e-014
Cngan15a13 TDnga25 TDn15a25 1.302320e-014
Cngan15a14 TDnga27 TDn15a27 1.302320e-014
Cngan15a15 TDnga29 TDn15a29 1.302320e-014
Cngan15a16 TDnga31 TDn15a31 1.302320e-014
Cngan15a17 TDnga33 TDn15a33 1.690880e-014
Cngan16a1 TDnga1 TDn16a1 1.690880e-014
Cngan16a2 TDnga3 TDn16a3 1.302320e-014
Cngan16a3 TDnga5 TDn16a5 1.302320e-014
Cngan16a4 TDnga7 TDn16a7 1.302320e-014
Cngan16a5 TDnga9 TDn16a9 1.302320e-014
Cngan16a6 TDnga11 TDn16a11 1.302320e-014
Cngan16a7 TDnga13 TDn16a13 1.302320e-014
Cngan16a8 TDnga15 TDn16a15 1.302320e-014
Cngan16a9 TDnga17 TDn16a17 1.302320e-014
Cngan16a10 TDnga19 TDn16a19 1.302320e-014
Cngan16a11 TDnga21 TDn16a21 1.302320e-014
Cngan16a12 TDnga23 TDn16a23 1.302320e-014
Cngan16a13 TDnga25 TDn16a25 1.302320e-014
Cngan16a14 TDnga27 TDn16a27 1.302320e-014
Cngan16a15 TDnga29 TDn16a29 1.302320e-014
Cngan16a16 TDnga31 TDn16a31 1.302320e-014
Cngan16a17 TDnga33 TDn16a33 1.690880e-014
Cngan17a1 TDnga1 TDn17a1 1.690880e-014
Cngan17a2 TDnga3 TDn17a3 1.302320e-014
Cngan17a3 TDnga5 TDn17a5 1.302320e-014
Cngan17a4 TDnga7 TDn17a7 1.302320e-014
Cngan17a5 TDnga9 TDn17a9 1.302320e-014
Cngan17a6 TDnga11 TDn17a11 1.302320e-014
Cngan17a7 TDnga13 TDn17a13 1.302320e-014
Cngan17a8 TDnga15 TDn17a15 1.302320e-014
Cngan17a9 TDnga17 TDn17a17 1.302320e-014
Cngan17a10 TDnga19 TDn17a19 1.302320e-014
Cngan17a11 TDnga21 TDn17a21 1.302320e-014
Cngan17a12 TDnga23 TDn17a23 1.302320e-014
Cngan17a13 TDnga25 TDn17a25 1.302320e-014
Cngan17a14 TDnga27 TDn17a27 1.302320e-014
Cngan17a15 TDnga29 TDn17a29 1.302320e-014
Cngan17a16 TDnga31 TDn17a31 1.302320e-014
Cngan17a17 TDnga33 TDn17a33 1.690880e-014
Cngan18a1 TDnga1 TDn18a1 1.690880e-014
Cngan18a2 TDnga3 TDn18a3 1.302320e-014
Cngan18a3 TDnga5 TDn18a5 1.302320e-014
Cngan18a4 TDnga7 TDn18a7 1.302320e-014
Cngan18a5 TDnga9 TDn18a9 1.302320e-014
Cngan18a6 TDnga11 TDn18a11 1.302320e-014
Cngan18a7 TDnga13 TDn18a13 1.302320e-014
Cngan18a8 TDnga15 TDn18a15 1.302320e-014
Cngan18a9 TDnga17 TDn18a17 1.302320e-014
Cngan18a10 TDnga19 TDn18a19 1.302320e-014
Cngan18a11 TDnga21 TDn18a21 1.302320e-014
Cngan18a12 TDnga23 TDn18a23 1.302320e-014
Cngan18a13 TDnga25 TDn18a25 1.302320e-014
Cngan18a14 TDnga27 TDn18a27 1.302320e-014
Cngan18a15 TDnga29 TDn18a29 1.302320e-014
Cngan18a16 TDnga31 TDn18a31 1.302320e-014
Cngan18a17 TDnga33 TDn18a33 1.690880e-014
Cngan19a1 TDnga1 TDn19a1 1.690880e-014
Cngan19a2 TDnga3 TDn19a3 1.302320e-014
Cngan19a3 TDnga5 TDn19a5 1.302320e-014
Cngan19a4 TDnga7 TDn19a7 1.302320e-014
Cngan19a5 TDnga9 TDn19a9 1.302320e-014
Cngan19a6 TDnga11 TDn19a11 1.302320e-014
Cngan19a7 TDnga13 TDn19a13 1.302320e-014
Cngan19a8 TDnga15 TDn19a15 1.302320e-014
Cngan19a9 TDnga17 TDn19a17 1.302320e-014
Cngan19a10 TDnga19 TDn19a19 1.302320e-014
Cngan19a11 TDnga21 TDn19a21 1.302320e-014
Cngan19a12 TDnga23 TDn19a23 1.302320e-014
Cngan19a13 TDnga25 TDn19a25 1.302320e-014
Cngan19a14 TDnga27 TDn19a27 1.302320e-014
Cngan19a15 TDnga29 TDn19a29 1.302320e-014
Cngan19a16 TDnga31 TDn19a31 1.302320e-014
Cngan19a17 TDnga33 TDn19a33 1.690880e-014
Cngan20a1 TDnga1 TDn20a1 1.690880e-014
Cngan20a2 TDnga3 TDn20a3 1.302320e-014
Cngan20a3 TDnga5 TDn20a5 1.302320e-014
Cngan20a4 TDnga7 TDn20a7 1.302320e-014
Cngan20a5 TDnga9 TDn20a9 1.302320e-014
Cngan20a6 TDnga11 TDn20a11 1.302320e-014
Cngan20a7 TDnga13 TDn20a13 1.302320e-014
Cngan20a8 TDnga15 TDn20a15 1.302320e-014
Cngan20a9 TDnga17 TDn20a17 1.302320e-014
Cngan20a10 TDnga19 TDn20a19 1.302320e-014
Cngan20a11 TDnga21 TDn20a21 1.302320e-014
Cngan20a12 TDnga23 TDn20a23 1.302320e-014
Cngan20a13 TDnga25 TDn20a25 1.302320e-014
Cngan20a14 TDnga27 TDn20a27 1.302320e-014
Cngan20a15 TDnga29 TDn20a29 1.302320e-014
Cngan20a16 TDnga31 TDn20a31 1.302320e-014
Cngan20a17 TDnga33 TDn20a33 1.690880e-014
Cngan21a1 TDnga1 TDn21a1 1.690880e-014
Cngan21a2 TDnga3 TDn21a3 1.302320e-014
Cngan21a3 TDnga5 TDn21a5 1.302320e-014
Cngan21a4 TDnga7 TDn21a7 1.302320e-014
Cngan21a5 TDnga9 TDn21a9 1.302320e-014
Cngan21a6 TDnga11 TDn21a11 1.302320e-014
Cngan21a7 TDnga13 TDn21a13 1.302320e-014
Cngan21a8 TDnga15 TDn21a15 1.302320e-014
Cngan21a9 TDnga17 TDn21a17 1.302320e-014
Cngan21a10 TDnga19 TDn21a19 1.302320e-014
Cngan21a11 TDnga21 TDn21a21 1.302320e-014
Cngan21a12 TDnga23 TDn21a23 1.302320e-014
Cngan21a13 TDnga25 TDn21a25 1.302320e-014
Cngan21a14 TDnga27 TDn21a27 1.302320e-014
Cngan21a15 TDnga29 TDn21a29 1.302320e-014
Cngan21a16 TDnga31 TDn21a31 1.302320e-014
Cngan21a17 TDnga33 TDn21a33 1.690880e-014
Cngan22a1 TDnga1 TDn22a1 1.690880e-014
Cngan22a2 TDnga3 TDn22a3 1.302320e-014
Cngan22a3 TDnga5 TDn22a5 1.302320e-014
Cngan22a4 TDnga7 TDn22a7 1.302320e-014
Cngan22a5 TDnga9 TDn22a9 1.302320e-014
Cngan22a6 TDnga11 TDn22a11 1.302320e-014
Cngan22a7 TDnga13 TDn22a13 1.302320e-014
Cngan22a8 TDnga15 TDn22a15 1.302320e-014
Cngan22a9 TDnga17 TDn22a17 1.302320e-014
Cngan22a10 TDnga19 TDn22a19 1.302320e-014
Cngan22a11 TDnga21 TDn22a21 1.302320e-014
Cngan22a12 TDnga23 TDn22a23 1.302320e-014
Cngan22a13 TDnga25 TDn22a25 1.302320e-014
Cngan22a14 TDnga27 TDn22a27 1.302320e-014
Cngan22a15 TDnga29 TDn22a29 1.302320e-014
Cngan22a16 TDnga31 TDn22a31 1.302320e-014
Cngan22a17 TDnga33 TDn22a33 1.690880e-014
Cngan23a1 TDnga1 TDn23a1 1.690880e-014
Cngan23a2 TDnga3 TDn23a3 1.302320e-014
Cngan23a3 TDnga5 TDn23a5 1.302320e-014
Cngan23a4 TDnga7 TDn23a7 1.302320e-014
Cngan23a5 TDnga9 TDn23a9 1.302320e-014
Cngan23a6 TDnga11 TDn23a11 1.302320e-014
Cngan23a7 TDnga13 TDn23a13 1.302320e-014
Cngan23a8 TDnga15 TDn23a15 1.302320e-014
Cngan23a9 TDnga17 TDn23a17 1.302320e-014
Cngan23a10 TDnga19 TDn23a19 1.302320e-014
Cngan23a11 TDnga21 TDn23a21 1.302320e-014
Cngan23a12 TDnga23 TDn23a23 1.302320e-014
Cngan23a13 TDnga25 TDn23a25 1.302320e-014
Cngan23a14 TDnga27 TDn23a27 1.302320e-014
Cngan23a15 TDnga29 TDn23a29 1.302320e-014
Cngan23a16 TDnga31 TDn23a31 1.302320e-014
Cngan23a17 TDnga33 TDn23a33 1.690880e-014
Cngan24a1 TDnga1 TDn24a1 1.690880e-014
Cngan24a2 TDnga3 TDn24a3 1.302320e-014
Cngan24a3 TDnga5 TDn24a5 1.302320e-014
Cngan24a4 TDnga7 TDn24a7 1.302320e-014
Cngan24a5 TDnga9 TDn24a9 1.302320e-014
Cngan24a6 TDnga11 TDn24a11 1.302320e-014
Cngan24a7 TDnga13 TDn24a13 1.302320e-014
Cngan24a8 TDnga15 TDn24a15 1.302320e-014
Cngan24a9 TDnga17 TDn24a17 1.302320e-014
Cngan24a10 TDnga19 TDn24a19 1.302320e-014
Cngan24a11 TDnga21 TDn24a21 1.302320e-014
Cngan24a12 TDnga23 TDn24a23 1.302320e-014
Cngan24a13 TDnga25 TDn24a25 1.302320e-014
Cngan24a14 TDnga27 TDn24a27 1.302320e-014
Cngan24a15 TDnga29 TDn24a29 1.302320e-014
Cngan24a16 TDnga31 TDn24a31 1.302320e-014
Cngan24a17 TDnga33 TDn24a33 1.690880e-014
Cngan25a1 TDnga1 TDn25a1 1.690880e-014
Cngan25a2 TDnga3 TDn25a3 1.302320e-014
Cngan25a3 TDnga5 TDn25a5 1.302320e-014
Cngan25a4 TDnga7 TDn25a7 1.302320e-014
Cngan25a5 TDnga9 TDn25a9 1.302320e-014
Cngan25a6 TDnga11 TDn25a11 1.302320e-014
Cngan25a7 TDnga13 TDn25a13 1.302320e-014
Cngan25a8 TDnga15 TDn25a15 1.302320e-014
Cngan25a9 TDnga17 TDn25a17 1.302320e-014
Cngan25a10 TDnga19 TDn25a19 1.302320e-014
Cngan25a11 TDnga21 TDn25a21 1.302320e-014
Cngan25a12 TDnga23 TDn25a23 1.302320e-014
Cngan25a13 TDnga25 TDn25a25 1.302320e-014
Cngan25a14 TDnga27 TDn25a27 1.302320e-014
Cngan25a15 TDnga29 TDn25a29 1.302320e-014
Cngan25a16 TDnga31 TDn25a31 1.302320e-014
Cngan25a17 TDnga33 TDn25a33 1.690880e-014
Cngan26a1 TDnga1 TDn26a1 1.690880e-014
Cngan26a2 TDnga3 TDn26a3 1.302320e-014
Cngan26a3 TDnga5 TDn26a5 1.302320e-014
Cngan26a4 TDnga7 TDn26a7 1.302320e-014
Cngan26a5 TDnga9 TDn26a9 1.302320e-014
Cngan26a6 TDnga11 TDn26a11 1.302320e-014
Cngan26a7 TDnga13 TDn26a13 1.302320e-014
Cngan26a8 TDnga15 TDn26a15 1.302320e-014
Cngan26a9 TDnga17 TDn26a17 1.302320e-014
Cngan26a10 TDnga19 TDn26a19 1.302320e-014
Cngan26a11 TDnga21 TDn26a21 1.302320e-014
Cngan26a12 TDnga23 TDn26a23 1.302320e-014
Cngan26a13 TDnga25 TDn26a25 1.302320e-014
Cngan26a14 TDnga27 TDn26a27 1.302320e-014
Cngan26a15 TDnga29 TDn26a29 1.302320e-014
Cngan26a16 TDnga31 TDn26a31 1.302320e-014
Cngan26a17 TDnga33 TDn26a33 1.690880e-014
Cngan27a1 TDnga1 TDn27a1 1.690880e-014
Cngan27a2 TDnga3 TDn27a3 1.302320e-014
Cngan27a3 TDnga5 TDn27a5 1.302320e-014
Cngan27a4 TDnga7 TDn27a7 1.302320e-014
Cngan27a5 TDnga9 TDn27a9 1.302320e-014
Cngan27a6 TDnga11 TDn27a11 1.302320e-014
Cngan27a7 TDnga13 TDn27a13 1.302320e-014
Cngan27a8 TDnga15 TDn27a15 1.302320e-014
Cngan27a9 TDnga17 TDn27a17 1.302320e-014
Cngan27a10 TDnga19 TDn27a19 1.302320e-014
Cngan27a11 TDnga21 TDn27a21 1.302320e-014
Cngan27a12 TDnga23 TDn27a23 1.302320e-014
Cngan27a13 TDnga25 TDn27a25 1.302320e-014
Cngan27a14 TDnga27 TDn27a27 1.302320e-014
Cngan27a15 TDnga29 TDn27a29 1.302320e-014
Cngan27a16 TDnga31 TDn27a31 1.302320e-014
Cngan27a17 TDnga33 TDn27a33 1.690880e-014
Cngan28a1 TDnga1 TDn28a1 1.690880e-014
Cngan28a2 TDnga3 TDn28a3 1.302320e-014
Cngan28a3 TDnga5 TDn28a5 1.302320e-014
Cngan28a4 TDnga7 TDn28a7 1.302320e-014
Cngan28a5 TDnga9 TDn28a9 1.302320e-014
Cngan28a6 TDnga11 TDn28a11 1.302320e-014
Cngan28a7 TDnga13 TDn28a13 1.302320e-014
Cngan28a8 TDnga15 TDn28a15 1.302320e-014
Cngan28a9 TDnga17 TDn28a17 1.302320e-014
Cngan28a10 TDnga19 TDn28a19 1.302320e-014
Cngan28a11 TDnga21 TDn28a21 1.302320e-014
Cngan28a12 TDnga23 TDn28a23 1.302320e-014
Cngan28a13 TDnga25 TDn28a25 1.302320e-014
Cngan28a14 TDnga27 TDn28a27 1.302320e-014
Cngan28a15 TDnga29 TDn28a29 1.302320e-014
Cngan28a16 TDnga31 TDn28a31 1.302320e-014
Cngan28a17 TDnga33 TDn28a33 1.690880e-014
Cngan29a1 TDnga1 TDn29a1 1.690880e-014
Cngan29a2 TDnga3 TDn29a3 1.302320e-014
Cngan29a3 TDnga5 TDn29a5 1.302320e-014
Cngan29a4 TDnga7 TDn29a7 1.302320e-014
Cngan29a5 TDnga9 TDn29a9 1.302320e-014
Cngan29a6 TDnga11 TDn29a11 1.302320e-014
Cngan29a7 TDnga13 TDn29a13 1.302320e-014
Cngan29a8 TDnga15 TDn29a15 1.302320e-014
Cngan29a9 TDnga17 TDn29a17 1.302320e-014
Cngan29a10 TDnga19 TDn29a19 1.302320e-014
Cngan29a11 TDnga21 TDn29a21 1.302320e-014
Cngan29a12 TDnga23 TDn29a23 1.302320e-014
Cngan29a13 TDnga25 TDn29a25 1.302320e-014
Cngan29a14 TDnga27 TDn29a27 1.302320e-014
Cngan29a15 TDnga29 TDn29a29 1.302320e-014
Cngan29a16 TDnga31 TDn29a31 1.302320e-014
Cngan29a17 TDnga33 TDn29a33 1.690880e-014
Cngan30a1 TDnga1 TDn30a1 1.690880e-014
Cngan30a2 TDnga3 TDn30a3 1.302320e-014
Cngan30a3 TDnga5 TDn30a5 1.302320e-014
Cngan30a4 TDnga7 TDn30a7 1.302320e-014
Cngan30a5 TDnga9 TDn30a9 1.302320e-014
Cngan30a6 TDnga11 TDn30a11 1.302320e-014
Cngan30a7 TDnga13 TDn30a13 1.302320e-014
Cngan30a8 TDnga15 TDn30a15 1.302320e-014
Cngan30a9 TDnga17 TDn30a17 1.302320e-014
Cngan30a10 TDnga19 TDn30a19 1.302320e-014
Cngan30a11 TDnga21 TDn30a21 1.302320e-014
Cngan30a12 TDnga23 TDn30a23 1.302320e-014
Cngan30a13 TDnga25 TDn30a25 1.302320e-014
Cngan30a14 TDnga27 TDn30a27 1.302320e-014
Cngan30a15 TDnga29 TDn30a29 1.302320e-014
Cngan30a16 TDnga31 TDn30a31 1.302320e-014
Cngan30a17 TDnga33 TDn30a33 1.690880e-014
Cngan31a1 TDnga1 TDn31a1 1.690880e-014
Cngan31a2 TDnga3 TDn31a3 1.302320e-014
Cngan31a3 TDnga5 TDn31a5 1.302320e-014
Cngan31a4 TDnga7 TDn31a7 1.302320e-014
Cngan31a5 TDnga9 TDn31a9 1.302320e-014
Cngan31a6 TDnga11 TDn31a11 1.302320e-014
Cngan31a7 TDnga13 TDn31a13 1.302320e-014
Cngan31a8 TDnga15 TDn31a15 1.302320e-014
Cngan31a9 TDnga17 TDn31a17 1.302320e-014
Cngan31a10 TDnga19 TDn31a19 1.302320e-014
Cngan31a11 TDnga21 TDn31a21 1.302320e-014
Cngan31a12 TDnga23 TDn31a23 1.302320e-014
Cngan31a13 TDnga25 TDn31a25 1.302320e-014
Cngan31a14 TDnga27 TDn31a27 1.302320e-014
Cngan31a15 TDnga29 TDn31a29 1.302320e-014
Cngan31a16 TDnga31 TDn31a31 1.302320e-014
Cngan31a17 TDnga33 TDn31a33 1.690880e-014
Cngan32a1 TDnga1 TDn32a1 1.690880e-014
Cngan32a2 TDnga3 TDn32a3 1.302320e-014
Cngan32a3 TDnga5 TDn32a5 1.302320e-014
Cngan32a4 TDnga7 TDn32a7 1.302320e-014
Cngan32a5 TDnga9 TDn32a9 1.302320e-014
Cngan32a6 TDnga11 TDn32a11 1.302320e-014
Cngan32a7 TDnga13 TDn32a13 1.302320e-014
Cngan32a8 TDnga15 TDn32a15 1.302320e-014
Cngan32a9 TDnga17 TDn32a17 1.302320e-014
Cngan32a10 TDnga19 TDn32a19 1.302320e-014
Cngan32a11 TDnga21 TDn32a21 1.302320e-014
Cngan32a12 TDnga23 TDn32a23 1.302320e-014
Cngan32a13 TDnga25 TDn32a25 1.302320e-014
Cngan32a14 TDnga27 TDn32a27 1.302320e-014
Cngan32a15 TDnga29 TDn32a29 1.302320e-014
Cngan32a16 TDnga31 TDn32a31 1.302320e-014
Cngan32a17 TDnga33 TDn32a33 1.690880e-014
Cnganva1 TDnga1 TDnva1 1.690880e-014
Cnganva2 TDnga3 TDnva3 1.302320e-014
Cnganva3 TDnga5 TDnva5 1.302320e-014
Cnganva4 TDnga7 TDnva7 1.302320e-014
Cnganva5 TDnga9 TDnva9 1.302320e-014
Cnganva6 TDnga11 TDnva11 1.302320e-014
Cnganva7 TDnga13 TDnva13 1.302320e-014
Cnganva8 TDnga15 TDnva15 1.302320e-014
Cnganva9 TDnga17 TDnva17 1.302320e-014
Cnganva10 TDnga19 TDnva19 1.302320e-014
Cnganva11 TDnga21 TDnva21 1.302320e-014
Cnganva12 TDnga23 TDnva23 1.302320e-014
Cnganva13 TDnga25 TDnva25 1.302320e-014
Cnganva14 TDnga27 TDnva27 1.302320e-014
Cnganva15 TDnga29 TDnva29 1.302320e-014
Cnganva16 TDnga31 TDnva31 1.302320e-014
Cnganva17 TDnga33 TDnva33 1.690880e-014
Cn1an2a1 TDn1a1 TDn2a1 1.586220e-014
Cn1an2a2 TDn1a3 TDn2a3 3.172450e-014
Cn1an2a3 TDn1a5 TDn2a5 3.172450e-014
Cn1an2a4 TDn1a7 TDn2a7 3.172450e-014
Cn1an2a5 TDn1a9 TDn2a9 3.172450e-014
Cn1an2a6 TDn1a11 TDn2a11 3.172450e-014
Cn1an2a7 TDn1a13 TDn2a13 3.172450e-014
Cn1an2a8 TDn1a15 TDn2a15 3.172450e-014
Cn1an2a9 TDn1a17 TDn2a17 3.172450e-014
Cn1an2a10 TDn1a19 TDn2a19 3.172450e-014
Cn1an2a11 TDn1a21 TDn2a21 3.172450e-014
Cn1an2a12 TDn1a23 TDn2a23 3.172450e-014
Cn1an2a13 TDn1a25 TDn2a25 3.172450e-014
Cn1an2a14 TDn1a27 TDn2a27 3.172450e-014
Cn1an2a15 TDn1a29 TDn2a29 3.172450e-014
Cn1an2a16 TDn1a31 TDn2a31 3.172450e-014
Cn1an2a17 TDn1a33 TDn2a33 1.586220e-014
Cn1an3a1 TDn1a1 TDn3a1 5.674250e-015
Cn1an3a2 TDn1a3 TDn3a3 1.134850e-014
Cn1an3a3 TDn1a5 TDn3a5 1.134850e-014
Cn1an3a4 TDn1a7 TDn3a7 1.134850e-014
Cn1an3a5 TDn1a9 TDn3a9 1.134850e-014
Cn1an3a6 TDn1a11 TDn3a11 1.134850e-014
Cn1an3a7 TDn1a13 TDn3a13 1.134850e-014
Cn1an3a8 TDn1a15 TDn3a15 1.134850e-014
Cn1an3a9 TDn1a17 TDn3a17 1.134850e-014
Cn1an3a10 TDn1a19 TDn3a19 1.134850e-014
Cn1an3a11 TDn1a21 TDn3a21 1.134850e-014
Cn1an3a12 TDn1a23 TDn3a23 1.134850e-014
Cn1an3a13 TDn1a25 TDn3a25 1.134850e-014
Cn1an3a14 TDn1a27 TDn3a27 1.134850e-014
Cn1an3a15 TDn1a29 TDn3a29 1.134850e-014
Cn1an3a16 TDn1a31 TDn3a31 1.134850e-014
Cn1an3a17 TDn1a33 TDn3a33 5.674250e-015
Cn1an4a1 TDn1a1 TDn4a1 5.219520e-015
Cn1an4a2 TDn1a3 TDn4a3 1.043900e-014
Cn1an4a3 TDn1a5 TDn4a5 1.043900e-014
Cn1an4a4 TDn1a7 TDn4a7 1.043900e-014
Cn1an4a5 TDn1a9 TDn4a9 1.043900e-014
Cn1an4a6 TDn1a11 TDn4a11 1.043900e-014
Cn1an4a7 TDn1a13 TDn4a13 1.043900e-014
Cn1an4a8 TDn1a15 TDn4a15 1.043900e-014
Cn1an4a9 TDn1a17 TDn4a17 1.043900e-014
Cn1an4a10 TDn1a19 TDn4a19 1.043900e-014
Cn1an4a11 TDn1a21 TDn4a21 1.043900e-014
Cn1an4a12 TDn1a23 TDn4a23 1.043900e-014
Cn1an4a13 TDn1a25 TDn4a25 1.043900e-014
Cn1an4a14 TDn1a27 TDn4a27 1.043900e-014
Cn1an4a15 TDn1a29 TDn4a29 1.043900e-014
Cn1an4a16 TDn1a31 TDn4a31 1.043900e-014
Cn1an4a17 TDn1a33 TDn4a33 5.219520e-015
Cn1an5a1 TDn1a1 TDn5a1 5.062210e-015
Cn1an5a2 TDn1a3 TDn5a3 1.012440e-014
Cn1an5a3 TDn1a5 TDn5a5 1.012440e-014
Cn1an5a4 TDn1a7 TDn5a7 1.012440e-014
Cn1an5a5 TDn1a9 TDn5a9 1.012440e-014
Cn1an5a6 TDn1a11 TDn5a11 1.012440e-014
Cn1an5a7 TDn1a13 TDn5a13 1.012440e-014
Cn1an5a8 TDn1a15 TDn5a15 1.012440e-014
Cn1an5a9 TDn1a17 TDn5a17 1.012440e-014
Cn1an5a10 TDn1a19 TDn5a19 1.012440e-014
Cn1an5a11 TDn1a21 TDn5a21 1.012440e-014
Cn1an5a12 TDn1a23 TDn5a23 1.012440e-014
Cn1an5a13 TDn1a25 TDn5a25 1.012440e-014
Cn1an5a14 TDn1a27 TDn5a27 1.012440e-014
Cn1an5a15 TDn1a29 TDn5a29 1.012440e-014
Cn1an5a16 TDn1a31 TDn5a31 1.012440e-014
Cn1an5a17 TDn1a33 TDn5a33 5.062210e-015
Cn1an6a1 TDn1a1 TDn6a1 5.003840e-015
Cn1an6a2 TDn1a3 TDn6a3 1.000770e-014
Cn1an6a3 TDn1a5 TDn6a5 1.000770e-014
Cn1an6a4 TDn1a7 TDn6a7 1.000770e-014
Cn1an6a5 TDn1a9 TDn6a9 1.000770e-014
Cn1an6a6 TDn1a11 TDn6a11 1.000770e-014
Cn1an6a7 TDn1a13 TDn6a13 1.000770e-014
Cn1an6a8 TDn1a15 TDn6a15 1.000770e-014
Cn1an6a9 TDn1a17 TDn6a17 1.000770e-014
Cn1an6a10 TDn1a19 TDn6a19 1.000770e-014
Cn1an6a11 TDn1a21 TDn6a21 1.000770e-014
Cn1an6a12 TDn1a23 TDn6a23 1.000770e-014
Cn1an6a13 TDn1a25 TDn6a25 1.000770e-014
Cn1an6a14 TDn1a27 TDn6a27 1.000770e-014
Cn1an6a15 TDn1a29 TDn6a29 1.000770e-014
Cn1an6a16 TDn1a31 TDn6a31 1.000770e-014
Cn1an6a17 TDn1a33 TDn6a33 5.003840e-015
Cn1an7a1 TDn1a1 TDn7a1 4.990870e-015
Cn1an7a2 TDn1a3 TDn7a3 9.981750e-015
Cn1an7a3 TDn1a5 TDn7a5 9.981750e-015
Cn1an7a4 TDn1a7 TDn7a7 9.981750e-015
Cn1an7a5 TDn1a9 TDn7a9 9.981750e-015
Cn1an7a6 TDn1a11 TDn7a11 9.981750e-015
Cn1an7a7 TDn1a13 TDn7a13 9.981750e-015
Cn1an7a8 TDn1a15 TDn7a15 9.981750e-015
Cn1an7a9 TDn1a17 TDn7a17 9.981750e-015
Cn1an7a10 TDn1a19 TDn7a19 9.981750e-015
Cn1an7a11 TDn1a21 TDn7a21 9.981750e-015
Cn1an7a12 TDn1a23 TDn7a23 9.981750e-015
Cn1an7a13 TDn1a25 TDn7a25 9.981750e-015
Cn1an7a14 TDn1a27 TDn7a27 9.981750e-015
Cn1an7a15 TDn1a29 TDn7a29 9.981750e-015
Cn1an7a16 TDn1a31 TDn7a31 9.981750e-015
Cn1an7a17 TDn1a33 TDn7a33 4.990870e-015
Cn1an8a1 TDn1a1 TDn8a1 5.026740e-015
Cn1an8a2 TDn1a3 TDn8a3 1.005350e-014
Cn1an8a3 TDn1a5 TDn8a5 1.005350e-014
Cn1an8a4 TDn1a7 TDn8a7 1.005350e-014
Cn1an8a5 TDn1a9 TDn8a9 1.005350e-014
Cn1an8a6 TDn1a11 TDn8a11 1.005350e-014
Cn1an8a7 TDn1a13 TDn8a13 1.005350e-014
Cn1an8a8 TDn1a15 TDn8a15 1.005350e-014
Cn1an8a9 TDn1a17 TDn8a17 1.005350e-014
Cn1an8a10 TDn1a19 TDn8a19 1.005350e-014
Cn1an8a11 TDn1a21 TDn8a21 1.005350e-014
Cn1an8a12 TDn1a23 TDn8a23 1.005350e-014
Cn1an8a13 TDn1a25 TDn8a25 1.005350e-014
Cn1an8a14 TDn1a27 TDn8a27 1.005350e-014
Cn1an8a15 TDn1a29 TDn8a29 1.005350e-014
Cn1an8a16 TDn1a31 TDn8a31 1.005350e-014
Cn1an8a17 TDn1a33 TDn8a33 5.026740e-015
Cn1an9a1 TDn1a1 TDn9a1 5.751040e-015
Cn1an9a2 TDn1a3 TDn9a3 1.150210e-014
Cn1an9a3 TDn1a5 TDn9a5 1.150210e-014
Cn1an9a4 TDn1a7 TDn9a7 1.150210e-014
Cn1an9a5 TDn1a9 TDn9a9 1.150210e-014
Cn1an9a6 TDn1a11 TDn9a11 1.150210e-014
Cn1an9a7 TDn1a13 TDn9a13 1.150210e-014
Cn1an9a8 TDn1a15 TDn9a15 1.150210e-014
Cn1an9a9 TDn1a17 TDn9a17 1.150210e-014
Cn1an9a10 TDn1a19 TDn9a19 1.150210e-014
Cn1an9a11 TDn1a21 TDn9a21 1.150210e-014
Cn1an9a12 TDn1a23 TDn9a23 1.150210e-014
Cn1an9a13 TDn1a25 TDn9a25 1.150210e-014
Cn1an9a14 TDn1a27 TDn9a27 1.150210e-014
Cn1an9a15 TDn1a29 TDn9a29 1.150210e-014
Cn1an9a16 TDn1a31 TDn9a31 1.150210e-014
Cn1an9a17 TDn1a33 TDn9a33 5.751040e-015
Cn1an10a1 TDn1a1 TDn10a1 1.690880e-014
Cn1an10a2 TDn1a3 TDn10a3 1.302320e-014
Cn1an10a3 TDn1a5 TDn10a5 1.302320e-014
Cn1an10a4 TDn1a7 TDn10a7 1.302320e-014
Cn1an10a5 TDn1a9 TDn10a9 1.302320e-014
Cn1an10a6 TDn1a11 TDn10a11 1.302320e-014
Cn1an10a7 TDn1a13 TDn10a13 1.302320e-014
Cn1an10a8 TDn1a15 TDn10a15 1.302320e-014
Cn1an10a9 TDn1a17 TDn10a17 1.302320e-014
Cn1an10a10 TDn1a19 TDn10a19 1.302320e-014
Cn1an10a11 TDn1a21 TDn10a21 1.302320e-014
Cn1an10a12 TDn1a23 TDn10a23 1.302320e-014
Cn1an10a13 TDn1a25 TDn10a25 1.302320e-014
Cn1an10a14 TDn1a27 TDn10a27 1.302320e-014
Cn1an10a15 TDn1a29 TDn10a29 1.302320e-014
Cn1an10a16 TDn1a31 TDn10a31 1.302320e-014
Cn1an10a17 TDn1a33 TDn10a33 1.690880e-014
Cn1an11a1 TDn1a1 TDn11a1 1.690880e-014
Cn1an11a2 TDn1a3 TDn11a3 1.302320e-014
Cn1an11a3 TDn1a5 TDn11a5 1.302320e-014
Cn1an11a4 TDn1a7 TDn11a7 1.302320e-014
Cn1an11a5 TDn1a9 TDn11a9 1.302320e-014
Cn1an11a6 TDn1a11 TDn11a11 1.302320e-014
Cn1an11a7 TDn1a13 TDn11a13 1.302320e-014
Cn1an11a8 TDn1a15 TDn11a15 1.302320e-014
Cn1an11a9 TDn1a17 TDn11a17 1.302320e-014
Cn1an11a10 TDn1a19 TDn11a19 1.302320e-014
Cn1an11a11 TDn1a21 TDn11a21 1.302320e-014
Cn1an11a12 TDn1a23 TDn11a23 1.302320e-014
Cn1an11a13 TDn1a25 TDn11a25 1.302320e-014
Cn1an11a14 TDn1a27 TDn11a27 1.302320e-014
Cn1an11a15 TDn1a29 TDn11a29 1.302320e-014
Cn1an11a16 TDn1a31 TDn11a31 1.302320e-014
Cn1an11a17 TDn1a33 TDn11a33 1.690880e-014
Cn1an12a1 TDn1a1 TDn12a1 1.690880e-014
Cn1an12a2 TDn1a3 TDn12a3 1.302320e-014
Cn1an12a3 TDn1a5 TDn12a5 1.302320e-014
Cn1an12a4 TDn1a7 TDn12a7 1.302320e-014
Cn1an12a5 TDn1a9 TDn12a9 1.302320e-014
Cn1an12a6 TDn1a11 TDn12a11 1.302320e-014
Cn1an12a7 TDn1a13 TDn12a13 1.302320e-014
Cn1an12a8 TDn1a15 TDn12a15 1.302320e-014
Cn1an12a9 TDn1a17 TDn12a17 1.302320e-014
Cn1an12a10 TDn1a19 TDn12a19 1.302320e-014
Cn1an12a11 TDn1a21 TDn12a21 1.302320e-014
Cn1an12a12 TDn1a23 TDn12a23 1.302320e-014
Cn1an12a13 TDn1a25 TDn12a25 1.302320e-014
Cn1an12a14 TDn1a27 TDn12a27 1.302320e-014
Cn1an12a15 TDn1a29 TDn12a29 1.302320e-014
Cn1an12a16 TDn1a31 TDn12a31 1.302320e-014
Cn1an12a17 TDn1a33 TDn12a33 1.690880e-014
Cn1an13a1 TDn1a1 TDn13a1 1.690880e-014
Cn1an13a2 TDn1a3 TDn13a3 1.302320e-014
Cn1an13a3 TDn1a5 TDn13a5 1.302320e-014
Cn1an13a4 TDn1a7 TDn13a7 1.302320e-014
Cn1an13a5 TDn1a9 TDn13a9 1.302320e-014
Cn1an13a6 TDn1a11 TDn13a11 1.302320e-014
Cn1an13a7 TDn1a13 TDn13a13 1.302320e-014
Cn1an13a8 TDn1a15 TDn13a15 1.302320e-014
Cn1an13a9 TDn1a17 TDn13a17 1.302320e-014
Cn1an13a10 TDn1a19 TDn13a19 1.302320e-014
Cn1an13a11 TDn1a21 TDn13a21 1.302320e-014
Cn1an13a12 TDn1a23 TDn13a23 1.302320e-014
Cn1an13a13 TDn1a25 TDn13a25 1.302320e-014
Cn1an13a14 TDn1a27 TDn13a27 1.302320e-014
Cn1an13a15 TDn1a29 TDn13a29 1.302320e-014
Cn1an13a16 TDn1a31 TDn13a31 1.302320e-014
Cn1an13a17 TDn1a33 TDn13a33 1.690880e-014
Cn1an14a1 TDn1a1 TDn14a1 1.690880e-014
Cn1an14a2 TDn1a3 TDn14a3 1.302320e-014
Cn1an14a3 TDn1a5 TDn14a5 1.302320e-014
Cn1an14a4 TDn1a7 TDn14a7 1.302320e-014
Cn1an14a5 TDn1a9 TDn14a9 1.302320e-014
Cn1an14a6 TDn1a11 TDn14a11 1.302320e-014
Cn1an14a7 TDn1a13 TDn14a13 1.302320e-014
Cn1an14a8 TDn1a15 TDn14a15 1.302320e-014
Cn1an14a9 TDn1a17 TDn14a17 1.302320e-014
Cn1an14a10 TDn1a19 TDn14a19 1.302320e-014
Cn1an14a11 TDn1a21 TDn14a21 1.302320e-014
Cn1an14a12 TDn1a23 TDn14a23 1.302320e-014
Cn1an14a13 TDn1a25 TDn14a25 1.302320e-014
Cn1an14a14 TDn1a27 TDn14a27 1.302320e-014
Cn1an14a15 TDn1a29 TDn14a29 1.302320e-014
Cn1an14a16 TDn1a31 TDn14a31 1.302320e-014
Cn1an14a17 TDn1a33 TDn14a33 1.690880e-014
Cn1an15a1 TDn1a1 TDn15a1 1.690880e-014
Cn1an15a2 TDn1a3 TDn15a3 1.302320e-014
Cn1an15a3 TDn1a5 TDn15a5 1.302320e-014
Cn1an15a4 TDn1a7 TDn15a7 1.302320e-014
Cn1an15a5 TDn1a9 TDn15a9 1.302320e-014
Cn1an15a6 TDn1a11 TDn15a11 1.302320e-014
Cn1an15a7 TDn1a13 TDn15a13 1.302320e-014
Cn1an15a8 TDn1a15 TDn15a15 1.302320e-014
Cn1an15a9 TDn1a17 TDn15a17 1.302320e-014
Cn1an15a10 TDn1a19 TDn15a19 1.302320e-014
Cn1an15a11 TDn1a21 TDn15a21 1.302320e-014
Cn1an15a12 TDn1a23 TDn15a23 1.302320e-014
Cn1an15a13 TDn1a25 TDn15a25 1.302320e-014
Cn1an15a14 TDn1a27 TDn15a27 1.302320e-014
Cn1an15a15 TDn1a29 TDn15a29 1.302320e-014
Cn1an15a16 TDn1a31 TDn15a31 1.302320e-014
Cn1an15a17 TDn1a33 TDn15a33 1.690880e-014
Cn1an16a1 TDn1a1 TDn16a1 1.690880e-014
Cn1an16a2 TDn1a3 TDn16a3 1.302320e-014
Cn1an16a3 TDn1a5 TDn16a5 1.302320e-014
Cn1an16a4 TDn1a7 TDn16a7 1.302320e-014
Cn1an16a5 TDn1a9 TDn16a9 1.302320e-014
Cn1an16a6 TDn1a11 TDn16a11 1.302320e-014
Cn1an16a7 TDn1a13 TDn16a13 1.302320e-014
Cn1an16a8 TDn1a15 TDn16a15 1.302320e-014
Cn1an16a9 TDn1a17 TDn16a17 1.302320e-014
Cn1an16a10 TDn1a19 TDn16a19 1.302320e-014
Cn1an16a11 TDn1a21 TDn16a21 1.302320e-014
Cn1an16a12 TDn1a23 TDn16a23 1.302320e-014
Cn1an16a13 TDn1a25 TDn16a25 1.302320e-014
Cn1an16a14 TDn1a27 TDn16a27 1.302320e-014
Cn1an16a15 TDn1a29 TDn16a29 1.302320e-014
Cn1an16a16 TDn1a31 TDn16a31 1.302320e-014
Cn1an16a17 TDn1a33 TDn16a33 1.690880e-014
Cn1an17a1 TDn1a1 TDn17a1 1.690880e-014
Cn1an17a2 TDn1a3 TDn17a3 1.302320e-014
Cn1an17a3 TDn1a5 TDn17a5 1.302320e-014
Cn1an17a4 TDn1a7 TDn17a7 1.302320e-014
Cn1an17a5 TDn1a9 TDn17a9 1.302320e-014
Cn1an17a6 TDn1a11 TDn17a11 1.302320e-014
Cn1an17a7 TDn1a13 TDn17a13 1.302320e-014
Cn1an17a8 TDn1a15 TDn17a15 1.302320e-014
Cn1an17a9 TDn1a17 TDn17a17 1.302320e-014
Cn1an17a10 TDn1a19 TDn17a19 1.302320e-014
Cn1an17a11 TDn1a21 TDn17a21 1.302320e-014
Cn1an17a12 TDn1a23 TDn17a23 1.302320e-014
Cn1an17a13 TDn1a25 TDn17a25 1.302320e-014
Cn1an17a14 TDn1a27 TDn17a27 1.302320e-014
Cn1an17a15 TDn1a29 TDn17a29 1.302320e-014
Cn1an17a16 TDn1a31 TDn17a31 1.302320e-014
Cn1an17a17 TDn1a33 TDn17a33 1.690880e-014
Cn1an18a1 TDn1a1 TDn18a1 1.690880e-014
Cn1an18a2 TDn1a3 TDn18a3 1.302320e-014
Cn1an18a3 TDn1a5 TDn18a5 1.302320e-014
Cn1an18a4 TDn1a7 TDn18a7 1.302320e-014
Cn1an18a5 TDn1a9 TDn18a9 1.302320e-014
Cn1an18a6 TDn1a11 TDn18a11 1.302320e-014
Cn1an18a7 TDn1a13 TDn18a13 1.302320e-014
Cn1an18a8 TDn1a15 TDn18a15 1.302320e-014
Cn1an18a9 TDn1a17 TDn18a17 1.302320e-014
Cn1an18a10 TDn1a19 TDn18a19 1.302320e-014
Cn1an18a11 TDn1a21 TDn18a21 1.302320e-014
Cn1an18a12 TDn1a23 TDn18a23 1.302320e-014
Cn1an18a13 TDn1a25 TDn18a25 1.302320e-014
Cn1an18a14 TDn1a27 TDn18a27 1.302320e-014
Cn1an18a15 TDn1a29 TDn18a29 1.302320e-014
Cn1an18a16 TDn1a31 TDn18a31 1.302320e-014
Cn1an18a17 TDn1a33 TDn18a33 1.690880e-014
Cn1an19a1 TDn1a1 TDn19a1 1.690880e-014
Cn1an19a2 TDn1a3 TDn19a3 1.302320e-014
Cn1an19a3 TDn1a5 TDn19a5 1.302320e-014
Cn1an19a4 TDn1a7 TDn19a7 1.302320e-014
Cn1an19a5 TDn1a9 TDn19a9 1.302320e-014
Cn1an19a6 TDn1a11 TDn19a11 1.302320e-014
Cn1an19a7 TDn1a13 TDn19a13 1.302320e-014
Cn1an19a8 TDn1a15 TDn19a15 1.302320e-014
Cn1an19a9 TDn1a17 TDn19a17 1.302320e-014
Cn1an19a10 TDn1a19 TDn19a19 1.302320e-014
Cn1an19a11 TDn1a21 TDn19a21 1.302320e-014
Cn1an19a12 TDn1a23 TDn19a23 1.302320e-014
Cn1an19a13 TDn1a25 TDn19a25 1.302320e-014
Cn1an19a14 TDn1a27 TDn19a27 1.302320e-014
Cn1an19a15 TDn1a29 TDn19a29 1.302320e-014
Cn1an19a16 TDn1a31 TDn19a31 1.302320e-014
Cn1an19a17 TDn1a33 TDn19a33 1.690880e-014
Cn1an20a1 TDn1a1 TDn20a1 1.690880e-014
Cn1an20a2 TDn1a3 TDn20a3 1.302320e-014
Cn1an20a3 TDn1a5 TDn20a5 1.302320e-014
Cn1an20a4 TDn1a7 TDn20a7 1.302320e-014
Cn1an20a5 TDn1a9 TDn20a9 1.302320e-014
Cn1an20a6 TDn1a11 TDn20a11 1.302320e-014
Cn1an20a7 TDn1a13 TDn20a13 1.302320e-014
Cn1an20a8 TDn1a15 TDn20a15 1.302320e-014
Cn1an20a9 TDn1a17 TDn20a17 1.302320e-014
Cn1an20a10 TDn1a19 TDn20a19 1.302320e-014
Cn1an20a11 TDn1a21 TDn20a21 1.302320e-014
Cn1an20a12 TDn1a23 TDn20a23 1.302320e-014
Cn1an20a13 TDn1a25 TDn20a25 1.302320e-014
Cn1an20a14 TDn1a27 TDn20a27 1.302320e-014
Cn1an20a15 TDn1a29 TDn20a29 1.302320e-014
Cn1an20a16 TDn1a31 TDn20a31 1.302320e-014
Cn1an20a17 TDn1a33 TDn20a33 1.690880e-014
Cn1an21a1 TDn1a1 TDn21a1 1.690880e-014
Cn1an21a2 TDn1a3 TDn21a3 1.302320e-014
Cn1an21a3 TDn1a5 TDn21a5 1.302320e-014
Cn1an21a4 TDn1a7 TDn21a7 1.302320e-014
Cn1an21a5 TDn1a9 TDn21a9 1.302320e-014
Cn1an21a6 TDn1a11 TDn21a11 1.302320e-014
Cn1an21a7 TDn1a13 TDn21a13 1.302320e-014
Cn1an21a8 TDn1a15 TDn21a15 1.302320e-014
Cn1an21a9 TDn1a17 TDn21a17 1.302320e-014
Cn1an21a10 TDn1a19 TDn21a19 1.302320e-014
Cn1an21a11 TDn1a21 TDn21a21 1.302320e-014
Cn1an21a12 TDn1a23 TDn21a23 1.302320e-014
Cn1an21a13 TDn1a25 TDn21a25 1.302320e-014
Cn1an21a14 TDn1a27 TDn21a27 1.302320e-014
Cn1an21a15 TDn1a29 TDn21a29 1.302320e-014
Cn1an21a16 TDn1a31 TDn21a31 1.302320e-014
Cn1an21a17 TDn1a33 TDn21a33 1.690880e-014
Cn1an22a1 TDn1a1 TDn22a1 1.690880e-014
Cn1an22a2 TDn1a3 TDn22a3 1.302320e-014
Cn1an22a3 TDn1a5 TDn22a5 1.302320e-014
Cn1an22a4 TDn1a7 TDn22a7 1.302320e-014
Cn1an22a5 TDn1a9 TDn22a9 1.302320e-014
Cn1an22a6 TDn1a11 TDn22a11 1.302320e-014
Cn1an22a7 TDn1a13 TDn22a13 1.302320e-014
Cn1an22a8 TDn1a15 TDn22a15 1.302320e-014
Cn1an22a9 TDn1a17 TDn22a17 1.302320e-014
Cn1an22a10 TDn1a19 TDn22a19 1.302320e-014
Cn1an22a11 TDn1a21 TDn22a21 1.302320e-014
Cn1an22a12 TDn1a23 TDn22a23 1.302320e-014
Cn1an22a13 TDn1a25 TDn22a25 1.302320e-014
Cn1an22a14 TDn1a27 TDn22a27 1.302320e-014
Cn1an22a15 TDn1a29 TDn22a29 1.302320e-014
Cn1an22a16 TDn1a31 TDn22a31 1.302320e-014
Cn1an22a17 TDn1a33 TDn22a33 1.690880e-014
Cn1an23a1 TDn1a1 TDn23a1 1.690880e-014
Cn1an23a2 TDn1a3 TDn23a3 1.302320e-014
Cn1an23a3 TDn1a5 TDn23a5 1.302320e-014
Cn1an23a4 TDn1a7 TDn23a7 1.302320e-014
Cn1an23a5 TDn1a9 TDn23a9 1.302320e-014
Cn1an23a6 TDn1a11 TDn23a11 1.302320e-014
Cn1an23a7 TDn1a13 TDn23a13 1.302320e-014
Cn1an23a8 TDn1a15 TDn23a15 1.302320e-014
Cn1an23a9 TDn1a17 TDn23a17 1.302320e-014
Cn1an23a10 TDn1a19 TDn23a19 1.302320e-014
Cn1an23a11 TDn1a21 TDn23a21 1.302320e-014
Cn1an23a12 TDn1a23 TDn23a23 1.302320e-014
Cn1an23a13 TDn1a25 TDn23a25 1.302320e-014
Cn1an23a14 TDn1a27 TDn23a27 1.302320e-014
Cn1an23a15 TDn1a29 TDn23a29 1.302320e-014
Cn1an23a16 TDn1a31 TDn23a31 1.302320e-014
Cn1an23a17 TDn1a33 TDn23a33 1.690880e-014
Cn1an24a1 TDn1a1 TDn24a1 1.690880e-014
Cn1an24a2 TDn1a3 TDn24a3 1.302320e-014
Cn1an24a3 TDn1a5 TDn24a5 1.302320e-014
Cn1an24a4 TDn1a7 TDn24a7 1.302320e-014
Cn1an24a5 TDn1a9 TDn24a9 1.302320e-014
Cn1an24a6 TDn1a11 TDn24a11 1.302320e-014
Cn1an24a7 TDn1a13 TDn24a13 1.302320e-014
Cn1an24a8 TDn1a15 TDn24a15 1.302320e-014
Cn1an24a9 TDn1a17 TDn24a17 1.302320e-014
Cn1an24a10 TDn1a19 TDn24a19 1.302320e-014
Cn1an24a11 TDn1a21 TDn24a21 1.302320e-014
Cn1an24a12 TDn1a23 TDn24a23 1.302320e-014
Cn1an24a13 TDn1a25 TDn24a25 1.302320e-014
Cn1an24a14 TDn1a27 TDn24a27 1.302320e-014
Cn1an24a15 TDn1a29 TDn24a29 1.302320e-014
Cn1an24a16 TDn1a31 TDn24a31 1.302320e-014
Cn1an24a17 TDn1a33 TDn24a33 1.690880e-014
Cn1an25a1 TDn1a1 TDn25a1 1.690880e-014
Cn1an25a2 TDn1a3 TDn25a3 1.302320e-014
Cn1an25a3 TDn1a5 TDn25a5 1.302320e-014
Cn1an25a4 TDn1a7 TDn25a7 1.302320e-014
Cn1an25a5 TDn1a9 TDn25a9 1.302320e-014
Cn1an25a6 TDn1a11 TDn25a11 1.302320e-014
Cn1an25a7 TDn1a13 TDn25a13 1.302320e-014
Cn1an25a8 TDn1a15 TDn25a15 1.302320e-014
Cn1an25a9 TDn1a17 TDn25a17 1.302320e-014
Cn1an25a10 TDn1a19 TDn25a19 1.302320e-014
Cn1an25a11 TDn1a21 TDn25a21 1.302320e-014
Cn1an25a12 TDn1a23 TDn25a23 1.302320e-014
Cn1an25a13 TDn1a25 TDn25a25 1.302320e-014
Cn1an25a14 TDn1a27 TDn25a27 1.302320e-014
Cn1an25a15 TDn1a29 TDn25a29 1.302320e-014
Cn1an25a16 TDn1a31 TDn25a31 1.302320e-014
Cn1an25a17 TDn1a33 TDn25a33 1.690880e-014
Cn1an26a1 TDn1a1 TDn26a1 1.690880e-014
Cn1an26a2 TDn1a3 TDn26a3 1.302320e-014
Cn1an26a3 TDn1a5 TDn26a5 1.302320e-014
Cn1an26a4 TDn1a7 TDn26a7 1.302320e-014
Cn1an26a5 TDn1a9 TDn26a9 1.302320e-014
Cn1an26a6 TDn1a11 TDn26a11 1.302320e-014
Cn1an26a7 TDn1a13 TDn26a13 1.302320e-014
Cn1an26a8 TDn1a15 TDn26a15 1.302320e-014
Cn1an26a9 TDn1a17 TDn26a17 1.302320e-014
Cn1an26a10 TDn1a19 TDn26a19 1.302320e-014
Cn1an26a11 TDn1a21 TDn26a21 1.302320e-014
Cn1an26a12 TDn1a23 TDn26a23 1.302320e-014
Cn1an26a13 TDn1a25 TDn26a25 1.302320e-014
Cn1an26a14 TDn1a27 TDn26a27 1.302320e-014
Cn1an26a15 TDn1a29 TDn26a29 1.302320e-014
Cn1an26a16 TDn1a31 TDn26a31 1.302320e-014
Cn1an26a17 TDn1a33 TDn26a33 1.690880e-014
Cn1an27a1 TDn1a1 TDn27a1 1.690880e-014
Cn1an27a2 TDn1a3 TDn27a3 1.302320e-014
Cn1an27a3 TDn1a5 TDn27a5 1.302320e-014
Cn1an27a4 TDn1a7 TDn27a7 1.302320e-014
Cn1an27a5 TDn1a9 TDn27a9 1.302320e-014
Cn1an27a6 TDn1a11 TDn27a11 1.302320e-014
Cn1an27a7 TDn1a13 TDn27a13 1.302320e-014
Cn1an27a8 TDn1a15 TDn27a15 1.302320e-014
Cn1an27a9 TDn1a17 TDn27a17 1.302320e-014
Cn1an27a10 TDn1a19 TDn27a19 1.302320e-014
Cn1an27a11 TDn1a21 TDn27a21 1.302320e-014
Cn1an27a12 TDn1a23 TDn27a23 1.302320e-014
Cn1an27a13 TDn1a25 TDn27a25 1.302320e-014
Cn1an27a14 TDn1a27 TDn27a27 1.302320e-014
Cn1an27a15 TDn1a29 TDn27a29 1.302320e-014
Cn1an27a16 TDn1a31 TDn27a31 1.302320e-014
Cn1an27a17 TDn1a33 TDn27a33 1.690880e-014
Cn1an28a1 TDn1a1 TDn28a1 1.690880e-014
Cn1an28a2 TDn1a3 TDn28a3 1.302320e-014
Cn1an28a3 TDn1a5 TDn28a5 1.302320e-014
Cn1an28a4 TDn1a7 TDn28a7 1.302320e-014
Cn1an28a5 TDn1a9 TDn28a9 1.302320e-014
Cn1an28a6 TDn1a11 TDn28a11 1.302320e-014
Cn1an28a7 TDn1a13 TDn28a13 1.302320e-014
Cn1an28a8 TDn1a15 TDn28a15 1.302320e-014
Cn1an28a9 TDn1a17 TDn28a17 1.302320e-014
Cn1an28a10 TDn1a19 TDn28a19 1.302320e-014
Cn1an28a11 TDn1a21 TDn28a21 1.302320e-014
Cn1an28a12 TDn1a23 TDn28a23 1.302320e-014
Cn1an28a13 TDn1a25 TDn28a25 1.302320e-014
Cn1an28a14 TDn1a27 TDn28a27 1.302320e-014
Cn1an28a15 TDn1a29 TDn28a29 1.302320e-014
Cn1an28a16 TDn1a31 TDn28a31 1.302320e-014
Cn1an28a17 TDn1a33 TDn28a33 1.690880e-014
Cn1an29a1 TDn1a1 TDn29a1 1.690880e-014
Cn1an29a2 TDn1a3 TDn29a3 1.302320e-014
Cn1an29a3 TDn1a5 TDn29a5 1.302320e-014
Cn1an29a4 TDn1a7 TDn29a7 1.302320e-014
Cn1an29a5 TDn1a9 TDn29a9 1.302320e-014
Cn1an29a6 TDn1a11 TDn29a11 1.302320e-014
Cn1an29a7 TDn1a13 TDn29a13 1.302320e-014
Cn1an29a8 TDn1a15 TDn29a15 1.302320e-014
Cn1an29a9 TDn1a17 TDn29a17 1.302320e-014
Cn1an29a10 TDn1a19 TDn29a19 1.302320e-014
Cn1an29a11 TDn1a21 TDn29a21 1.302320e-014
Cn1an29a12 TDn1a23 TDn29a23 1.302320e-014
Cn1an29a13 TDn1a25 TDn29a25 1.302320e-014
Cn1an29a14 TDn1a27 TDn29a27 1.302320e-014
Cn1an29a15 TDn1a29 TDn29a29 1.302320e-014
Cn1an29a16 TDn1a31 TDn29a31 1.302320e-014
Cn1an29a17 TDn1a33 TDn29a33 1.690880e-014
Cn1an30a1 TDn1a1 TDn30a1 1.690880e-014
Cn1an30a2 TDn1a3 TDn30a3 1.302320e-014
Cn1an30a3 TDn1a5 TDn30a5 1.302320e-014
Cn1an30a4 TDn1a7 TDn30a7 1.302320e-014
Cn1an30a5 TDn1a9 TDn30a9 1.302320e-014
Cn1an30a6 TDn1a11 TDn30a11 1.302320e-014
Cn1an30a7 TDn1a13 TDn30a13 1.302320e-014
Cn1an30a8 TDn1a15 TDn30a15 1.302320e-014
Cn1an30a9 TDn1a17 TDn30a17 1.302320e-014
Cn1an30a10 TDn1a19 TDn30a19 1.302320e-014
Cn1an30a11 TDn1a21 TDn30a21 1.302320e-014
Cn1an30a12 TDn1a23 TDn30a23 1.302320e-014
Cn1an30a13 TDn1a25 TDn30a25 1.302320e-014
Cn1an30a14 TDn1a27 TDn30a27 1.302320e-014
Cn1an30a15 TDn1a29 TDn30a29 1.302320e-014
Cn1an30a16 TDn1a31 TDn30a31 1.302320e-014
Cn1an30a17 TDn1a33 TDn30a33 1.690880e-014
Cn1an31a1 TDn1a1 TDn31a1 1.690880e-014
Cn1an31a2 TDn1a3 TDn31a3 1.302320e-014
Cn1an31a3 TDn1a5 TDn31a5 1.302320e-014
Cn1an31a4 TDn1a7 TDn31a7 1.302320e-014
Cn1an31a5 TDn1a9 TDn31a9 1.302320e-014
Cn1an31a6 TDn1a11 TDn31a11 1.302320e-014
Cn1an31a7 TDn1a13 TDn31a13 1.302320e-014
Cn1an31a8 TDn1a15 TDn31a15 1.302320e-014
Cn1an31a9 TDn1a17 TDn31a17 1.302320e-014
Cn1an31a10 TDn1a19 TDn31a19 1.302320e-014
Cn1an31a11 TDn1a21 TDn31a21 1.302320e-014
Cn1an31a12 TDn1a23 TDn31a23 1.302320e-014
Cn1an31a13 TDn1a25 TDn31a25 1.302320e-014
Cn1an31a14 TDn1a27 TDn31a27 1.302320e-014
Cn1an31a15 TDn1a29 TDn31a29 1.302320e-014
Cn1an31a16 TDn1a31 TDn31a31 1.302320e-014
Cn1an31a17 TDn1a33 TDn31a33 1.690880e-014
Cn1an32a1 TDn1a1 TDn32a1 1.690880e-014
Cn1an32a2 TDn1a3 TDn32a3 1.302320e-014
Cn1an32a3 TDn1a5 TDn32a5 1.302320e-014
Cn1an32a4 TDn1a7 TDn32a7 1.302320e-014
Cn1an32a5 TDn1a9 TDn32a9 1.302320e-014
Cn1an32a6 TDn1a11 TDn32a11 1.302320e-014
Cn1an32a7 TDn1a13 TDn32a13 1.302320e-014
Cn1an32a8 TDn1a15 TDn32a15 1.302320e-014
Cn1an32a9 TDn1a17 TDn32a17 1.302320e-014
Cn1an32a10 TDn1a19 TDn32a19 1.302320e-014
Cn1an32a11 TDn1a21 TDn32a21 1.302320e-014
Cn1an32a12 TDn1a23 TDn32a23 1.302320e-014
Cn1an32a13 TDn1a25 TDn32a25 1.302320e-014
Cn1an32a14 TDn1a27 TDn32a27 1.302320e-014
Cn1an32a15 TDn1a29 TDn32a29 1.302320e-014
Cn1an32a16 TDn1a31 TDn32a31 1.302320e-014
Cn1an32a17 TDn1a33 TDn32a33 1.690880e-014
Cn1anva1 TDn1a1 TDnva1 1.690880e-014
Cn1anva2 TDn1a3 TDnva3 1.690880e-014
Cn1anva3 TDn1a5 TDnva5 1.690880e-014
Cn1anva4 TDn1a7 TDnva7 1.690880e-014
Cn1anva5 TDn1a9 TDnva9 1.690880e-014
Cn1anva6 TDn1a11 TDnva11 1.690880e-014
Cn1anva7 TDn1a13 TDnva13 1.690880e-014
Cn1anva8 TDn1a15 TDnva15 1.690880e-014
Cn1anva9 TDn1a17 TDnva17 1.690880e-014
Cn1anva10 TDn1a19 TDnva19 1.690880e-014
Cn1anva11 TDn1a21 TDnva21 1.690880e-014
Cn1anva12 TDn1a23 TDnva23 1.690880e-014
Cn1anva13 TDn1a25 TDnva25 1.690880e-014
Cn1anva14 TDn1a27 TDnva27 1.690880e-014
Cn1anva15 TDn1a29 TDnva29 1.690880e-014
Cn1anva16 TDn1a31 TDnva31 1.690880e-014
Cn1anva17 TDn1a33 TDnva33 1.690880e-014
Cn2an3a1 TDn2a1 TDn3a1 1.576950e-014
Cn2an3a2 TDn2a3 TDn3a3 3.153910e-014
Cn2an3a3 TDn2a5 TDn3a5 3.153910e-014
Cn2an3a4 TDn2a7 TDn3a7 3.153910e-014
Cn2an3a5 TDn2a9 TDn3a9 3.153910e-014
Cn2an3a6 TDn2a11 TDn3a11 3.153910e-014
Cn2an3a7 TDn2a13 TDn3a13 3.153910e-014
Cn2an3a8 TDn2a15 TDn3a15 3.153910e-014
Cn2an3a9 TDn2a17 TDn3a17 3.153910e-014
Cn2an3a10 TDn2a19 TDn3a19 3.153910e-014
Cn2an3a11 TDn2a21 TDn3a21 3.153910e-014
Cn2an3a12 TDn2a23 TDn3a23 3.153910e-014
Cn2an3a13 TDn2a25 TDn3a25 3.153910e-014
Cn2an3a14 TDn2a27 TDn3a27 3.153910e-014
Cn2an3a15 TDn2a29 TDn3a29 3.153910e-014
Cn2an3a16 TDn2a31 TDn3a31 3.153910e-014
Cn2an3a17 TDn2a33 TDn3a33 1.576950e-014
Cn2an4a1 TDn2a1 TDn4a1 5.623050e-015
Cn2an4a2 TDn2a3 TDn4a3 1.124610e-014
Cn2an4a3 TDn2a5 TDn4a5 1.124610e-014
Cn2an4a4 TDn2a7 TDn4a7 1.124610e-014
Cn2an4a5 TDn2a9 TDn4a9 1.124610e-014
Cn2an4a6 TDn2a11 TDn4a11 1.124610e-014
Cn2an4a7 TDn2a13 TDn4a13 1.124610e-014
Cn2an4a8 TDn2a15 TDn4a15 1.124610e-014
Cn2an4a9 TDn2a17 TDn4a17 1.124610e-014
Cn2an4a10 TDn2a19 TDn4a19 1.124610e-014
Cn2an4a11 TDn2a21 TDn4a21 1.124610e-014
Cn2an4a12 TDn2a23 TDn4a23 1.124610e-014
Cn2an4a13 TDn2a25 TDn4a25 1.124610e-014
Cn2an4a14 TDn2a27 TDn4a27 1.124610e-014
Cn2an4a15 TDn2a29 TDn4a29 1.124610e-014
Cn2an4a16 TDn2a31 TDn4a31 1.124610e-014
Cn2an4a17 TDn2a33 TDn4a33 5.623050e-015
Cn2an5a1 TDn2a1 TDn5a1 5.149670e-015
Cn2an5a2 TDn2a3 TDn5a3 1.029930e-014
Cn2an5a3 TDn2a5 TDn5a5 1.029930e-014
Cn2an5a4 TDn2a7 TDn5a7 1.029930e-014
Cn2an5a5 TDn2a9 TDn5a9 1.029930e-014
Cn2an5a6 TDn2a11 TDn5a11 1.029930e-014
Cn2an5a7 TDn2a13 TDn5a13 1.029930e-014
Cn2an5a8 TDn2a15 TDn5a15 1.029930e-014
Cn2an5a9 TDn2a17 TDn5a17 1.029930e-014
Cn2an5a10 TDn2a19 TDn5a19 1.029930e-014
Cn2an5a11 TDn2a21 TDn5a21 1.029930e-014
Cn2an5a12 TDn2a23 TDn5a23 1.029930e-014
Cn2an5a13 TDn2a25 TDn5a25 1.029930e-014
Cn2an5a14 TDn2a27 TDn5a27 1.029930e-014
Cn2an5a15 TDn2a29 TDn5a29 1.029930e-014
Cn2an5a16 TDn2a31 TDn5a31 1.029930e-014
Cn2an5a17 TDn2a33 TDn5a33 5.149670e-015
Cn2an6a1 TDn2a1 TDn6a1 5.011480e-015
Cn2an6a2 TDn2a3 TDn6a3 1.002300e-014
Cn2an6a3 TDn2a5 TDn6a5 1.002300e-014
Cn2an6a4 TDn2a7 TDn6a7 1.002300e-014
Cn2an6a5 TDn2a9 TDn6a9 1.002300e-014
Cn2an6a6 TDn2a11 TDn6a11 1.002300e-014
Cn2an6a7 TDn2a13 TDn6a13 1.002300e-014
Cn2an6a8 TDn2a15 TDn6a15 1.002300e-014
Cn2an6a9 TDn2a17 TDn6a17 1.002300e-014
Cn2an6a10 TDn2a19 TDn6a19 1.002300e-014
Cn2an6a11 TDn2a21 TDn6a21 1.002300e-014
Cn2an6a12 TDn2a23 TDn6a23 1.002300e-014
Cn2an6a13 TDn2a25 TDn6a25 1.002300e-014
Cn2an6a14 TDn2a27 TDn6a27 1.002300e-014
Cn2an6a15 TDn2a29 TDn6a29 1.002300e-014
Cn2an6a16 TDn2a31 TDn6a31 1.002300e-014
Cn2an6a17 TDn2a33 TDn6a33 5.011480e-015
Cn2an7a1 TDn2a1 TDn7a1 4.968610e-015
Cn2an7a2 TDn2a3 TDn7a3 9.937210e-015
Cn2an7a3 TDn2a5 TDn7a5 9.937210e-015
Cn2an7a4 TDn2a7 TDn7a7 9.937210e-015
Cn2an7a5 TDn2a9 TDn7a9 9.937210e-015
Cn2an7a6 TDn2a11 TDn7a11 9.937210e-015
Cn2an7a7 TDn2a13 TDn7a13 9.937210e-015
Cn2an7a8 TDn2a15 TDn7a15 9.937210e-015
Cn2an7a9 TDn2a17 TDn7a17 9.937210e-015
Cn2an7a10 TDn2a19 TDn7a19 9.937210e-015
Cn2an7a11 TDn2a21 TDn7a21 9.937210e-015
Cn2an7a12 TDn2a23 TDn7a23 9.937210e-015
Cn2an7a13 TDn2a25 TDn7a25 9.937210e-015
Cn2an7a14 TDn2a27 TDn7a27 9.937210e-015
Cn2an7a15 TDn2a29 TDn7a29 9.937210e-015
Cn2an7a16 TDn2a31 TDn7a31 9.937210e-015
Cn2an7a17 TDn2a33 TDn7a33 4.968610e-015
Cn2an8a1 TDn2a1 TDn8a1 4.990350e-015
Cn2an8a2 TDn2a3 TDn8a3 9.980710e-015
Cn2an8a3 TDn2a5 TDn8a5 9.980710e-015
Cn2an8a4 TDn2a7 TDn8a7 9.980710e-015
Cn2an8a5 TDn2a9 TDn8a9 9.980710e-015
Cn2an8a6 TDn2a11 TDn8a11 9.980710e-015
Cn2an8a7 TDn2a13 TDn8a13 9.980710e-015
Cn2an8a8 TDn2a15 TDn8a15 9.980710e-015
Cn2an8a9 TDn2a17 TDn8a17 9.980710e-015
Cn2an8a10 TDn2a19 TDn8a19 9.980710e-015
Cn2an8a11 TDn2a21 TDn8a21 9.980710e-015
Cn2an8a12 TDn2a23 TDn8a23 9.980710e-015
Cn2an8a13 TDn2a25 TDn8a25 9.980710e-015
Cn2an8a14 TDn2a27 TDn8a27 9.980710e-015
Cn2an8a15 TDn2a29 TDn8a29 9.980710e-015
Cn2an8a16 TDn2a31 TDn8a31 9.980710e-015
Cn2an8a17 TDn2a33 TDn8a33 4.990350e-015
Cn2an9a1 TDn2a1 TDn9a1 5.701980e-015
Cn2an9a2 TDn2a3 TDn9a3 1.140400e-014
Cn2an9a3 TDn2a5 TDn9a5 1.140400e-014
Cn2an9a4 TDn2a7 TDn9a7 1.140400e-014
Cn2an9a5 TDn2a9 TDn9a9 1.140400e-014
Cn2an9a6 TDn2a11 TDn9a11 1.140400e-014
Cn2an9a7 TDn2a13 TDn9a13 1.140400e-014
Cn2an9a8 TDn2a15 TDn9a15 1.140400e-014
Cn2an9a9 TDn2a17 TDn9a17 1.140400e-014
Cn2an9a10 TDn2a19 TDn9a19 1.140400e-014
Cn2an9a11 TDn2a21 TDn9a21 1.140400e-014
Cn2an9a12 TDn2a23 TDn9a23 1.140400e-014
Cn2an9a13 TDn2a25 TDn9a25 1.140400e-014
Cn2an9a14 TDn2a27 TDn9a27 1.140400e-014
Cn2an9a15 TDn2a29 TDn9a29 1.140400e-014
Cn2an9a16 TDn2a31 TDn9a31 1.140400e-014
Cn2an9a17 TDn2a33 TDn9a33 5.701980e-015
Cn2an10a1 TDn2a1 TDn10a1 1.690880e-014
Cn2an10a2 TDn2a3 TDn10a3 1.302320e-014
Cn2an10a3 TDn2a5 TDn10a5 1.302320e-014
Cn2an10a4 TDn2a7 TDn10a7 1.302320e-014
Cn2an10a5 TDn2a9 TDn10a9 1.302320e-014
Cn2an10a6 TDn2a11 TDn10a11 1.302320e-014
Cn2an10a7 TDn2a13 TDn10a13 1.302320e-014
Cn2an10a8 TDn2a15 TDn10a15 1.302320e-014
Cn2an10a9 TDn2a17 TDn10a17 1.302320e-014
Cn2an10a10 TDn2a19 TDn10a19 1.302320e-014
Cn2an10a11 TDn2a21 TDn10a21 1.302320e-014
Cn2an10a12 TDn2a23 TDn10a23 1.302320e-014
Cn2an10a13 TDn2a25 TDn10a25 1.302320e-014
Cn2an10a14 TDn2a27 TDn10a27 1.302320e-014
Cn2an10a15 TDn2a29 TDn10a29 1.302320e-014
Cn2an10a16 TDn2a31 TDn10a31 1.302320e-014
Cn2an10a17 TDn2a33 TDn10a33 1.690880e-014
Cn2an11a1 TDn2a1 TDn11a1 1.690880e-014
Cn2an11a2 TDn2a3 TDn11a3 1.302320e-014
Cn2an11a3 TDn2a5 TDn11a5 1.302320e-014
Cn2an11a4 TDn2a7 TDn11a7 1.302320e-014
Cn2an11a5 TDn2a9 TDn11a9 1.302320e-014
Cn2an11a6 TDn2a11 TDn11a11 1.302320e-014
Cn2an11a7 TDn2a13 TDn11a13 1.302320e-014
Cn2an11a8 TDn2a15 TDn11a15 1.302320e-014
Cn2an11a9 TDn2a17 TDn11a17 1.302320e-014
Cn2an11a10 TDn2a19 TDn11a19 1.302320e-014
Cn2an11a11 TDn2a21 TDn11a21 1.302320e-014
Cn2an11a12 TDn2a23 TDn11a23 1.302320e-014
Cn2an11a13 TDn2a25 TDn11a25 1.302320e-014
Cn2an11a14 TDn2a27 TDn11a27 1.302320e-014
Cn2an11a15 TDn2a29 TDn11a29 1.302320e-014
Cn2an11a16 TDn2a31 TDn11a31 1.302320e-014
Cn2an11a17 TDn2a33 TDn11a33 1.690880e-014
Cn2an12a1 TDn2a1 TDn12a1 1.690880e-014
Cn2an12a2 TDn2a3 TDn12a3 1.302320e-014
Cn2an12a3 TDn2a5 TDn12a5 1.302320e-014
Cn2an12a4 TDn2a7 TDn12a7 1.302320e-014
Cn2an12a5 TDn2a9 TDn12a9 1.302320e-014
Cn2an12a6 TDn2a11 TDn12a11 1.302320e-014
Cn2an12a7 TDn2a13 TDn12a13 1.302320e-014
Cn2an12a8 TDn2a15 TDn12a15 1.302320e-014
Cn2an12a9 TDn2a17 TDn12a17 1.302320e-014
Cn2an12a10 TDn2a19 TDn12a19 1.302320e-014
Cn2an12a11 TDn2a21 TDn12a21 1.302320e-014
Cn2an12a12 TDn2a23 TDn12a23 1.302320e-014
Cn2an12a13 TDn2a25 TDn12a25 1.302320e-014
Cn2an12a14 TDn2a27 TDn12a27 1.302320e-014
Cn2an12a15 TDn2a29 TDn12a29 1.302320e-014
Cn2an12a16 TDn2a31 TDn12a31 1.302320e-014
Cn2an12a17 TDn2a33 TDn12a33 1.690880e-014
Cn2an13a1 TDn2a1 TDn13a1 1.690880e-014
Cn2an13a2 TDn2a3 TDn13a3 1.302320e-014
Cn2an13a3 TDn2a5 TDn13a5 1.302320e-014
Cn2an13a4 TDn2a7 TDn13a7 1.302320e-014
Cn2an13a5 TDn2a9 TDn13a9 1.302320e-014
Cn2an13a6 TDn2a11 TDn13a11 1.302320e-014
Cn2an13a7 TDn2a13 TDn13a13 1.302320e-014
Cn2an13a8 TDn2a15 TDn13a15 1.302320e-014
Cn2an13a9 TDn2a17 TDn13a17 1.302320e-014
Cn2an13a10 TDn2a19 TDn13a19 1.302320e-014
Cn2an13a11 TDn2a21 TDn13a21 1.302320e-014
Cn2an13a12 TDn2a23 TDn13a23 1.302320e-014
Cn2an13a13 TDn2a25 TDn13a25 1.302320e-014
Cn2an13a14 TDn2a27 TDn13a27 1.302320e-014
Cn2an13a15 TDn2a29 TDn13a29 1.302320e-014
Cn2an13a16 TDn2a31 TDn13a31 1.302320e-014
Cn2an13a17 TDn2a33 TDn13a33 1.690880e-014
Cn2an14a1 TDn2a1 TDn14a1 1.690880e-014
Cn2an14a2 TDn2a3 TDn14a3 1.302320e-014
Cn2an14a3 TDn2a5 TDn14a5 1.302320e-014
Cn2an14a4 TDn2a7 TDn14a7 1.302320e-014
Cn2an14a5 TDn2a9 TDn14a9 1.302320e-014
Cn2an14a6 TDn2a11 TDn14a11 1.302320e-014
Cn2an14a7 TDn2a13 TDn14a13 1.302320e-014
Cn2an14a8 TDn2a15 TDn14a15 1.302320e-014
Cn2an14a9 TDn2a17 TDn14a17 1.302320e-014
Cn2an14a10 TDn2a19 TDn14a19 1.302320e-014
Cn2an14a11 TDn2a21 TDn14a21 1.302320e-014
Cn2an14a12 TDn2a23 TDn14a23 1.302320e-014
Cn2an14a13 TDn2a25 TDn14a25 1.302320e-014
Cn2an14a14 TDn2a27 TDn14a27 1.302320e-014
Cn2an14a15 TDn2a29 TDn14a29 1.302320e-014
Cn2an14a16 TDn2a31 TDn14a31 1.302320e-014
Cn2an14a17 TDn2a33 TDn14a33 1.690880e-014
Cn2an15a1 TDn2a1 TDn15a1 1.690880e-014
Cn2an15a2 TDn2a3 TDn15a3 1.302320e-014
Cn2an15a3 TDn2a5 TDn15a5 1.302320e-014
Cn2an15a4 TDn2a7 TDn15a7 1.302320e-014
Cn2an15a5 TDn2a9 TDn15a9 1.302320e-014
Cn2an15a6 TDn2a11 TDn15a11 1.302320e-014
Cn2an15a7 TDn2a13 TDn15a13 1.302320e-014
Cn2an15a8 TDn2a15 TDn15a15 1.302320e-014
Cn2an15a9 TDn2a17 TDn15a17 1.302320e-014
Cn2an15a10 TDn2a19 TDn15a19 1.302320e-014
Cn2an15a11 TDn2a21 TDn15a21 1.302320e-014
Cn2an15a12 TDn2a23 TDn15a23 1.302320e-014
Cn2an15a13 TDn2a25 TDn15a25 1.302320e-014
Cn2an15a14 TDn2a27 TDn15a27 1.302320e-014
Cn2an15a15 TDn2a29 TDn15a29 1.302320e-014
Cn2an15a16 TDn2a31 TDn15a31 1.302320e-014
Cn2an15a17 TDn2a33 TDn15a33 1.690880e-014
Cn2an16a1 TDn2a1 TDn16a1 1.690880e-014
Cn2an16a2 TDn2a3 TDn16a3 1.302320e-014
Cn2an16a3 TDn2a5 TDn16a5 1.302320e-014
Cn2an16a4 TDn2a7 TDn16a7 1.302320e-014
Cn2an16a5 TDn2a9 TDn16a9 1.302320e-014
Cn2an16a6 TDn2a11 TDn16a11 1.302320e-014
Cn2an16a7 TDn2a13 TDn16a13 1.302320e-014
Cn2an16a8 TDn2a15 TDn16a15 1.302320e-014
Cn2an16a9 TDn2a17 TDn16a17 1.302320e-014
Cn2an16a10 TDn2a19 TDn16a19 1.302320e-014
Cn2an16a11 TDn2a21 TDn16a21 1.302320e-014
Cn2an16a12 TDn2a23 TDn16a23 1.302320e-014
Cn2an16a13 TDn2a25 TDn16a25 1.302320e-014
Cn2an16a14 TDn2a27 TDn16a27 1.302320e-014
Cn2an16a15 TDn2a29 TDn16a29 1.302320e-014
Cn2an16a16 TDn2a31 TDn16a31 1.302320e-014
Cn2an16a17 TDn2a33 TDn16a33 1.690880e-014
Cn2an17a1 TDn2a1 TDn17a1 1.690880e-014
Cn2an17a2 TDn2a3 TDn17a3 1.302320e-014
Cn2an17a3 TDn2a5 TDn17a5 1.302320e-014
Cn2an17a4 TDn2a7 TDn17a7 1.302320e-014
Cn2an17a5 TDn2a9 TDn17a9 1.302320e-014
Cn2an17a6 TDn2a11 TDn17a11 1.302320e-014
Cn2an17a7 TDn2a13 TDn17a13 1.302320e-014
Cn2an17a8 TDn2a15 TDn17a15 1.302320e-014
Cn2an17a9 TDn2a17 TDn17a17 1.302320e-014
Cn2an17a10 TDn2a19 TDn17a19 1.302320e-014
Cn2an17a11 TDn2a21 TDn17a21 1.302320e-014
Cn2an17a12 TDn2a23 TDn17a23 1.302320e-014
Cn2an17a13 TDn2a25 TDn17a25 1.302320e-014
Cn2an17a14 TDn2a27 TDn17a27 1.302320e-014
Cn2an17a15 TDn2a29 TDn17a29 1.302320e-014
Cn2an17a16 TDn2a31 TDn17a31 1.302320e-014
Cn2an17a17 TDn2a33 TDn17a33 1.690880e-014
Cn2an18a1 TDn2a1 TDn18a1 1.690880e-014
Cn2an18a2 TDn2a3 TDn18a3 1.302320e-014
Cn2an18a3 TDn2a5 TDn18a5 1.302320e-014
Cn2an18a4 TDn2a7 TDn18a7 1.302320e-014
Cn2an18a5 TDn2a9 TDn18a9 1.302320e-014
Cn2an18a6 TDn2a11 TDn18a11 1.302320e-014
Cn2an18a7 TDn2a13 TDn18a13 1.302320e-014
Cn2an18a8 TDn2a15 TDn18a15 1.302320e-014
Cn2an18a9 TDn2a17 TDn18a17 1.302320e-014
Cn2an18a10 TDn2a19 TDn18a19 1.302320e-014
Cn2an18a11 TDn2a21 TDn18a21 1.302320e-014
Cn2an18a12 TDn2a23 TDn18a23 1.302320e-014
Cn2an18a13 TDn2a25 TDn18a25 1.302320e-014
Cn2an18a14 TDn2a27 TDn18a27 1.302320e-014
Cn2an18a15 TDn2a29 TDn18a29 1.302320e-014
Cn2an18a16 TDn2a31 TDn18a31 1.302320e-014
Cn2an18a17 TDn2a33 TDn18a33 1.690880e-014
Cn2an19a1 TDn2a1 TDn19a1 1.690880e-014
Cn2an19a2 TDn2a3 TDn19a3 1.302320e-014
Cn2an19a3 TDn2a5 TDn19a5 1.302320e-014
Cn2an19a4 TDn2a7 TDn19a7 1.302320e-014
Cn2an19a5 TDn2a9 TDn19a9 1.302320e-014
Cn2an19a6 TDn2a11 TDn19a11 1.302320e-014
Cn2an19a7 TDn2a13 TDn19a13 1.302320e-014
Cn2an19a8 TDn2a15 TDn19a15 1.302320e-014
Cn2an19a9 TDn2a17 TDn19a17 1.302320e-014
Cn2an19a10 TDn2a19 TDn19a19 1.302320e-014
Cn2an19a11 TDn2a21 TDn19a21 1.302320e-014
Cn2an19a12 TDn2a23 TDn19a23 1.302320e-014
Cn2an19a13 TDn2a25 TDn19a25 1.302320e-014
Cn2an19a14 TDn2a27 TDn19a27 1.302320e-014
Cn2an19a15 TDn2a29 TDn19a29 1.302320e-014
Cn2an19a16 TDn2a31 TDn19a31 1.302320e-014
Cn2an19a17 TDn2a33 TDn19a33 1.690880e-014
Cn2an20a1 TDn2a1 TDn20a1 1.690880e-014
Cn2an20a2 TDn2a3 TDn20a3 1.302320e-014
Cn2an20a3 TDn2a5 TDn20a5 1.302320e-014
Cn2an20a4 TDn2a7 TDn20a7 1.302320e-014
Cn2an20a5 TDn2a9 TDn20a9 1.302320e-014
Cn2an20a6 TDn2a11 TDn20a11 1.302320e-014
Cn2an20a7 TDn2a13 TDn20a13 1.302320e-014
Cn2an20a8 TDn2a15 TDn20a15 1.302320e-014
Cn2an20a9 TDn2a17 TDn20a17 1.302320e-014
Cn2an20a10 TDn2a19 TDn20a19 1.302320e-014
Cn2an20a11 TDn2a21 TDn20a21 1.302320e-014
Cn2an20a12 TDn2a23 TDn20a23 1.302320e-014
Cn2an20a13 TDn2a25 TDn20a25 1.302320e-014
Cn2an20a14 TDn2a27 TDn20a27 1.302320e-014
Cn2an20a15 TDn2a29 TDn20a29 1.302320e-014
Cn2an20a16 TDn2a31 TDn20a31 1.302320e-014
Cn2an20a17 TDn2a33 TDn20a33 1.690880e-014
Cn2an21a1 TDn2a1 TDn21a1 1.690880e-014
Cn2an21a2 TDn2a3 TDn21a3 1.302320e-014
Cn2an21a3 TDn2a5 TDn21a5 1.302320e-014
Cn2an21a4 TDn2a7 TDn21a7 1.302320e-014
Cn2an21a5 TDn2a9 TDn21a9 1.302320e-014
Cn2an21a6 TDn2a11 TDn21a11 1.302320e-014
Cn2an21a7 TDn2a13 TDn21a13 1.302320e-014
Cn2an21a8 TDn2a15 TDn21a15 1.302320e-014
Cn2an21a9 TDn2a17 TDn21a17 1.302320e-014
Cn2an21a10 TDn2a19 TDn21a19 1.302320e-014
Cn2an21a11 TDn2a21 TDn21a21 1.302320e-014
Cn2an21a12 TDn2a23 TDn21a23 1.302320e-014
Cn2an21a13 TDn2a25 TDn21a25 1.302320e-014
Cn2an21a14 TDn2a27 TDn21a27 1.302320e-014
Cn2an21a15 TDn2a29 TDn21a29 1.302320e-014
Cn2an21a16 TDn2a31 TDn21a31 1.302320e-014
Cn2an21a17 TDn2a33 TDn21a33 1.690880e-014
Cn2an22a1 TDn2a1 TDn22a1 1.690880e-014
Cn2an22a2 TDn2a3 TDn22a3 1.302320e-014
Cn2an22a3 TDn2a5 TDn22a5 1.302320e-014
Cn2an22a4 TDn2a7 TDn22a7 1.302320e-014
Cn2an22a5 TDn2a9 TDn22a9 1.302320e-014
Cn2an22a6 TDn2a11 TDn22a11 1.302320e-014
Cn2an22a7 TDn2a13 TDn22a13 1.302320e-014
Cn2an22a8 TDn2a15 TDn22a15 1.302320e-014
Cn2an22a9 TDn2a17 TDn22a17 1.302320e-014
Cn2an22a10 TDn2a19 TDn22a19 1.302320e-014
Cn2an22a11 TDn2a21 TDn22a21 1.302320e-014
Cn2an22a12 TDn2a23 TDn22a23 1.302320e-014
Cn2an22a13 TDn2a25 TDn22a25 1.302320e-014
Cn2an22a14 TDn2a27 TDn22a27 1.302320e-014
Cn2an22a15 TDn2a29 TDn22a29 1.302320e-014
Cn2an22a16 TDn2a31 TDn22a31 1.302320e-014
Cn2an22a17 TDn2a33 TDn22a33 1.690880e-014
Cn2an23a1 TDn2a1 TDn23a1 1.690880e-014
Cn2an23a2 TDn2a3 TDn23a3 1.302320e-014
Cn2an23a3 TDn2a5 TDn23a5 1.302320e-014
Cn2an23a4 TDn2a7 TDn23a7 1.302320e-014
Cn2an23a5 TDn2a9 TDn23a9 1.302320e-014
Cn2an23a6 TDn2a11 TDn23a11 1.302320e-014
Cn2an23a7 TDn2a13 TDn23a13 1.302320e-014
Cn2an23a8 TDn2a15 TDn23a15 1.302320e-014
Cn2an23a9 TDn2a17 TDn23a17 1.302320e-014
Cn2an23a10 TDn2a19 TDn23a19 1.302320e-014
Cn2an23a11 TDn2a21 TDn23a21 1.302320e-014
Cn2an23a12 TDn2a23 TDn23a23 1.302320e-014
Cn2an23a13 TDn2a25 TDn23a25 1.302320e-014
Cn2an23a14 TDn2a27 TDn23a27 1.302320e-014
Cn2an23a15 TDn2a29 TDn23a29 1.302320e-014
Cn2an23a16 TDn2a31 TDn23a31 1.302320e-014
Cn2an23a17 TDn2a33 TDn23a33 1.690880e-014
Cn2an24a1 TDn2a1 TDn24a1 1.690880e-014
Cn2an24a2 TDn2a3 TDn24a3 1.302320e-014
Cn2an24a3 TDn2a5 TDn24a5 1.302320e-014
Cn2an24a4 TDn2a7 TDn24a7 1.302320e-014
Cn2an24a5 TDn2a9 TDn24a9 1.302320e-014
Cn2an24a6 TDn2a11 TDn24a11 1.302320e-014
Cn2an24a7 TDn2a13 TDn24a13 1.302320e-014
Cn2an24a8 TDn2a15 TDn24a15 1.302320e-014
Cn2an24a9 TDn2a17 TDn24a17 1.302320e-014
Cn2an24a10 TDn2a19 TDn24a19 1.302320e-014
Cn2an24a11 TDn2a21 TDn24a21 1.302320e-014
Cn2an24a12 TDn2a23 TDn24a23 1.302320e-014
Cn2an24a13 TDn2a25 TDn24a25 1.302320e-014
Cn2an24a14 TDn2a27 TDn24a27 1.302320e-014
Cn2an24a15 TDn2a29 TDn24a29 1.302320e-014
Cn2an24a16 TDn2a31 TDn24a31 1.302320e-014
Cn2an24a17 TDn2a33 TDn24a33 1.690880e-014
Cn2an25a1 TDn2a1 TDn25a1 1.690880e-014
Cn2an25a2 TDn2a3 TDn25a3 1.302320e-014
Cn2an25a3 TDn2a5 TDn25a5 1.302320e-014
Cn2an25a4 TDn2a7 TDn25a7 1.302320e-014
Cn2an25a5 TDn2a9 TDn25a9 1.302320e-014
Cn2an25a6 TDn2a11 TDn25a11 1.302320e-014
Cn2an25a7 TDn2a13 TDn25a13 1.302320e-014
Cn2an25a8 TDn2a15 TDn25a15 1.302320e-014
Cn2an25a9 TDn2a17 TDn25a17 1.302320e-014
Cn2an25a10 TDn2a19 TDn25a19 1.302320e-014
Cn2an25a11 TDn2a21 TDn25a21 1.302320e-014
Cn2an25a12 TDn2a23 TDn25a23 1.302320e-014
Cn2an25a13 TDn2a25 TDn25a25 1.302320e-014
Cn2an25a14 TDn2a27 TDn25a27 1.302320e-014
Cn2an25a15 TDn2a29 TDn25a29 1.302320e-014
Cn2an25a16 TDn2a31 TDn25a31 1.302320e-014
Cn2an25a17 TDn2a33 TDn25a33 1.690880e-014
Cn2an26a1 TDn2a1 TDn26a1 1.690880e-014
Cn2an26a2 TDn2a3 TDn26a3 1.302320e-014
Cn2an26a3 TDn2a5 TDn26a5 1.302320e-014
Cn2an26a4 TDn2a7 TDn26a7 1.302320e-014
Cn2an26a5 TDn2a9 TDn26a9 1.302320e-014
Cn2an26a6 TDn2a11 TDn26a11 1.302320e-014
Cn2an26a7 TDn2a13 TDn26a13 1.302320e-014
Cn2an26a8 TDn2a15 TDn26a15 1.302320e-014
Cn2an26a9 TDn2a17 TDn26a17 1.302320e-014
Cn2an26a10 TDn2a19 TDn26a19 1.302320e-014
Cn2an26a11 TDn2a21 TDn26a21 1.302320e-014
Cn2an26a12 TDn2a23 TDn26a23 1.302320e-014
Cn2an26a13 TDn2a25 TDn26a25 1.302320e-014
Cn2an26a14 TDn2a27 TDn26a27 1.302320e-014
Cn2an26a15 TDn2a29 TDn26a29 1.302320e-014
Cn2an26a16 TDn2a31 TDn26a31 1.302320e-014
Cn2an26a17 TDn2a33 TDn26a33 1.690880e-014
Cn2an27a1 TDn2a1 TDn27a1 1.690880e-014
Cn2an27a2 TDn2a3 TDn27a3 1.302320e-014
Cn2an27a3 TDn2a5 TDn27a5 1.302320e-014
Cn2an27a4 TDn2a7 TDn27a7 1.302320e-014
Cn2an27a5 TDn2a9 TDn27a9 1.302320e-014
Cn2an27a6 TDn2a11 TDn27a11 1.302320e-014
Cn2an27a7 TDn2a13 TDn27a13 1.302320e-014
Cn2an27a8 TDn2a15 TDn27a15 1.302320e-014
Cn2an27a9 TDn2a17 TDn27a17 1.302320e-014
Cn2an27a10 TDn2a19 TDn27a19 1.302320e-014
Cn2an27a11 TDn2a21 TDn27a21 1.302320e-014
Cn2an27a12 TDn2a23 TDn27a23 1.302320e-014
Cn2an27a13 TDn2a25 TDn27a25 1.302320e-014
Cn2an27a14 TDn2a27 TDn27a27 1.302320e-014
Cn2an27a15 TDn2a29 TDn27a29 1.302320e-014
Cn2an27a16 TDn2a31 TDn27a31 1.302320e-014
Cn2an27a17 TDn2a33 TDn27a33 1.690880e-014
Cn2an28a1 TDn2a1 TDn28a1 1.690880e-014
Cn2an28a2 TDn2a3 TDn28a3 1.302320e-014
Cn2an28a3 TDn2a5 TDn28a5 1.302320e-014
Cn2an28a4 TDn2a7 TDn28a7 1.302320e-014
Cn2an28a5 TDn2a9 TDn28a9 1.302320e-014
Cn2an28a6 TDn2a11 TDn28a11 1.302320e-014
Cn2an28a7 TDn2a13 TDn28a13 1.302320e-014
Cn2an28a8 TDn2a15 TDn28a15 1.302320e-014
Cn2an28a9 TDn2a17 TDn28a17 1.302320e-014
Cn2an28a10 TDn2a19 TDn28a19 1.302320e-014
Cn2an28a11 TDn2a21 TDn28a21 1.302320e-014
Cn2an28a12 TDn2a23 TDn28a23 1.302320e-014
Cn2an28a13 TDn2a25 TDn28a25 1.302320e-014
Cn2an28a14 TDn2a27 TDn28a27 1.302320e-014
Cn2an28a15 TDn2a29 TDn28a29 1.302320e-014
Cn2an28a16 TDn2a31 TDn28a31 1.302320e-014
Cn2an28a17 TDn2a33 TDn28a33 1.690880e-014
Cn2an29a1 TDn2a1 TDn29a1 1.690880e-014
Cn2an29a2 TDn2a3 TDn29a3 1.302320e-014
Cn2an29a3 TDn2a5 TDn29a5 1.302320e-014
Cn2an29a4 TDn2a7 TDn29a7 1.302320e-014
Cn2an29a5 TDn2a9 TDn29a9 1.302320e-014
Cn2an29a6 TDn2a11 TDn29a11 1.302320e-014
Cn2an29a7 TDn2a13 TDn29a13 1.302320e-014
Cn2an29a8 TDn2a15 TDn29a15 1.302320e-014
Cn2an29a9 TDn2a17 TDn29a17 1.302320e-014
Cn2an29a10 TDn2a19 TDn29a19 1.302320e-014
Cn2an29a11 TDn2a21 TDn29a21 1.302320e-014
Cn2an29a12 TDn2a23 TDn29a23 1.302320e-014
Cn2an29a13 TDn2a25 TDn29a25 1.302320e-014
Cn2an29a14 TDn2a27 TDn29a27 1.302320e-014
Cn2an29a15 TDn2a29 TDn29a29 1.302320e-014
Cn2an29a16 TDn2a31 TDn29a31 1.302320e-014
Cn2an29a17 TDn2a33 TDn29a33 1.690880e-014
Cn2an30a1 TDn2a1 TDn30a1 1.690880e-014
Cn2an30a2 TDn2a3 TDn30a3 1.302320e-014
Cn2an30a3 TDn2a5 TDn30a5 1.302320e-014
Cn2an30a4 TDn2a7 TDn30a7 1.302320e-014
Cn2an30a5 TDn2a9 TDn30a9 1.302320e-014
Cn2an30a6 TDn2a11 TDn30a11 1.302320e-014
Cn2an30a7 TDn2a13 TDn30a13 1.302320e-014
Cn2an30a8 TDn2a15 TDn30a15 1.302320e-014
Cn2an30a9 TDn2a17 TDn30a17 1.302320e-014
Cn2an30a10 TDn2a19 TDn30a19 1.302320e-014
Cn2an30a11 TDn2a21 TDn30a21 1.302320e-014
Cn2an30a12 TDn2a23 TDn30a23 1.302320e-014
Cn2an30a13 TDn2a25 TDn30a25 1.302320e-014
Cn2an30a14 TDn2a27 TDn30a27 1.302320e-014
Cn2an30a15 TDn2a29 TDn30a29 1.302320e-014
Cn2an30a16 TDn2a31 TDn30a31 1.302320e-014
Cn2an30a17 TDn2a33 TDn30a33 1.690880e-014
Cn2an31a1 TDn2a1 TDn31a1 1.690880e-014
Cn2an31a2 TDn2a3 TDn31a3 1.302320e-014
Cn2an31a3 TDn2a5 TDn31a5 1.302320e-014
Cn2an31a4 TDn2a7 TDn31a7 1.302320e-014
Cn2an31a5 TDn2a9 TDn31a9 1.302320e-014
Cn2an31a6 TDn2a11 TDn31a11 1.302320e-014
Cn2an31a7 TDn2a13 TDn31a13 1.302320e-014
Cn2an31a8 TDn2a15 TDn31a15 1.302320e-014
Cn2an31a9 TDn2a17 TDn31a17 1.302320e-014
Cn2an31a10 TDn2a19 TDn31a19 1.302320e-014
Cn2an31a11 TDn2a21 TDn31a21 1.302320e-014
Cn2an31a12 TDn2a23 TDn31a23 1.302320e-014
Cn2an31a13 TDn2a25 TDn31a25 1.302320e-014
Cn2an31a14 TDn2a27 TDn31a27 1.302320e-014
Cn2an31a15 TDn2a29 TDn31a29 1.302320e-014
Cn2an31a16 TDn2a31 TDn31a31 1.302320e-014
Cn2an31a17 TDn2a33 TDn31a33 1.690880e-014
Cn2an32a1 TDn2a1 TDn32a1 1.690880e-014
Cn2an32a2 TDn2a3 TDn32a3 1.302320e-014
Cn2an32a3 TDn2a5 TDn32a5 1.302320e-014
Cn2an32a4 TDn2a7 TDn32a7 1.302320e-014
Cn2an32a5 TDn2a9 TDn32a9 1.302320e-014
Cn2an32a6 TDn2a11 TDn32a11 1.302320e-014
Cn2an32a7 TDn2a13 TDn32a13 1.302320e-014
Cn2an32a8 TDn2a15 TDn32a15 1.302320e-014
Cn2an32a9 TDn2a17 TDn32a17 1.302320e-014
Cn2an32a10 TDn2a19 TDn32a19 1.302320e-014
Cn2an32a11 TDn2a21 TDn32a21 1.302320e-014
Cn2an32a12 TDn2a23 TDn32a23 1.302320e-014
Cn2an32a13 TDn2a25 TDn32a25 1.302320e-014
Cn2an32a14 TDn2a27 TDn32a27 1.302320e-014
Cn2an32a15 TDn2a29 TDn32a29 1.302320e-014
Cn2an32a16 TDn2a31 TDn32a31 1.302320e-014
Cn2an32a17 TDn2a33 TDn32a33 1.690880e-014
Cn2anva1 TDn2a1 TDnva1 1.690880e-014
Cn2anva2 TDn2a3 TDnva3 1.690880e-014
Cn2anva3 TDn2a5 TDnva5 1.690880e-014
Cn2anva4 TDn2a7 TDnva7 1.690880e-014
Cn2anva5 TDn2a9 TDnva9 1.690880e-014
Cn2anva6 TDn2a11 TDnva11 1.690880e-014
Cn2anva7 TDn2a13 TDnva13 1.690880e-014
Cn2anva8 TDn2a15 TDnva15 1.690880e-014
Cn2anva9 TDn2a17 TDnva17 1.690880e-014
Cn2anva10 TDn2a19 TDnva19 1.690880e-014
Cn2anva11 TDn2a21 TDnva21 1.690880e-014
Cn2anva12 TDn2a23 TDnva23 1.690880e-014
Cn2anva13 TDn2a25 TDnva25 1.690880e-014
Cn2anva14 TDn2a27 TDnva27 1.690880e-014
Cn2anva15 TDn2a29 TDnva29 1.690880e-014
Cn2anva16 TDn2a31 TDnva31 1.690880e-014
Cn2anva17 TDn2a33 TDnva33 1.690880e-014
Cn3an4a1 TDn3a1 TDn4a1 1.575450e-014
Cn3an4a2 TDn3a3 TDn4a3 3.150900e-014
Cn3an4a3 TDn3a5 TDn4a5 3.150900e-014
Cn3an4a4 TDn3a7 TDn4a7 3.150900e-014
Cn3an4a5 TDn3a9 TDn4a9 3.150900e-014
Cn3an4a6 TDn3a11 TDn4a11 3.150900e-014
Cn3an4a7 TDn3a13 TDn4a13 3.150900e-014
Cn3an4a8 TDn3a15 TDn4a15 3.150900e-014
Cn3an4a9 TDn3a17 TDn4a17 3.150900e-014
Cn3an4a10 TDn3a19 TDn4a19 3.150900e-014
Cn3an4a11 TDn3a21 TDn4a21 3.150900e-014
Cn3an4a12 TDn3a23 TDn4a23 3.150900e-014
Cn3an4a13 TDn3a25 TDn4a25 3.150900e-014
Cn3an4a14 TDn3a27 TDn4a27 3.150900e-014
Cn3an4a15 TDn3a29 TDn4a29 3.150900e-014
Cn3an4a16 TDn3a31 TDn4a31 3.150900e-014
Cn3an4a17 TDn3a33 TDn4a33 1.575450e-014
Cn3an5a1 TDn3a1 TDn5a1 5.588630e-015
Cn3an5a2 TDn3a3 TDn5a3 1.117730e-014
Cn3an5a3 TDn3a5 TDn5a5 1.117730e-014
Cn3an5a4 TDn3a7 TDn5a7 1.117730e-014
Cn3an5a5 TDn3a9 TDn5a9 1.117730e-014
Cn3an5a6 TDn3a11 TDn5a11 1.117730e-014
Cn3an5a7 TDn3a13 TDn5a13 1.117730e-014
Cn3an5a8 TDn3a15 TDn5a15 1.117730e-014
Cn3an5a9 TDn3a17 TDn5a17 1.117730e-014
Cn3an5a10 TDn3a19 TDn5a19 1.117730e-014
Cn3an5a11 TDn3a21 TDn5a21 1.117730e-014
Cn3an5a12 TDn3a23 TDn5a23 1.117730e-014
Cn3an5a13 TDn3a25 TDn5a25 1.117730e-014
Cn3an5a14 TDn3a27 TDn5a27 1.117730e-014
Cn3an5a15 TDn3a29 TDn5a29 1.117730e-014
Cn3an5a16 TDn3a31 TDn5a31 1.117730e-014
Cn3an5a17 TDn3a33 TDn5a33 5.588630e-015
Cn3an6a1 TDn3a1 TDn6a1 5.135110e-015
Cn3an6a2 TDn3a3 TDn6a3 1.027020e-014
Cn3an6a3 TDn3a5 TDn6a5 1.027020e-014
Cn3an6a4 TDn3a7 TDn6a7 1.027020e-014
Cn3an6a5 TDn3a9 TDn6a9 1.027020e-014
Cn3an6a6 TDn3a11 TDn6a11 1.027020e-014
Cn3an6a7 TDn3a13 TDn6a13 1.027020e-014
Cn3an6a8 TDn3a15 TDn6a15 1.027020e-014
Cn3an6a9 TDn3a17 TDn6a17 1.027020e-014
Cn3an6a10 TDn3a19 TDn6a19 1.027020e-014
Cn3an6a11 TDn3a21 TDn6a21 1.027020e-014
Cn3an6a12 TDn3a23 TDn6a23 1.027020e-014
Cn3an6a13 TDn3a25 TDn6a25 1.027020e-014
Cn3an6a14 TDn3a27 TDn6a27 1.027020e-014
Cn3an6a15 TDn3a29 TDn6a29 1.027020e-014
Cn3an6a16 TDn3a31 TDn6a31 1.027020e-014
Cn3an6a17 TDn3a33 TDn6a33 5.135110e-015
Cn3an7a1 TDn3a1 TDn7a1 5.012180e-015
Cn3an7a2 TDn3a3 TDn7a3 1.002440e-014
Cn3an7a3 TDn3a5 TDn7a5 1.002440e-014
Cn3an7a4 TDn3a7 TDn7a7 1.002440e-014
Cn3an7a5 TDn3a9 TDn7a9 1.002440e-014
Cn3an7a6 TDn3a11 TDn7a11 1.002440e-014
Cn3an7a7 TDn3a13 TDn7a13 1.002440e-014
Cn3an7a8 TDn3a15 TDn7a15 1.002440e-014
Cn3an7a9 TDn3a17 TDn7a17 1.002440e-014
Cn3an7a10 TDn3a19 TDn7a19 1.002440e-014
Cn3an7a11 TDn3a21 TDn7a21 1.002440e-014
Cn3an7a12 TDn3a23 TDn7a23 1.002440e-014
Cn3an7a13 TDn3a25 TDn7a25 1.002440e-014
Cn3an7a14 TDn3a27 TDn7a27 1.002440e-014
Cn3an7a15 TDn3a29 TDn7a29 1.002440e-014
Cn3an7a16 TDn3a31 TDn7a31 1.002440e-014
Cn3an7a17 TDn3a33 TDn7a33 5.012180e-015
Cn3an8a1 TDn3a1 TDn8a1 5.004030e-015
Cn3an8a2 TDn3a3 TDn8a3 1.000810e-014
Cn3an8a3 TDn3a5 TDn8a5 1.000810e-014
Cn3an8a4 TDn3a7 TDn8a7 1.000810e-014
Cn3an8a5 TDn3a9 TDn8a9 1.000810e-014
Cn3an8a6 TDn3a11 TDn8a11 1.000810e-014
Cn3an8a7 TDn3a13 TDn8a13 1.000810e-014
Cn3an8a8 TDn3a15 TDn8a15 1.000810e-014
Cn3an8a9 TDn3a17 TDn8a17 1.000810e-014
Cn3an8a10 TDn3a19 TDn8a19 1.000810e-014
Cn3an8a11 TDn3a21 TDn8a21 1.000810e-014
Cn3an8a12 TDn3a23 TDn8a23 1.000810e-014
Cn3an8a13 TDn3a25 TDn8a25 1.000810e-014
Cn3an8a14 TDn3a27 TDn8a27 1.000810e-014
Cn3an8a15 TDn3a29 TDn8a29 1.000810e-014
Cn3an8a16 TDn3a31 TDn8a31 1.000810e-014
Cn3an8a17 TDn3a33 TDn8a33 5.004030e-015
Cn3an9a1 TDn3a1 TDn9a1 5.703560e-015
Cn3an9a2 TDn3a3 TDn9a3 1.140710e-014
Cn3an9a3 TDn3a5 TDn9a5 1.140710e-014
Cn3an9a4 TDn3a7 TDn9a7 1.140710e-014
Cn3an9a5 TDn3a9 TDn9a9 1.140710e-014
Cn3an9a6 TDn3a11 TDn9a11 1.140710e-014
Cn3an9a7 TDn3a13 TDn9a13 1.140710e-014
Cn3an9a8 TDn3a15 TDn9a15 1.140710e-014
Cn3an9a9 TDn3a17 TDn9a17 1.140710e-014
Cn3an9a10 TDn3a19 TDn9a19 1.140710e-014
Cn3an9a11 TDn3a21 TDn9a21 1.140710e-014
Cn3an9a12 TDn3a23 TDn9a23 1.140710e-014
Cn3an9a13 TDn3a25 TDn9a25 1.140710e-014
Cn3an9a14 TDn3a27 TDn9a27 1.140710e-014
Cn3an9a15 TDn3a29 TDn9a29 1.140710e-014
Cn3an9a16 TDn3a31 TDn9a31 1.140710e-014
Cn3an9a17 TDn3a33 TDn9a33 5.703560e-015
Cn3an10a1 TDn3a1 TDn10a1 1.690880e-014
Cn3an10a2 TDn3a3 TDn10a3 1.302320e-014
Cn3an10a3 TDn3a5 TDn10a5 1.302320e-014
Cn3an10a4 TDn3a7 TDn10a7 1.302320e-014
Cn3an10a5 TDn3a9 TDn10a9 1.302320e-014
Cn3an10a6 TDn3a11 TDn10a11 1.302320e-014
Cn3an10a7 TDn3a13 TDn10a13 1.302320e-014
Cn3an10a8 TDn3a15 TDn10a15 1.302320e-014
Cn3an10a9 TDn3a17 TDn10a17 1.302320e-014
Cn3an10a10 TDn3a19 TDn10a19 1.302320e-014
Cn3an10a11 TDn3a21 TDn10a21 1.302320e-014
Cn3an10a12 TDn3a23 TDn10a23 1.302320e-014
Cn3an10a13 TDn3a25 TDn10a25 1.302320e-014
Cn3an10a14 TDn3a27 TDn10a27 1.302320e-014
Cn3an10a15 TDn3a29 TDn10a29 1.302320e-014
Cn3an10a16 TDn3a31 TDn10a31 1.302320e-014
Cn3an10a17 TDn3a33 TDn10a33 1.690880e-014
Cn3an11a1 TDn3a1 TDn11a1 1.690880e-014
Cn3an11a2 TDn3a3 TDn11a3 1.302320e-014
Cn3an11a3 TDn3a5 TDn11a5 1.302320e-014
Cn3an11a4 TDn3a7 TDn11a7 1.302320e-014
Cn3an11a5 TDn3a9 TDn11a9 1.302320e-014
Cn3an11a6 TDn3a11 TDn11a11 1.302320e-014
Cn3an11a7 TDn3a13 TDn11a13 1.302320e-014
Cn3an11a8 TDn3a15 TDn11a15 1.302320e-014
Cn3an11a9 TDn3a17 TDn11a17 1.302320e-014
Cn3an11a10 TDn3a19 TDn11a19 1.302320e-014
Cn3an11a11 TDn3a21 TDn11a21 1.302320e-014
Cn3an11a12 TDn3a23 TDn11a23 1.302320e-014
Cn3an11a13 TDn3a25 TDn11a25 1.302320e-014
Cn3an11a14 TDn3a27 TDn11a27 1.302320e-014
Cn3an11a15 TDn3a29 TDn11a29 1.302320e-014
Cn3an11a16 TDn3a31 TDn11a31 1.302320e-014
Cn3an11a17 TDn3a33 TDn11a33 1.690880e-014
Cn3an12a1 TDn3a1 TDn12a1 1.690880e-014
Cn3an12a2 TDn3a3 TDn12a3 1.302320e-014
Cn3an12a3 TDn3a5 TDn12a5 1.302320e-014
Cn3an12a4 TDn3a7 TDn12a7 1.302320e-014
Cn3an12a5 TDn3a9 TDn12a9 1.302320e-014
Cn3an12a6 TDn3a11 TDn12a11 1.302320e-014
Cn3an12a7 TDn3a13 TDn12a13 1.302320e-014
Cn3an12a8 TDn3a15 TDn12a15 1.302320e-014
Cn3an12a9 TDn3a17 TDn12a17 1.302320e-014
Cn3an12a10 TDn3a19 TDn12a19 1.302320e-014
Cn3an12a11 TDn3a21 TDn12a21 1.302320e-014
Cn3an12a12 TDn3a23 TDn12a23 1.302320e-014
Cn3an12a13 TDn3a25 TDn12a25 1.302320e-014
Cn3an12a14 TDn3a27 TDn12a27 1.302320e-014
Cn3an12a15 TDn3a29 TDn12a29 1.302320e-014
Cn3an12a16 TDn3a31 TDn12a31 1.302320e-014
Cn3an12a17 TDn3a33 TDn12a33 1.690880e-014
Cn3an13a1 TDn3a1 TDn13a1 1.690880e-014
Cn3an13a2 TDn3a3 TDn13a3 1.302320e-014
Cn3an13a3 TDn3a5 TDn13a5 1.302320e-014
Cn3an13a4 TDn3a7 TDn13a7 1.302320e-014
Cn3an13a5 TDn3a9 TDn13a9 1.302320e-014
Cn3an13a6 TDn3a11 TDn13a11 1.302320e-014
Cn3an13a7 TDn3a13 TDn13a13 1.302320e-014
Cn3an13a8 TDn3a15 TDn13a15 1.302320e-014
Cn3an13a9 TDn3a17 TDn13a17 1.302320e-014
Cn3an13a10 TDn3a19 TDn13a19 1.302320e-014
Cn3an13a11 TDn3a21 TDn13a21 1.302320e-014
Cn3an13a12 TDn3a23 TDn13a23 1.302320e-014
Cn3an13a13 TDn3a25 TDn13a25 1.302320e-014
Cn3an13a14 TDn3a27 TDn13a27 1.302320e-014
Cn3an13a15 TDn3a29 TDn13a29 1.302320e-014
Cn3an13a16 TDn3a31 TDn13a31 1.302320e-014
Cn3an13a17 TDn3a33 TDn13a33 1.690880e-014
Cn3an14a1 TDn3a1 TDn14a1 1.690880e-014
Cn3an14a2 TDn3a3 TDn14a3 1.302320e-014
Cn3an14a3 TDn3a5 TDn14a5 1.302320e-014
Cn3an14a4 TDn3a7 TDn14a7 1.302320e-014
Cn3an14a5 TDn3a9 TDn14a9 1.302320e-014
Cn3an14a6 TDn3a11 TDn14a11 1.302320e-014
Cn3an14a7 TDn3a13 TDn14a13 1.302320e-014
Cn3an14a8 TDn3a15 TDn14a15 1.302320e-014
Cn3an14a9 TDn3a17 TDn14a17 1.302320e-014
Cn3an14a10 TDn3a19 TDn14a19 1.302320e-014
Cn3an14a11 TDn3a21 TDn14a21 1.302320e-014
Cn3an14a12 TDn3a23 TDn14a23 1.302320e-014
Cn3an14a13 TDn3a25 TDn14a25 1.302320e-014
Cn3an14a14 TDn3a27 TDn14a27 1.302320e-014
Cn3an14a15 TDn3a29 TDn14a29 1.302320e-014
Cn3an14a16 TDn3a31 TDn14a31 1.302320e-014
Cn3an14a17 TDn3a33 TDn14a33 1.690880e-014
Cn3an15a1 TDn3a1 TDn15a1 1.690880e-014
Cn3an15a2 TDn3a3 TDn15a3 1.302320e-014
Cn3an15a3 TDn3a5 TDn15a5 1.302320e-014
Cn3an15a4 TDn3a7 TDn15a7 1.302320e-014
Cn3an15a5 TDn3a9 TDn15a9 1.302320e-014
Cn3an15a6 TDn3a11 TDn15a11 1.302320e-014
Cn3an15a7 TDn3a13 TDn15a13 1.302320e-014
Cn3an15a8 TDn3a15 TDn15a15 1.302320e-014
Cn3an15a9 TDn3a17 TDn15a17 1.302320e-014
Cn3an15a10 TDn3a19 TDn15a19 1.302320e-014
Cn3an15a11 TDn3a21 TDn15a21 1.302320e-014
Cn3an15a12 TDn3a23 TDn15a23 1.302320e-014
Cn3an15a13 TDn3a25 TDn15a25 1.302320e-014
Cn3an15a14 TDn3a27 TDn15a27 1.302320e-014
Cn3an15a15 TDn3a29 TDn15a29 1.302320e-014
Cn3an15a16 TDn3a31 TDn15a31 1.302320e-014
Cn3an15a17 TDn3a33 TDn15a33 1.690880e-014
Cn3an16a1 TDn3a1 TDn16a1 1.690880e-014
Cn3an16a2 TDn3a3 TDn16a3 1.302320e-014
Cn3an16a3 TDn3a5 TDn16a5 1.302320e-014
Cn3an16a4 TDn3a7 TDn16a7 1.302320e-014
Cn3an16a5 TDn3a9 TDn16a9 1.302320e-014
Cn3an16a6 TDn3a11 TDn16a11 1.302320e-014
Cn3an16a7 TDn3a13 TDn16a13 1.302320e-014
Cn3an16a8 TDn3a15 TDn16a15 1.302320e-014
Cn3an16a9 TDn3a17 TDn16a17 1.302320e-014
Cn3an16a10 TDn3a19 TDn16a19 1.302320e-014
Cn3an16a11 TDn3a21 TDn16a21 1.302320e-014
Cn3an16a12 TDn3a23 TDn16a23 1.302320e-014
Cn3an16a13 TDn3a25 TDn16a25 1.302320e-014
Cn3an16a14 TDn3a27 TDn16a27 1.302320e-014
Cn3an16a15 TDn3a29 TDn16a29 1.302320e-014
Cn3an16a16 TDn3a31 TDn16a31 1.302320e-014
Cn3an16a17 TDn3a33 TDn16a33 1.690880e-014
Cn3an17a1 TDn3a1 TDn17a1 1.690880e-014
Cn3an17a2 TDn3a3 TDn17a3 1.302320e-014
Cn3an17a3 TDn3a5 TDn17a5 1.302320e-014
Cn3an17a4 TDn3a7 TDn17a7 1.302320e-014
Cn3an17a5 TDn3a9 TDn17a9 1.302320e-014
Cn3an17a6 TDn3a11 TDn17a11 1.302320e-014
Cn3an17a7 TDn3a13 TDn17a13 1.302320e-014
Cn3an17a8 TDn3a15 TDn17a15 1.302320e-014
Cn3an17a9 TDn3a17 TDn17a17 1.302320e-014
Cn3an17a10 TDn3a19 TDn17a19 1.302320e-014
Cn3an17a11 TDn3a21 TDn17a21 1.302320e-014
Cn3an17a12 TDn3a23 TDn17a23 1.302320e-014
Cn3an17a13 TDn3a25 TDn17a25 1.302320e-014
Cn3an17a14 TDn3a27 TDn17a27 1.302320e-014
Cn3an17a15 TDn3a29 TDn17a29 1.302320e-014
Cn3an17a16 TDn3a31 TDn17a31 1.302320e-014
Cn3an17a17 TDn3a33 TDn17a33 1.690880e-014
Cn3an18a1 TDn3a1 TDn18a1 1.690880e-014
Cn3an18a2 TDn3a3 TDn18a3 1.302320e-014
Cn3an18a3 TDn3a5 TDn18a5 1.302320e-014
Cn3an18a4 TDn3a7 TDn18a7 1.302320e-014
Cn3an18a5 TDn3a9 TDn18a9 1.302320e-014
Cn3an18a6 TDn3a11 TDn18a11 1.302320e-014
Cn3an18a7 TDn3a13 TDn18a13 1.302320e-014
Cn3an18a8 TDn3a15 TDn18a15 1.302320e-014
Cn3an18a9 TDn3a17 TDn18a17 1.302320e-014
Cn3an18a10 TDn3a19 TDn18a19 1.302320e-014
Cn3an18a11 TDn3a21 TDn18a21 1.302320e-014
Cn3an18a12 TDn3a23 TDn18a23 1.302320e-014
Cn3an18a13 TDn3a25 TDn18a25 1.302320e-014
Cn3an18a14 TDn3a27 TDn18a27 1.302320e-014
Cn3an18a15 TDn3a29 TDn18a29 1.302320e-014
Cn3an18a16 TDn3a31 TDn18a31 1.302320e-014
Cn3an18a17 TDn3a33 TDn18a33 1.690880e-014
Cn3an19a1 TDn3a1 TDn19a1 1.690880e-014
Cn3an19a2 TDn3a3 TDn19a3 1.302320e-014
Cn3an19a3 TDn3a5 TDn19a5 1.302320e-014
Cn3an19a4 TDn3a7 TDn19a7 1.302320e-014
Cn3an19a5 TDn3a9 TDn19a9 1.302320e-014
Cn3an19a6 TDn3a11 TDn19a11 1.302320e-014
Cn3an19a7 TDn3a13 TDn19a13 1.302320e-014
Cn3an19a8 TDn3a15 TDn19a15 1.302320e-014
Cn3an19a9 TDn3a17 TDn19a17 1.302320e-014
Cn3an19a10 TDn3a19 TDn19a19 1.302320e-014
Cn3an19a11 TDn3a21 TDn19a21 1.302320e-014
Cn3an19a12 TDn3a23 TDn19a23 1.302320e-014
Cn3an19a13 TDn3a25 TDn19a25 1.302320e-014
Cn3an19a14 TDn3a27 TDn19a27 1.302320e-014
Cn3an19a15 TDn3a29 TDn19a29 1.302320e-014
Cn3an19a16 TDn3a31 TDn19a31 1.302320e-014
Cn3an19a17 TDn3a33 TDn19a33 1.690880e-014
Cn3an20a1 TDn3a1 TDn20a1 1.690880e-014
Cn3an20a2 TDn3a3 TDn20a3 1.302320e-014
Cn3an20a3 TDn3a5 TDn20a5 1.302320e-014
Cn3an20a4 TDn3a7 TDn20a7 1.302320e-014
Cn3an20a5 TDn3a9 TDn20a9 1.302320e-014
Cn3an20a6 TDn3a11 TDn20a11 1.302320e-014
Cn3an20a7 TDn3a13 TDn20a13 1.302320e-014
Cn3an20a8 TDn3a15 TDn20a15 1.302320e-014
Cn3an20a9 TDn3a17 TDn20a17 1.302320e-014
Cn3an20a10 TDn3a19 TDn20a19 1.302320e-014
Cn3an20a11 TDn3a21 TDn20a21 1.302320e-014
Cn3an20a12 TDn3a23 TDn20a23 1.302320e-014
Cn3an20a13 TDn3a25 TDn20a25 1.302320e-014
Cn3an20a14 TDn3a27 TDn20a27 1.302320e-014
Cn3an20a15 TDn3a29 TDn20a29 1.302320e-014
Cn3an20a16 TDn3a31 TDn20a31 1.302320e-014
Cn3an20a17 TDn3a33 TDn20a33 1.690880e-014
Cn3an21a1 TDn3a1 TDn21a1 1.690880e-014
Cn3an21a2 TDn3a3 TDn21a3 1.302320e-014
Cn3an21a3 TDn3a5 TDn21a5 1.302320e-014
Cn3an21a4 TDn3a7 TDn21a7 1.302320e-014
Cn3an21a5 TDn3a9 TDn21a9 1.302320e-014
Cn3an21a6 TDn3a11 TDn21a11 1.302320e-014
Cn3an21a7 TDn3a13 TDn21a13 1.302320e-014
Cn3an21a8 TDn3a15 TDn21a15 1.302320e-014
Cn3an21a9 TDn3a17 TDn21a17 1.302320e-014
Cn3an21a10 TDn3a19 TDn21a19 1.302320e-014
Cn3an21a11 TDn3a21 TDn21a21 1.302320e-014
Cn3an21a12 TDn3a23 TDn21a23 1.302320e-014
Cn3an21a13 TDn3a25 TDn21a25 1.302320e-014
Cn3an21a14 TDn3a27 TDn21a27 1.302320e-014
Cn3an21a15 TDn3a29 TDn21a29 1.302320e-014
Cn3an21a16 TDn3a31 TDn21a31 1.302320e-014
Cn3an21a17 TDn3a33 TDn21a33 1.690880e-014
Cn3an22a1 TDn3a1 TDn22a1 1.690880e-014
Cn3an22a2 TDn3a3 TDn22a3 1.302320e-014
Cn3an22a3 TDn3a5 TDn22a5 1.302320e-014
Cn3an22a4 TDn3a7 TDn22a7 1.302320e-014
Cn3an22a5 TDn3a9 TDn22a9 1.302320e-014
Cn3an22a6 TDn3a11 TDn22a11 1.302320e-014
Cn3an22a7 TDn3a13 TDn22a13 1.302320e-014
Cn3an22a8 TDn3a15 TDn22a15 1.302320e-014
Cn3an22a9 TDn3a17 TDn22a17 1.302320e-014
Cn3an22a10 TDn3a19 TDn22a19 1.302320e-014
Cn3an22a11 TDn3a21 TDn22a21 1.302320e-014
Cn3an22a12 TDn3a23 TDn22a23 1.302320e-014
Cn3an22a13 TDn3a25 TDn22a25 1.302320e-014
Cn3an22a14 TDn3a27 TDn22a27 1.302320e-014
Cn3an22a15 TDn3a29 TDn22a29 1.302320e-014
Cn3an22a16 TDn3a31 TDn22a31 1.302320e-014
Cn3an22a17 TDn3a33 TDn22a33 1.690880e-014
Cn3an23a1 TDn3a1 TDn23a1 1.690880e-014
Cn3an23a2 TDn3a3 TDn23a3 1.302320e-014
Cn3an23a3 TDn3a5 TDn23a5 1.302320e-014
Cn3an23a4 TDn3a7 TDn23a7 1.302320e-014
Cn3an23a5 TDn3a9 TDn23a9 1.302320e-014
Cn3an23a6 TDn3a11 TDn23a11 1.302320e-014
Cn3an23a7 TDn3a13 TDn23a13 1.302320e-014
Cn3an23a8 TDn3a15 TDn23a15 1.302320e-014
Cn3an23a9 TDn3a17 TDn23a17 1.302320e-014
Cn3an23a10 TDn3a19 TDn23a19 1.302320e-014
Cn3an23a11 TDn3a21 TDn23a21 1.302320e-014
Cn3an23a12 TDn3a23 TDn23a23 1.302320e-014
Cn3an23a13 TDn3a25 TDn23a25 1.302320e-014
Cn3an23a14 TDn3a27 TDn23a27 1.302320e-014
Cn3an23a15 TDn3a29 TDn23a29 1.302320e-014
Cn3an23a16 TDn3a31 TDn23a31 1.302320e-014
Cn3an23a17 TDn3a33 TDn23a33 1.690880e-014
Cn3an24a1 TDn3a1 TDn24a1 1.690880e-014
Cn3an24a2 TDn3a3 TDn24a3 1.302320e-014
Cn3an24a3 TDn3a5 TDn24a5 1.302320e-014
Cn3an24a4 TDn3a7 TDn24a7 1.302320e-014
Cn3an24a5 TDn3a9 TDn24a9 1.302320e-014
Cn3an24a6 TDn3a11 TDn24a11 1.302320e-014
Cn3an24a7 TDn3a13 TDn24a13 1.302320e-014
Cn3an24a8 TDn3a15 TDn24a15 1.302320e-014
Cn3an24a9 TDn3a17 TDn24a17 1.302320e-014
Cn3an24a10 TDn3a19 TDn24a19 1.302320e-014
Cn3an24a11 TDn3a21 TDn24a21 1.302320e-014
Cn3an24a12 TDn3a23 TDn24a23 1.302320e-014
Cn3an24a13 TDn3a25 TDn24a25 1.302320e-014
Cn3an24a14 TDn3a27 TDn24a27 1.302320e-014
Cn3an24a15 TDn3a29 TDn24a29 1.302320e-014
Cn3an24a16 TDn3a31 TDn24a31 1.302320e-014
Cn3an24a17 TDn3a33 TDn24a33 1.690880e-014
Cn3an25a1 TDn3a1 TDn25a1 1.690880e-014
Cn3an25a2 TDn3a3 TDn25a3 1.302320e-014
Cn3an25a3 TDn3a5 TDn25a5 1.302320e-014
Cn3an25a4 TDn3a7 TDn25a7 1.302320e-014
Cn3an25a5 TDn3a9 TDn25a9 1.302320e-014
Cn3an25a6 TDn3a11 TDn25a11 1.302320e-014
Cn3an25a7 TDn3a13 TDn25a13 1.302320e-014
Cn3an25a8 TDn3a15 TDn25a15 1.302320e-014
Cn3an25a9 TDn3a17 TDn25a17 1.302320e-014
Cn3an25a10 TDn3a19 TDn25a19 1.302320e-014
Cn3an25a11 TDn3a21 TDn25a21 1.302320e-014
Cn3an25a12 TDn3a23 TDn25a23 1.302320e-014
Cn3an25a13 TDn3a25 TDn25a25 1.302320e-014
Cn3an25a14 TDn3a27 TDn25a27 1.302320e-014
Cn3an25a15 TDn3a29 TDn25a29 1.302320e-014
Cn3an25a16 TDn3a31 TDn25a31 1.302320e-014
Cn3an25a17 TDn3a33 TDn25a33 1.690880e-014
Cn3an26a1 TDn3a1 TDn26a1 1.690880e-014
Cn3an26a2 TDn3a3 TDn26a3 1.302320e-014
Cn3an26a3 TDn3a5 TDn26a5 1.302320e-014
Cn3an26a4 TDn3a7 TDn26a7 1.302320e-014
Cn3an26a5 TDn3a9 TDn26a9 1.302320e-014
Cn3an26a6 TDn3a11 TDn26a11 1.302320e-014
Cn3an26a7 TDn3a13 TDn26a13 1.302320e-014
Cn3an26a8 TDn3a15 TDn26a15 1.302320e-014
Cn3an26a9 TDn3a17 TDn26a17 1.302320e-014
Cn3an26a10 TDn3a19 TDn26a19 1.302320e-014
Cn3an26a11 TDn3a21 TDn26a21 1.302320e-014
Cn3an26a12 TDn3a23 TDn26a23 1.302320e-014
Cn3an26a13 TDn3a25 TDn26a25 1.302320e-014
Cn3an26a14 TDn3a27 TDn26a27 1.302320e-014
Cn3an26a15 TDn3a29 TDn26a29 1.302320e-014
Cn3an26a16 TDn3a31 TDn26a31 1.302320e-014
Cn3an26a17 TDn3a33 TDn26a33 1.690880e-014
Cn3an27a1 TDn3a1 TDn27a1 1.690880e-014
Cn3an27a2 TDn3a3 TDn27a3 1.302320e-014
Cn3an27a3 TDn3a5 TDn27a5 1.302320e-014
Cn3an27a4 TDn3a7 TDn27a7 1.302320e-014
Cn3an27a5 TDn3a9 TDn27a9 1.302320e-014
Cn3an27a6 TDn3a11 TDn27a11 1.302320e-014
Cn3an27a7 TDn3a13 TDn27a13 1.302320e-014
Cn3an27a8 TDn3a15 TDn27a15 1.302320e-014
Cn3an27a9 TDn3a17 TDn27a17 1.302320e-014
Cn3an27a10 TDn3a19 TDn27a19 1.302320e-014
Cn3an27a11 TDn3a21 TDn27a21 1.302320e-014
Cn3an27a12 TDn3a23 TDn27a23 1.302320e-014
Cn3an27a13 TDn3a25 TDn27a25 1.302320e-014
Cn3an27a14 TDn3a27 TDn27a27 1.302320e-014
Cn3an27a15 TDn3a29 TDn27a29 1.302320e-014
Cn3an27a16 TDn3a31 TDn27a31 1.302320e-014
Cn3an27a17 TDn3a33 TDn27a33 1.690880e-014
Cn3an28a1 TDn3a1 TDn28a1 1.690880e-014
Cn3an28a2 TDn3a3 TDn28a3 1.302320e-014
Cn3an28a3 TDn3a5 TDn28a5 1.302320e-014
Cn3an28a4 TDn3a7 TDn28a7 1.302320e-014
Cn3an28a5 TDn3a9 TDn28a9 1.302320e-014
Cn3an28a6 TDn3a11 TDn28a11 1.302320e-014
Cn3an28a7 TDn3a13 TDn28a13 1.302320e-014
Cn3an28a8 TDn3a15 TDn28a15 1.302320e-014
Cn3an28a9 TDn3a17 TDn28a17 1.302320e-014
Cn3an28a10 TDn3a19 TDn28a19 1.302320e-014
Cn3an28a11 TDn3a21 TDn28a21 1.302320e-014
Cn3an28a12 TDn3a23 TDn28a23 1.302320e-014
Cn3an28a13 TDn3a25 TDn28a25 1.302320e-014
Cn3an28a14 TDn3a27 TDn28a27 1.302320e-014
Cn3an28a15 TDn3a29 TDn28a29 1.302320e-014
Cn3an28a16 TDn3a31 TDn28a31 1.302320e-014
Cn3an28a17 TDn3a33 TDn28a33 1.690880e-014
Cn3an29a1 TDn3a1 TDn29a1 1.690880e-014
Cn3an29a2 TDn3a3 TDn29a3 1.302320e-014
Cn3an29a3 TDn3a5 TDn29a5 1.302320e-014
Cn3an29a4 TDn3a7 TDn29a7 1.302320e-014
Cn3an29a5 TDn3a9 TDn29a9 1.302320e-014
Cn3an29a6 TDn3a11 TDn29a11 1.302320e-014
Cn3an29a7 TDn3a13 TDn29a13 1.302320e-014
Cn3an29a8 TDn3a15 TDn29a15 1.302320e-014
Cn3an29a9 TDn3a17 TDn29a17 1.302320e-014
Cn3an29a10 TDn3a19 TDn29a19 1.302320e-014
Cn3an29a11 TDn3a21 TDn29a21 1.302320e-014
Cn3an29a12 TDn3a23 TDn29a23 1.302320e-014
Cn3an29a13 TDn3a25 TDn29a25 1.302320e-014
Cn3an29a14 TDn3a27 TDn29a27 1.302320e-014
Cn3an29a15 TDn3a29 TDn29a29 1.302320e-014
Cn3an29a16 TDn3a31 TDn29a31 1.302320e-014
Cn3an29a17 TDn3a33 TDn29a33 1.690880e-014
Cn3an30a1 TDn3a1 TDn30a1 1.690880e-014
Cn3an30a2 TDn3a3 TDn30a3 1.302320e-014
Cn3an30a3 TDn3a5 TDn30a5 1.302320e-014
Cn3an30a4 TDn3a7 TDn30a7 1.302320e-014
Cn3an30a5 TDn3a9 TDn30a9 1.302320e-014
Cn3an30a6 TDn3a11 TDn30a11 1.302320e-014
Cn3an30a7 TDn3a13 TDn30a13 1.302320e-014
Cn3an30a8 TDn3a15 TDn30a15 1.302320e-014
Cn3an30a9 TDn3a17 TDn30a17 1.302320e-014
Cn3an30a10 TDn3a19 TDn30a19 1.302320e-014
Cn3an30a11 TDn3a21 TDn30a21 1.302320e-014
Cn3an30a12 TDn3a23 TDn30a23 1.302320e-014
Cn3an30a13 TDn3a25 TDn30a25 1.302320e-014
Cn3an30a14 TDn3a27 TDn30a27 1.302320e-014
Cn3an30a15 TDn3a29 TDn30a29 1.302320e-014
Cn3an30a16 TDn3a31 TDn30a31 1.302320e-014
Cn3an30a17 TDn3a33 TDn30a33 1.690880e-014
Cn3an31a1 TDn3a1 TDn31a1 1.690880e-014
Cn3an31a2 TDn3a3 TDn31a3 1.302320e-014
Cn3an31a3 TDn3a5 TDn31a5 1.302320e-014
Cn3an31a4 TDn3a7 TDn31a7 1.302320e-014
Cn3an31a5 TDn3a9 TDn31a9 1.302320e-014
Cn3an31a6 TDn3a11 TDn31a11 1.302320e-014
Cn3an31a7 TDn3a13 TDn31a13 1.302320e-014
Cn3an31a8 TDn3a15 TDn31a15 1.302320e-014
Cn3an31a9 TDn3a17 TDn31a17 1.302320e-014
Cn3an31a10 TDn3a19 TDn31a19 1.302320e-014
Cn3an31a11 TDn3a21 TDn31a21 1.302320e-014
Cn3an31a12 TDn3a23 TDn31a23 1.302320e-014
Cn3an31a13 TDn3a25 TDn31a25 1.302320e-014
Cn3an31a14 TDn3a27 TDn31a27 1.302320e-014
Cn3an31a15 TDn3a29 TDn31a29 1.302320e-014
Cn3an31a16 TDn3a31 TDn31a31 1.302320e-014
Cn3an31a17 TDn3a33 TDn31a33 1.690880e-014
Cn3an32a1 TDn3a1 TDn32a1 1.690880e-014
Cn3an32a2 TDn3a3 TDn32a3 1.302320e-014
Cn3an32a3 TDn3a5 TDn32a5 1.302320e-014
Cn3an32a4 TDn3a7 TDn32a7 1.302320e-014
Cn3an32a5 TDn3a9 TDn32a9 1.302320e-014
Cn3an32a6 TDn3a11 TDn32a11 1.302320e-014
Cn3an32a7 TDn3a13 TDn32a13 1.302320e-014
Cn3an32a8 TDn3a15 TDn32a15 1.302320e-014
Cn3an32a9 TDn3a17 TDn32a17 1.302320e-014
Cn3an32a10 TDn3a19 TDn32a19 1.302320e-014
Cn3an32a11 TDn3a21 TDn32a21 1.302320e-014
Cn3an32a12 TDn3a23 TDn32a23 1.302320e-014
Cn3an32a13 TDn3a25 TDn32a25 1.302320e-014
Cn3an32a14 TDn3a27 TDn32a27 1.302320e-014
Cn3an32a15 TDn3a29 TDn32a29 1.302320e-014
Cn3an32a16 TDn3a31 TDn32a31 1.302320e-014
Cn3an32a17 TDn3a33 TDn32a33 1.690880e-014
Cn3anva1 TDn3a1 TDnva1 1.690880e-014
Cn3anva2 TDn3a3 TDnva3 1.690880e-014
Cn3anva3 TDn3a5 TDnva5 1.690880e-014
Cn3anva4 TDn3a7 TDnva7 1.690880e-014
Cn3anva5 TDn3a9 TDnva9 1.690880e-014
Cn3anva6 TDn3a11 TDnva11 1.690880e-014
Cn3anva7 TDn3a13 TDnva13 1.690880e-014
Cn3anva8 TDn3a15 TDnva15 1.690880e-014
Cn3anva9 TDn3a17 TDnva17 1.690880e-014
Cn3anva10 TDn3a19 TDnva19 1.690880e-014
Cn3anva11 TDn3a21 TDnva21 1.690880e-014
Cn3anva12 TDn3a23 TDnva23 1.690880e-014
Cn3anva13 TDn3a25 TDnva25 1.690880e-014
Cn3anva14 TDn3a27 TDnva27 1.690880e-014
Cn3anva15 TDn3a29 TDnva29 1.690880e-014
Cn3anva16 TDn3a31 TDnva31 1.690880e-014
Cn3anva17 TDn3a33 TDnva33 1.690880e-014
Cn4an5a1 TDn4a1 TDn5a1 1.573240e-014
Cn4an5a2 TDn4a3 TDn5a3 3.146480e-014
Cn4an5a3 TDn4a5 TDn5a5 3.146480e-014
Cn4an5a4 TDn4a7 TDn5a7 3.146480e-014
Cn4an5a5 TDn4a9 TDn5a9 3.146480e-014
Cn4an5a6 TDn4a11 TDn5a11 3.146480e-014
Cn4an5a7 TDn4a13 TDn5a13 3.146480e-014
Cn4an5a8 TDn4a15 TDn5a15 3.146480e-014
Cn4an5a9 TDn4a17 TDn5a17 3.146480e-014
Cn4an5a10 TDn4a19 TDn5a19 3.146480e-014
Cn4an5a11 TDn4a21 TDn5a21 3.146480e-014
Cn4an5a12 TDn4a23 TDn5a23 3.146480e-014
Cn4an5a13 TDn4a25 TDn5a25 3.146480e-014
Cn4an5a14 TDn4a27 TDn5a27 3.146480e-014
Cn4an5a15 TDn4a29 TDn5a29 3.146480e-014
Cn4an5a16 TDn4a31 TDn5a31 3.146480e-014
Cn4an5a17 TDn4a33 TDn5a33 1.573240e-014
Cn4an6a1 TDn4a1 TDn6a1 5.586810e-015
Cn4an6a2 TDn4a3 TDn6a3 1.117360e-014
Cn4an6a3 TDn4a5 TDn6a5 1.117360e-014
Cn4an6a4 TDn4a7 TDn6a7 1.117360e-014
Cn4an6a5 TDn4a9 TDn6a9 1.117360e-014
Cn4an6a6 TDn4a11 TDn6a11 1.117360e-014
Cn4an6a7 TDn4a13 TDn6a13 1.117360e-014
Cn4an6a8 TDn4a15 TDn6a15 1.117360e-014
Cn4an6a9 TDn4a17 TDn6a17 1.117360e-014
Cn4an6a10 TDn4a19 TDn6a19 1.117360e-014
Cn4an6a11 TDn4a21 TDn6a21 1.117360e-014
Cn4an6a12 TDn4a23 TDn6a23 1.117360e-014
Cn4an6a13 TDn4a25 TDn6a25 1.117360e-014
Cn4an6a14 TDn4a27 TDn6a27 1.117360e-014
Cn4an6a15 TDn4a29 TDn6a29 1.117360e-014
Cn4an6a16 TDn4a31 TDn6a31 1.117360e-014
Cn4an6a17 TDn4a33 TDn6a33 5.586810e-015
Cn4an7a1 TDn4a1 TDn7a1 5.148610e-015
Cn4an7a2 TDn4a3 TDn7a3 1.029720e-014
Cn4an7a3 TDn4a5 TDn7a5 1.029720e-014
Cn4an7a4 TDn4a7 TDn7a7 1.029720e-014
Cn4an7a5 TDn4a9 TDn7a9 1.029720e-014
Cn4an7a6 TDn4a11 TDn7a11 1.029720e-014
Cn4an7a7 TDn4a13 TDn7a13 1.029720e-014
Cn4an7a8 TDn4a15 TDn7a15 1.029720e-014
Cn4an7a9 TDn4a17 TDn7a17 1.029720e-014
Cn4an7a10 TDn4a19 TDn7a19 1.029720e-014
Cn4an7a11 TDn4a21 TDn7a21 1.029720e-014
Cn4an7a12 TDn4a23 TDn7a23 1.029720e-014
Cn4an7a13 TDn4a25 TDn7a25 1.029720e-014
Cn4an7a14 TDn4a27 TDn7a27 1.029720e-014
Cn4an7a15 TDn4a29 TDn7a29 1.029720e-014
Cn4an7a16 TDn4a31 TDn7a31 1.029720e-014
Cn4an7a17 TDn4a33 TDn7a33 5.148610e-015
Cn4an8a1 TDn4a1 TDn8a1 5.060570e-015
Cn4an8a2 TDn4a3 TDn8a3 1.012110e-014
Cn4an8a3 TDn4a5 TDn8a5 1.012110e-014
Cn4an8a4 TDn4a7 TDn8a7 1.012110e-014
Cn4an8a5 TDn4a9 TDn8a9 1.012110e-014
Cn4an8a6 TDn4a11 TDn8a11 1.012110e-014
Cn4an8a7 TDn4a13 TDn8a13 1.012110e-014
Cn4an8a8 TDn4a15 TDn8a15 1.012110e-014
Cn4an8a9 TDn4a17 TDn8a17 1.012110e-014
Cn4an8a10 TDn4a19 TDn8a19 1.012110e-014
Cn4an8a11 TDn4a21 TDn8a21 1.012110e-014
Cn4an8a12 TDn4a23 TDn8a23 1.012110e-014
Cn4an8a13 TDn4a25 TDn8a25 1.012110e-014
Cn4an8a14 TDn4a27 TDn8a27 1.012110e-014
Cn4an8a15 TDn4a29 TDn8a29 1.012110e-014
Cn4an8a16 TDn4a31 TDn8a31 1.012110e-014
Cn4an8a17 TDn4a33 TDn8a33 5.060570e-015
Cn4an9a1 TDn4a1 TDn9a1 5.736010e-015
Cn4an9a2 TDn4a3 TDn9a3 1.147200e-014
Cn4an9a3 TDn4a5 TDn9a5 1.147200e-014
Cn4an9a4 TDn4a7 TDn9a7 1.147200e-014
Cn4an9a5 TDn4a9 TDn9a9 1.147200e-014
Cn4an9a6 TDn4a11 TDn9a11 1.147200e-014
Cn4an9a7 TDn4a13 TDn9a13 1.147200e-014
Cn4an9a8 TDn4a15 TDn9a15 1.147200e-014
Cn4an9a9 TDn4a17 TDn9a17 1.147200e-014
Cn4an9a10 TDn4a19 TDn9a19 1.147200e-014
Cn4an9a11 TDn4a21 TDn9a21 1.147200e-014
Cn4an9a12 TDn4a23 TDn9a23 1.147200e-014
Cn4an9a13 TDn4a25 TDn9a25 1.147200e-014
Cn4an9a14 TDn4a27 TDn9a27 1.147200e-014
Cn4an9a15 TDn4a29 TDn9a29 1.147200e-014
Cn4an9a16 TDn4a31 TDn9a31 1.147200e-014
Cn4an9a17 TDn4a33 TDn9a33 5.736010e-015
Cn4an10a1 TDn4a1 TDn10a1 1.690880e-014
Cn4an10a2 TDn4a3 TDn10a3 1.302320e-014
Cn4an10a3 TDn4a5 TDn10a5 1.302320e-014
Cn4an10a4 TDn4a7 TDn10a7 1.302320e-014
Cn4an10a5 TDn4a9 TDn10a9 1.302320e-014
Cn4an10a6 TDn4a11 TDn10a11 1.302320e-014
Cn4an10a7 TDn4a13 TDn10a13 1.302320e-014
Cn4an10a8 TDn4a15 TDn10a15 1.302320e-014
Cn4an10a9 TDn4a17 TDn10a17 1.302320e-014
Cn4an10a10 TDn4a19 TDn10a19 1.302320e-014
Cn4an10a11 TDn4a21 TDn10a21 1.302320e-014
Cn4an10a12 TDn4a23 TDn10a23 1.302320e-014
Cn4an10a13 TDn4a25 TDn10a25 1.302320e-014
Cn4an10a14 TDn4a27 TDn10a27 1.302320e-014
Cn4an10a15 TDn4a29 TDn10a29 1.302320e-014
Cn4an10a16 TDn4a31 TDn10a31 1.302320e-014
Cn4an10a17 TDn4a33 TDn10a33 1.690880e-014
Cn4an11a1 TDn4a1 TDn11a1 1.690880e-014
Cn4an11a2 TDn4a3 TDn11a3 1.302320e-014
Cn4an11a3 TDn4a5 TDn11a5 1.302320e-014
Cn4an11a4 TDn4a7 TDn11a7 1.302320e-014
Cn4an11a5 TDn4a9 TDn11a9 1.302320e-014
Cn4an11a6 TDn4a11 TDn11a11 1.302320e-014
Cn4an11a7 TDn4a13 TDn11a13 1.302320e-014
Cn4an11a8 TDn4a15 TDn11a15 1.302320e-014
Cn4an11a9 TDn4a17 TDn11a17 1.302320e-014
Cn4an11a10 TDn4a19 TDn11a19 1.302320e-014
Cn4an11a11 TDn4a21 TDn11a21 1.302320e-014
Cn4an11a12 TDn4a23 TDn11a23 1.302320e-014
Cn4an11a13 TDn4a25 TDn11a25 1.302320e-014
Cn4an11a14 TDn4a27 TDn11a27 1.302320e-014
Cn4an11a15 TDn4a29 TDn11a29 1.302320e-014
Cn4an11a16 TDn4a31 TDn11a31 1.302320e-014
Cn4an11a17 TDn4a33 TDn11a33 1.690880e-014
Cn4an12a1 TDn4a1 TDn12a1 1.690880e-014
Cn4an12a2 TDn4a3 TDn12a3 1.302320e-014
Cn4an12a3 TDn4a5 TDn12a5 1.302320e-014
Cn4an12a4 TDn4a7 TDn12a7 1.302320e-014
Cn4an12a5 TDn4a9 TDn12a9 1.302320e-014
Cn4an12a6 TDn4a11 TDn12a11 1.302320e-014
Cn4an12a7 TDn4a13 TDn12a13 1.302320e-014
Cn4an12a8 TDn4a15 TDn12a15 1.302320e-014
Cn4an12a9 TDn4a17 TDn12a17 1.302320e-014
Cn4an12a10 TDn4a19 TDn12a19 1.302320e-014
Cn4an12a11 TDn4a21 TDn12a21 1.302320e-014
Cn4an12a12 TDn4a23 TDn12a23 1.302320e-014
Cn4an12a13 TDn4a25 TDn12a25 1.302320e-014
Cn4an12a14 TDn4a27 TDn12a27 1.302320e-014
Cn4an12a15 TDn4a29 TDn12a29 1.302320e-014
Cn4an12a16 TDn4a31 TDn12a31 1.302320e-014
Cn4an12a17 TDn4a33 TDn12a33 1.690880e-014
Cn4an13a1 TDn4a1 TDn13a1 1.690880e-014
Cn4an13a2 TDn4a3 TDn13a3 1.302320e-014
Cn4an13a3 TDn4a5 TDn13a5 1.302320e-014
Cn4an13a4 TDn4a7 TDn13a7 1.302320e-014
Cn4an13a5 TDn4a9 TDn13a9 1.302320e-014
Cn4an13a6 TDn4a11 TDn13a11 1.302320e-014
Cn4an13a7 TDn4a13 TDn13a13 1.302320e-014
Cn4an13a8 TDn4a15 TDn13a15 1.302320e-014
Cn4an13a9 TDn4a17 TDn13a17 1.302320e-014
Cn4an13a10 TDn4a19 TDn13a19 1.302320e-014
Cn4an13a11 TDn4a21 TDn13a21 1.302320e-014
Cn4an13a12 TDn4a23 TDn13a23 1.302320e-014
Cn4an13a13 TDn4a25 TDn13a25 1.302320e-014
Cn4an13a14 TDn4a27 TDn13a27 1.302320e-014
Cn4an13a15 TDn4a29 TDn13a29 1.302320e-014
Cn4an13a16 TDn4a31 TDn13a31 1.302320e-014
Cn4an13a17 TDn4a33 TDn13a33 1.690880e-014
Cn4an14a1 TDn4a1 TDn14a1 1.690880e-014
Cn4an14a2 TDn4a3 TDn14a3 1.302320e-014
Cn4an14a3 TDn4a5 TDn14a5 1.302320e-014
Cn4an14a4 TDn4a7 TDn14a7 1.302320e-014
Cn4an14a5 TDn4a9 TDn14a9 1.302320e-014
Cn4an14a6 TDn4a11 TDn14a11 1.302320e-014
Cn4an14a7 TDn4a13 TDn14a13 1.302320e-014
Cn4an14a8 TDn4a15 TDn14a15 1.302320e-014
Cn4an14a9 TDn4a17 TDn14a17 1.302320e-014
Cn4an14a10 TDn4a19 TDn14a19 1.302320e-014
Cn4an14a11 TDn4a21 TDn14a21 1.302320e-014
Cn4an14a12 TDn4a23 TDn14a23 1.302320e-014
Cn4an14a13 TDn4a25 TDn14a25 1.302320e-014
Cn4an14a14 TDn4a27 TDn14a27 1.302320e-014
Cn4an14a15 TDn4a29 TDn14a29 1.302320e-014
Cn4an14a16 TDn4a31 TDn14a31 1.302320e-014
Cn4an14a17 TDn4a33 TDn14a33 1.690880e-014
Cn4an15a1 TDn4a1 TDn15a1 1.690880e-014
Cn4an15a2 TDn4a3 TDn15a3 1.302320e-014
Cn4an15a3 TDn4a5 TDn15a5 1.302320e-014
Cn4an15a4 TDn4a7 TDn15a7 1.302320e-014
Cn4an15a5 TDn4a9 TDn15a9 1.302320e-014
Cn4an15a6 TDn4a11 TDn15a11 1.302320e-014
Cn4an15a7 TDn4a13 TDn15a13 1.302320e-014
Cn4an15a8 TDn4a15 TDn15a15 1.302320e-014
Cn4an15a9 TDn4a17 TDn15a17 1.302320e-014
Cn4an15a10 TDn4a19 TDn15a19 1.302320e-014
Cn4an15a11 TDn4a21 TDn15a21 1.302320e-014
Cn4an15a12 TDn4a23 TDn15a23 1.302320e-014
Cn4an15a13 TDn4a25 TDn15a25 1.302320e-014
Cn4an15a14 TDn4a27 TDn15a27 1.302320e-014
Cn4an15a15 TDn4a29 TDn15a29 1.302320e-014
Cn4an15a16 TDn4a31 TDn15a31 1.302320e-014
Cn4an15a17 TDn4a33 TDn15a33 1.690880e-014
Cn4an16a1 TDn4a1 TDn16a1 1.690880e-014
Cn4an16a2 TDn4a3 TDn16a3 1.302320e-014
Cn4an16a3 TDn4a5 TDn16a5 1.302320e-014
Cn4an16a4 TDn4a7 TDn16a7 1.302320e-014
Cn4an16a5 TDn4a9 TDn16a9 1.302320e-014
Cn4an16a6 TDn4a11 TDn16a11 1.302320e-014
Cn4an16a7 TDn4a13 TDn16a13 1.302320e-014
Cn4an16a8 TDn4a15 TDn16a15 1.302320e-014
Cn4an16a9 TDn4a17 TDn16a17 1.302320e-014
Cn4an16a10 TDn4a19 TDn16a19 1.302320e-014
Cn4an16a11 TDn4a21 TDn16a21 1.302320e-014
Cn4an16a12 TDn4a23 TDn16a23 1.302320e-014
Cn4an16a13 TDn4a25 TDn16a25 1.302320e-014
Cn4an16a14 TDn4a27 TDn16a27 1.302320e-014
Cn4an16a15 TDn4a29 TDn16a29 1.302320e-014
Cn4an16a16 TDn4a31 TDn16a31 1.302320e-014
Cn4an16a17 TDn4a33 TDn16a33 1.690880e-014
Cn4an17a1 TDn4a1 TDn17a1 1.690880e-014
Cn4an17a2 TDn4a3 TDn17a3 1.302320e-014
Cn4an17a3 TDn4a5 TDn17a5 1.302320e-014
Cn4an17a4 TDn4a7 TDn17a7 1.302320e-014
Cn4an17a5 TDn4a9 TDn17a9 1.302320e-014
Cn4an17a6 TDn4a11 TDn17a11 1.302320e-014
Cn4an17a7 TDn4a13 TDn17a13 1.302320e-014
Cn4an17a8 TDn4a15 TDn17a15 1.302320e-014
Cn4an17a9 TDn4a17 TDn17a17 1.302320e-014
Cn4an17a10 TDn4a19 TDn17a19 1.302320e-014
Cn4an17a11 TDn4a21 TDn17a21 1.302320e-014
Cn4an17a12 TDn4a23 TDn17a23 1.302320e-014
Cn4an17a13 TDn4a25 TDn17a25 1.302320e-014
Cn4an17a14 TDn4a27 TDn17a27 1.302320e-014
Cn4an17a15 TDn4a29 TDn17a29 1.302320e-014
Cn4an17a16 TDn4a31 TDn17a31 1.302320e-014
Cn4an17a17 TDn4a33 TDn17a33 1.690880e-014
Cn4an18a1 TDn4a1 TDn18a1 1.690880e-014
Cn4an18a2 TDn4a3 TDn18a3 1.302320e-014
Cn4an18a3 TDn4a5 TDn18a5 1.302320e-014
Cn4an18a4 TDn4a7 TDn18a7 1.302320e-014
Cn4an18a5 TDn4a9 TDn18a9 1.302320e-014
Cn4an18a6 TDn4a11 TDn18a11 1.302320e-014
Cn4an18a7 TDn4a13 TDn18a13 1.302320e-014
Cn4an18a8 TDn4a15 TDn18a15 1.302320e-014
Cn4an18a9 TDn4a17 TDn18a17 1.302320e-014
Cn4an18a10 TDn4a19 TDn18a19 1.302320e-014
Cn4an18a11 TDn4a21 TDn18a21 1.302320e-014
Cn4an18a12 TDn4a23 TDn18a23 1.302320e-014
Cn4an18a13 TDn4a25 TDn18a25 1.302320e-014
Cn4an18a14 TDn4a27 TDn18a27 1.302320e-014
Cn4an18a15 TDn4a29 TDn18a29 1.302320e-014
Cn4an18a16 TDn4a31 TDn18a31 1.302320e-014
Cn4an18a17 TDn4a33 TDn18a33 1.690880e-014
Cn4an19a1 TDn4a1 TDn19a1 1.690880e-014
Cn4an19a2 TDn4a3 TDn19a3 1.302320e-014
Cn4an19a3 TDn4a5 TDn19a5 1.302320e-014
Cn4an19a4 TDn4a7 TDn19a7 1.302320e-014
Cn4an19a5 TDn4a9 TDn19a9 1.302320e-014
Cn4an19a6 TDn4a11 TDn19a11 1.302320e-014
Cn4an19a7 TDn4a13 TDn19a13 1.302320e-014
Cn4an19a8 TDn4a15 TDn19a15 1.302320e-014
Cn4an19a9 TDn4a17 TDn19a17 1.302320e-014
Cn4an19a10 TDn4a19 TDn19a19 1.302320e-014
Cn4an19a11 TDn4a21 TDn19a21 1.302320e-014
Cn4an19a12 TDn4a23 TDn19a23 1.302320e-014
Cn4an19a13 TDn4a25 TDn19a25 1.302320e-014
Cn4an19a14 TDn4a27 TDn19a27 1.302320e-014
Cn4an19a15 TDn4a29 TDn19a29 1.302320e-014
Cn4an19a16 TDn4a31 TDn19a31 1.302320e-014
Cn4an19a17 TDn4a33 TDn19a33 1.690880e-014
Cn4an20a1 TDn4a1 TDn20a1 1.690880e-014
Cn4an20a2 TDn4a3 TDn20a3 1.302320e-014
Cn4an20a3 TDn4a5 TDn20a5 1.302320e-014
Cn4an20a4 TDn4a7 TDn20a7 1.302320e-014
Cn4an20a5 TDn4a9 TDn20a9 1.302320e-014
Cn4an20a6 TDn4a11 TDn20a11 1.302320e-014
Cn4an20a7 TDn4a13 TDn20a13 1.302320e-014
Cn4an20a8 TDn4a15 TDn20a15 1.302320e-014
Cn4an20a9 TDn4a17 TDn20a17 1.302320e-014
Cn4an20a10 TDn4a19 TDn20a19 1.302320e-014
Cn4an20a11 TDn4a21 TDn20a21 1.302320e-014
Cn4an20a12 TDn4a23 TDn20a23 1.302320e-014
Cn4an20a13 TDn4a25 TDn20a25 1.302320e-014
Cn4an20a14 TDn4a27 TDn20a27 1.302320e-014
Cn4an20a15 TDn4a29 TDn20a29 1.302320e-014
Cn4an20a16 TDn4a31 TDn20a31 1.302320e-014
Cn4an20a17 TDn4a33 TDn20a33 1.690880e-014
Cn4an21a1 TDn4a1 TDn21a1 1.690880e-014
Cn4an21a2 TDn4a3 TDn21a3 1.302320e-014
Cn4an21a3 TDn4a5 TDn21a5 1.302320e-014
Cn4an21a4 TDn4a7 TDn21a7 1.302320e-014
Cn4an21a5 TDn4a9 TDn21a9 1.302320e-014
Cn4an21a6 TDn4a11 TDn21a11 1.302320e-014
Cn4an21a7 TDn4a13 TDn21a13 1.302320e-014
Cn4an21a8 TDn4a15 TDn21a15 1.302320e-014
Cn4an21a9 TDn4a17 TDn21a17 1.302320e-014
Cn4an21a10 TDn4a19 TDn21a19 1.302320e-014
Cn4an21a11 TDn4a21 TDn21a21 1.302320e-014
Cn4an21a12 TDn4a23 TDn21a23 1.302320e-014
Cn4an21a13 TDn4a25 TDn21a25 1.302320e-014
Cn4an21a14 TDn4a27 TDn21a27 1.302320e-014
Cn4an21a15 TDn4a29 TDn21a29 1.302320e-014
Cn4an21a16 TDn4a31 TDn21a31 1.302320e-014
Cn4an21a17 TDn4a33 TDn21a33 1.690880e-014
Cn4an22a1 TDn4a1 TDn22a1 1.690880e-014
Cn4an22a2 TDn4a3 TDn22a3 1.302320e-014
Cn4an22a3 TDn4a5 TDn22a5 1.302320e-014
Cn4an22a4 TDn4a7 TDn22a7 1.302320e-014
Cn4an22a5 TDn4a9 TDn22a9 1.302320e-014
Cn4an22a6 TDn4a11 TDn22a11 1.302320e-014
Cn4an22a7 TDn4a13 TDn22a13 1.302320e-014
Cn4an22a8 TDn4a15 TDn22a15 1.302320e-014
Cn4an22a9 TDn4a17 TDn22a17 1.302320e-014
Cn4an22a10 TDn4a19 TDn22a19 1.302320e-014
Cn4an22a11 TDn4a21 TDn22a21 1.302320e-014
Cn4an22a12 TDn4a23 TDn22a23 1.302320e-014
Cn4an22a13 TDn4a25 TDn22a25 1.302320e-014
Cn4an22a14 TDn4a27 TDn22a27 1.302320e-014
Cn4an22a15 TDn4a29 TDn22a29 1.302320e-014
Cn4an22a16 TDn4a31 TDn22a31 1.302320e-014
Cn4an22a17 TDn4a33 TDn22a33 1.690880e-014
Cn4an23a1 TDn4a1 TDn23a1 1.690880e-014
Cn4an23a2 TDn4a3 TDn23a3 1.302320e-014
Cn4an23a3 TDn4a5 TDn23a5 1.302320e-014
Cn4an23a4 TDn4a7 TDn23a7 1.302320e-014
Cn4an23a5 TDn4a9 TDn23a9 1.302320e-014
Cn4an23a6 TDn4a11 TDn23a11 1.302320e-014
Cn4an23a7 TDn4a13 TDn23a13 1.302320e-014
Cn4an23a8 TDn4a15 TDn23a15 1.302320e-014
Cn4an23a9 TDn4a17 TDn23a17 1.302320e-014
Cn4an23a10 TDn4a19 TDn23a19 1.302320e-014
Cn4an23a11 TDn4a21 TDn23a21 1.302320e-014
Cn4an23a12 TDn4a23 TDn23a23 1.302320e-014
Cn4an23a13 TDn4a25 TDn23a25 1.302320e-014
Cn4an23a14 TDn4a27 TDn23a27 1.302320e-014
Cn4an23a15 TDn4a29 TDn23a29 1.302320e-014
Cn4an23a16 TDn4a31 TDn23a31 1.302320e-014
Cn4an23a17 TDn4a33 TDn23a33 1.690880e-014
Cn4an24a1 TDn4a1 TDn24a1 1.690880e-014
Cn4an24a2 TDn4a3 TDn24a3 1.302320e-014
Cn4an24a3 TDn4a5 TDn24a5 1.302320e-014
Cn4an24a4 TDn4a7 TDn24a7 1.302320e-014
Cn4an24a5 TDn4a9 TDn24a9 1.302320e-014
Cn4an24a6 TDn4a11 TDn24a11 1.302320e-014
Cn4an24a7 TDn4a13 TDn24a13 1.302320e-014
Cn4an24a8 TDn4a15 TDn24a15 1.302320e-014
Cn4an24a9 TDn4a17 TDn24a17 1.302320e-014
Cn4an24a10 TDn4a19 TDn24a19 1.302320e-014
Cn4an24a11 TDn4a21 TDn24a21 1.302320e-014
Cn4an24a12 TDn4a23 TDn24a23 1.302320e-014
Cn4an24a13 TDn4a25 TDn24a25 1.302320e-014
Cn4an24a14 TDn4a27 TDn24a27 1.302320e-014
Cn4an24a15 TDn4a29 TDn24a29 1.302320e-014
Cn4an24a16 TDn4a31 TDn24a31 1.302320e-014
Cn4an24a17 TDn4a33 TDn24a33 1.690880e-014
Cn4an25a1 TDn4a1 TDn25a1 1.690880e-014
Cn4an25a2 TDn4a3 TDn25a3 1.302320e-014
Cn4an25a3 TDn4a5 TDn25a5 1.302320e-014
Cn4an25a4 TDn4a7 TDn25a7 1.302320e-014
Cn4an25a5 TDn4a9 TDn25a9 1.302320e-014
Cn4an25a6 TDn4a11 TDn25a11 1.302320e-014
Cn4an25a7 TDn4a13 TDn25a13 1.302320e-014
Cn4an25a8 TDn4a15 TDn25a15 1.302320e-014
Cn4an25a9 TDn4a17 TDn25a17 1.302320e-014
Cn4an25a10 TDn4a19 TDn25a19 1.302320e-014
Cn4an25a11 TDn4a21 TDn25a21 1.302320e-014
Cn4an25a12 TDn4a23 TDn25a23 1.302320e-014
Cn4an25a13 TDn4a25 TDn25a25 1.302320e-014
Cn4an25a14 TDn4a27 TDn25a27 1.302320e-014
Cn4an25a15 TDn4a29 TDn25a29 1.302320e-014
Cn4an25a16 TDn4a31 TDn25a31 1.302320e-014
Cn4an25a17 TDn4a33 TDn25a33 1.690880e-014
Cn4an26a1 TDn4a1 TDn26a1 1.690880e-014
Cn4an26a2 TDn4a3 TDn26a3 1.302320e-014
Cn4an26a3 TDn4a5 TDn26a5 1.302320e-014
Cn4an26a4 TDn4a7 TDn26a7 1.302320e-014
Cn4an26a5 TDn4a9 TDn26a9 1.302320e-014
Cn4an26a6 TDn4a11 TDn26a11 1.302320e-014
Cn4an26a7 TDn4a13 TDn26a13 1.302320e-014
Cn4an26a8 TDn4a15 TDn26a15 1.302320e-014
Cn4an26a9 TDn4a17 TDn26a17 1.302320e-014
Cn4an26a10 TDn4a19 TDn26a19 1.302320e-014
Cn4an26a11 TDn4a21 TDn26a21 1.302320e-014
Cn4an26a12 TDn4a23 TDn26a23 1.302320e-014
Cn4an26a13 TDn4a25 TDn26a25 1.302320e-014
Cn4an26a14 TDn4a27 TDn26a27 1.302320e-014
Cn4an26a15 TDn4a29 TDn26a29 1.302320e-014
Cn4an26a16 TDn4a31 TDn26a31 1.302320e-014
Cn4an26a17 TDn4a33 TDn26a33 1.690880e-014
Cn4an27a1 TDn4a1 TDn27a1 1.690880e-014
Cn4an27a2 TDn4a3 TDn27a3 1.302320e-014
Cn4an27a3 TDn4a5 TDn27a5 1.302320e-014
Cn4an27a4 TDn4a7 TDn27a7 1.302320e-014
Cn4an27a5 TDn4a9 TDn27a9 1.302320e-014
Cn4an27a6 TDn4a11 TDn27a11 1.302320e-014
Cn4an27a7 TDn4a13 TDn27a13 1.302320e-014
Cn4an27a8 TDn4a15 TDn27a15 1.302320e-014
Cn4an27a9 TDn4a17 TDn27a17 1.302320e-014
Cn4an27a10 TDn4a19 TDn27a19 1.302320e-014
Cn4an27a11 TDn4a21 TDn27a21 1.302320e-014
Cn4an27a12 TDn4a23 TDn27a23 1.302320e-014
Cn4an27a13 TDn4a25 TDn27a25 1.302320e-014
Cn4an27a14 TDn4a27 TDn27a27 1.302320e-014
Cn4an27a15 TDn4a29 TDn27a29 1.302320e-014
Cn4an27a16 TDn4a31 TDn27a31 1.302320e-014
Cn4an27a17 TDn4a33 TDn27a33 1.690880e-014
Cn4an28a1 TDn4a1 TDn28a1 1.690880e-014
Cn4an28a2 TDn4a3 TDn28a3 1.302320e-014
Cn4an28a3 TDn4a5 TDn28a5 1.302320e-014
Cn4an28a4 TDn4a7 TDn28a7 1.302320e-014
Cn4an28a5 TDn4a9 TDn28a9 1.302320e-014
Cn4an28a6 TDn4a11 TDn28a11 1.302320e-014
Cn4an28a7 TDn4a13 TDn28a13 1.302320e-014
Cn4an28a8 TDn4a15 TDn28a15 1.302320e-014
Cn4an28a9 TDn4a17 TDn28a17 1.302320e-014
Cn4an28a10 TDn4a19 TDn28a19 1.302320e-014
Cn4an28a11 TDn4a21 TDn28a21 1.302320e-014
Cn4an28a12 TDn4a23 TDn28a23 1.302320e-014
Cn4an28a13 TDn4a25 TDn28a25 1.302320e-014
Cn4an28a14 TDn4a27 TDn28a27 1.302320e-014
Cn4an28a15 TDn4a29 TDn28a29 1.302320e-014
Cn4an28a16 TDn4a31 TDn28a31 1.302320e-014
Cn4an28a17 TDn4a33 TDn28a33 1.690880e-014
Cn4an29a1 TDn4a1 TDn29a1 1.690880e-014
Cn4an29a2 TDn4a3 TDn29a3 1.302320e-014
Cn4an29a3 TDn4a5 TDn29a5 1.302320e-014
Cn4an29a4 TDn4a7 TDn29a7 1.302320e-014
Cn4an29a5 TDn4a9 TDn29a9 1.302320e-014
Cn4an29a6 TDn4a11 TDn29a11 1.302320e-014
Cn4an29a7 TDn4a13 TDn29a13 1.302320e-014
Cn4an29a8 TDn4a15 TDn29a15 1.302320e-014
Cn4an29a9 TDn4a17 TDn29a17 1.302320e-014
Cn4an29a10 TDn4a19 TDn29a19 1.302320e-014
Cn4an29a11 TDn4a21 TDn29a21 1.302320e-014
Cn4an29a12 TDn4a23 TDn29a23 1.302320e-014
Cn4an29a13 TDn4a25 TDn29a25 1.302320e-014
Cn4an29a14 TDn4a27 TDn29a27 1.302320e-014
Cn4an29a15 TDn4a29 TDn29a29 1.302320e-014
Cn4an29a16 TDn4a31 TDn29a31 1.302320e-014
Cn4an29a17 TDn4a33 TDn29a33 1.690880e-014
Cn4an30a1 TDn4a1 TDn30a1 1.690880e-014
Cn4an30a2 TDn4a3 TDn30a3 1.302320e-014
Cn4an30a3 TDn4a5 TDn30a5 1.302320e-014
Cn4an30a4 TDn4a7 TDn30a7 1.302320e-014
Cn4an30a5 TDn4a9 TDn30a9 1.302320e-014
Cn4an30a6 TDn4a11 TDn30a11 1.302320e-014
Cn4an30a7 TDn4a13 TDn30a13 1.302320e-014
Cn4an30a8 TDn4a15 TDn30a15 1.302320e-014
Cn4an30a9 TDn4a17 TDn30a17 1.302320e-014
Cn4an30a10 TDn4a19 TDn30a19 1.302320e-014
Cn4an30a11 TDn4a21 TDn30a21 1.302320e-014
Cn4an30a12 TDn4a23 TDn30a23 1.302320e-014
Cn4an30a13 TDn4a25 TDn30a25 1.302320e-014
Cn4an30a14 TDn4a27 TDn30a27 1.302320e-014
Cn4an30a15 TDn4a29 TDn30a29 1.302320e-014
Cn4an30a16 TDn4a31 TDn30a31 1.302320e-014
Cn4an30a17 TDn4a33 TDn30a33 1.690880e-014
Cn4an31a1 TDn4a1 TDn31a1 1.690880e-014
Cn4an31a2 TDn4a3 TDn31a3 1.302320e-014
Cn4an31a3 TDn4a5 TDn31a5 1.302320e-014
Cn4an31a4 TDn4a7 TDn31a7 1.302320e-014
Cn4an31a5 TDn4a9 TDn31a9 1.302320e-014
Cn4an31a6 TDn4a11 TDn31a11 1.302320e-014
Cn4an31a7 TDn4a13 TDn31a13 1.302320e-014
Cn4an31a8 TDn4a15 TDn31a15 1.302320e-014
Cn4an31a9 TDn4a17 TDn31a17 1.302320e-014
Cn4an31a10 TDn4a19 TDn31a19 1.302320e-014
Cn4an31a11 TDn4a21 TDn31a21 1.302320e-014
Cn4an31a12 TDn4a23 TDn31a23 1.302320e-014
Cn4an31a13 TDn4a25 TDn31a25 1.302320e-014
Cn4an31a14 TDn4a27 TDn31a27 1.302320e-014
Cn4an31a15 TDn4a29 TDn31a29 1.302320e-014
Cn4an31a16 TDn4a31 TDn31a31 1.302320e-014
Cn4an31a17 TDn4a33 TDn31a33 1.690880e-014
Cn4an32a1 TDn4a1 TDn32a1 1.690880e-014
Cn4an32a2 TDn4a3 TDn32a3 1.302320e-014
Cn4an32a3 TDn4a5 TDn32a5 1.302320e-014
Cn4an32a4 TDn4a7 TDn32a7 1.302320e-014
Cn4an32a5 TDn4a9 TDn32a9 1.302320e-014
Cn4an32a6 TDn4a11 TDn32a11 1.302320e-014
Cn4an32a7 TDn4a13 TDn32a13 1.302320e-014
Cn4an32a8 TDn4a15 TDn32a15 1.302320e-014
Cn4an32a9 TDn4a17 TDn32a17 1.302320e-014
Cn4an32a10 TDn4a19 TDn32a19 1.302320e-014
Cn4an32a11 TDn4a21 TDn32a21 1.302320e-014
Cn4an32a12 TDn4a23 TDn32a23 1.302320e-014
Cn4an32a13 TDn4a25 TDn32a25 1.302320e-014
Cn4an32a14 TDn4a27 TDn32a27 1.302320e-014
Cn4an32a15 TDn4a29 TDn32a29 1.302320e-014
Cn4an32a16 TDn4a31 TDn32a31 1.302320e-014
Cn4an32a17 TDn4a33 TDn32a33 1.690880e-014
Cn4anva1 TDn4a1 TDnva1 1.690880e-014
Cn4anva2 TDn4a3 TDnva3 1.690880e-014
Cn4anva3 TDn4a5 TDnva5 1.690880e-014
Cn4anva4 TDn4a7 TDnva7 1.690880e-014
Cn4anva5 TDn4a9 TDnva9 1.690880e-014
Cn4anva6 TDn4a11 TDnva11 1.690880e-014
Cn4anva7 TDn4a13 TDnva13 1.690880e-014
Cn4anva8 TDn4a15 TDnva15 1.690880e-014
Cn4anva9 TDn4a17 TDnva17 1.690880e-014
Cn4anva10 TDn4a19 TDnva19 1.690880e-014
Cn4anva11 TDn4a21 TDnva21 1.690880e-014
Cn4anva12 TDn4a23 TDnva23 1.690880e-014
Cn4anva13 TDn4a25 TDnva25 1.690880e-014
Cn4anva14 TDn4a27 TDnva27 1.690880e-014
Cn4anva15 TDn4a29 TDnva29 1.690880e-014
Cn4anva16 TDn4a31 TDnva31 1.690880e-014
Cn4anva17 TDn4a33 TDnva33 1.690880e-014
Cn5an6a1 TDn5a1 TDn6a1 1.575710e-014
Cn5an6a2 TDn5a3 TDn6a3 3.151420e-014
Cn5an6a3 TDn5a5 TDn6a5 3.151420e-014
Cn5an6a4 TDn5a7 TDn6a7 3.151420e-014
Cn5an6a5 TDn5a9 TDn6a9 3.151420e-014
Cn5an6a6 TDn5a11 TDn6a11 3.151420e-014
Cn5an6a7 TDn5a13 TDn6a13 3.151420e-014
Cn5an6a8 TDn5a15 TDn6a15 3.151420e-014
Cn5an6a9 TDn5a17 TDn6a17 3.151420e-014
Cn5an6a10 TDn5a19 TDn6a19 3.151420e-014
Cn5an6a11 TDn5a21 TDn6a21 3.151420e-014
Cn5an6a12 TDn5a23 TDn6a23 3.151420e-014
Cn5an6a13 TDn5a25 TDn6a25 3.151420e-014
Cn5an6a14 TDn5a27 TDn6a27 3.151420e-014
Cn5an6a15 TDn5a29 TDn6a29 3.151420e-014
Cn5an6a16 TDn5a31 TDn6a31 3.151420e-014
Cn5an6a17 TDn5a33 TDn6a33 1.575710e-014
Cn5an7a1 TDn5a1 TDn7a1 5.608560e-015
Cn5an7a2 TDn5a3 TDn7a3 1.121710e-014
Cn5an7a3 TDn5a5 TDn7a5 1.121710e-014
Cn5an7a4 TDn5a7 TDn7a7 1.121710e-014
Cn5an7a5 TDn5a9 TDn7a9 1.121710e-014
Cn5an7a6 TDn5a11 TDn7a11 1.121710e-014
Cn5an7a7 TDn5a13 TDn7a13 1.121710e-014
Cn5an7a8 TDn5a15 TDn7a15 1.121710e-014
Cn5an7a9 TDn5a17 TDn7a17 1.121710e-014
Cn5an7a10 TDn5a19 TDn7a19 1.121710e-014
Cn5an7a11 TDn5a21 TDn7a21 1.121710e-014
Cn5an7a12 TDn5a23 TDn7a23 1.121710e-014
Cn5an7a13 TDn5a25 TDn7a25 1.121710e-014
Cn5an7a14 TDn5a27 TDn7a27 1.121710e-014
Cn5an7a15 TDn5a29 TDn7a29 1.121710e-014
Cn5an7a16 TDn5a31 TDn7a31 1.121710e-014
Cn5an7a17 TDn5a33 TDn7a33 5.608560e-015
Cn5an8a1 TDn5a1 TDn8a1 5.204690e-015
Cn5an8a2 TDn5a3 TDn8a3 1.040940e-014
Cn5an8a3 TDn5a5 TDn8a5 1.040940e-014
Cn5an8a4 TDn5a7 TDn8a7 1.040940e-014
Cn5an8a5 TDn5a9 TDn8a9 1.040940e-014
Cn5an8a6 TDn5a11 TDn8a11 1.040940e-014
Cn5an8a7 TDn5a13 TDn8a13 1.040940e-014
Cn5an8a8 TDn5a15 TDn8a15 1.040940e-014
Cn5an8a9 TDn5a17 TDn8a17 1.040940e-014
Cn5an8a10 TDn5a19 TDn8a19 1.040940e-014
Cn5an8a11 TDn5a21 TDn8a21 1.040940e-014
Cn5an8a12 TDn5a23 TDn8a23 1.040940e-014
Cn5an8a13 TDn5a25 TDn8a25 1.040940e-014
Cn5an8a14 TDn5a27 TDn8a27 1.040940e-014
Cn5an8a15 TDn5a29 TDn8a29 1.040940e-014
Cn5an8a16 TDn5a31 TDn8a31 1.040940e-014
Cn5an8a17 TDn5a33 TDn8a33 5.204690e-015
Cn5an9a1 TDn5a1 TDn9a1 5.818520e-015
Cn5an9a2 TDn5a3 TDn9a3 1.163700e-014
Cn5an9a3 TDn5a5 TDn9a5 1.163700e-014
Cn5an9a4 TDn5a7 TDn9a7 1.163700e-014
Cn5an9a5 TDn5a9 TDn9a9 1.163700e-014
Cn5an9a6 TDn5a11 TDn9a11 1.163700e-014
Cn5an9a7 TDn5a13 TDn9a13 1.163700e-014
Cn5an9a8 TDn5a15 TDn9a15 1.163700e-014
Cn5an9a9 TDn5a17 TDn9a17 1.163700e-014
Cn5an9a10 TDn5a19 TDn9a19 1.163700e-014
Cn5an9a11 TDn5a21 TDn9a21 1.163700e-014
Cn5an9a12 TDn5a23 TDn9a23 1.163700e-014
Cn5an9a13 TDn5a25 TDn9a25 1.163700e-014
Cn5an9a14 TDn5a27 TDn9a27 1.163700e-014
Cn5an9a15 TDn5a29 TDn9a29 1.163700e-014
Cn5an9a16 TDn5a31 TDn9a31 1.163700e-014
Cn5an9a17 TDn5a33 TDn9a33 5.818520e-015
Cn5an10a1 TDn5a1 TDn10a1 1.690880e-014
Cn5an10a2 TDn5a3 TDn10a3 1.302320e-014
Cn5an10a3 TDn5a5 TDn10a5 1.302320e-014
Cn5an10a4 TDn5a7 TDn10a7 1.302320e-014
Cn5an10a5 TDn5a9 TDn10a9 1.302320e-014
Cn5an10a6 TDn5a11 TDn10a11 1.302320e-014
Cn5an10a7 TDn5a13 TDn10a13 1.302320e-014
Cn5an10a8 TDn5a15 TDn10a15 1.302320e-014
Cn5an10a9 TDn5a17 TDn10a17 1.302320e-014
Cn5an10a10 TDn5a19 TDn10a19 1.302320e-014
Cn5an10a11 TDn5a21 TDn10a21 1.302320e-014
Cn5an10a12 TDn5a23 TDn10a23 1.302320e-014
Cn5an10a13 TDn5a25 TDn10a25 1.302320e-014
Cn5an10a14 TDn5a27 TDn10a27 1.302320e-014
Cn5an10a15 TDn5a29 TDn10a29 1.302320e-014
Cn5an10a16 TDn5a31 TDn10a31 1.302320e-014
Cn5an10a17 TDn5a33 TDn10a33 1.690880e-014
Cn5an11a1 TDn5a1 TDn11a1 1.690880e-014
Cn5an11a2 TDn5a3 TDn11a3 1.302320e-014
Cn5an11a3 TDn5a5 TDn11a5 1.302320e-014
Cn5an11a4 TDn5a7 TDn11a7 1.302320e-014
Cn5an11a5 TDn5a9 TDn11a9 1.302320e-014
Cn5an11a6 TDn5a11 TDn11a11 1.302320e-014
Cn5an11a7 TDn5a13 TDn11a13 1.302320e-014
Cn5an11a8 TDn5a15 TDn11a15 1.302320e-014
Cn5an11a9 TDn5a17 TDn11a17 1.302320e-014
Cn5an11a10 TDn5a19 TDn11a19 1.302320e-014
Cn5an11a11 TDn5a21 TDn11a21 1.302320e-014
Cn5an11a12 TDn5a23 TDn11a23 1.302320e-014
Cn5an11a13 TDn5a25 TDn11a25 1.302320e-014
Cn5an11a14 TDn5a27 TDn11a27 1.302320e-014
Cn5an11a15 TDn5a29 TDn11a29 1.302320e-014
Cn5an11a16 TDn5a31 TDn11a31 1.302320e-014
Cn5an11a17 TDn5a33 TDn11a33 1.690880e-014
Cn5an12a1 TDn5a1 TDn12a1 1.690880e-014
Cn5an12a2 TDn5a3 TDn12a3 1.302320e-014
Cn5an12a3 TDn5a5 TDn12a5 1.302320e-014
Cn5an12a4 TDn5a7 TDn12a7 1.302320e-014
Cn5an12a5 TDn5a9 TDn12a9 1.302320e-014
Cn5an12a6 TDn5a11 TDn12a11 1.302320e-014
Cn5an12a7 TDn5a13 TDn12a13 1.302320e-014
Cn5an12a8 TDn5a15 TDn12a15 1.302320e-014
Cn5an12a9 TDn5a17 TDn12a17 1.302320e-014
Cn5an12a10 TDn5a19 TDn12a19 1.302320e-014
Cn5an12a11 TDn5a21 TDn12a21 1.302320e-014
Cn5an12a12 TDn5a23 TDn12a23 1.302320e-014
Cn5an12a13 TDn5a25 TDn12a25 1.302320e-014
Cn5an12a14 TDn5a27 TDn12a27 1.302320e-014
Cn5an12a15 TDn5a29 TDn12a29 1.302320e-014
Cn5an12a16 TDn5a31 TDn12a31 1.302320e-014
Cn5an12a17 TDn5a33 TDn12a33 1.690880e-014
Cn5an13a1 TDn5a1 TDn13a1 1.690880e-014
Cn5an13a2 TDn5a3 TDn13a3 1.302320e-014
Cn5an13a3 TDn5a5 TDn13a5 1.302320e-014
Cn5an13a4 TDn5a7 TDn13a7 1.302320e-014
Cn5an13a5 TDn5a9 TDn13a9 1.302320e-014
Cn5an13a6 TDn5a11 TDn13a11 1.302320e-014
Cn5an13a7 TDn5a13 TDn13a13 1.302320e-014
Cn5an13a8 TDn5a15 TDn13a15 1.302320e-014
Cn5an13a9 TDn5a17 TDn13a17 1.302320e-014
Cn5an13a10 TDn5a19 TDn13a19 1.302320e-014
Cn5an13a11 TDn5a21 TDn13a21 1.302320e-014
Cn5an13a12 TDn5a23 TDn13a23 1.302320e-014
Cn5an13a13 TDn5a25 TDn13a25 1.302320e-014
Cn5an13a14 TDn5a27 TDn13a27 1.302320e-014
Cn5an13a15 TDn5a29 TDn13a29 1.302320e-014
Cn5an13a16 TDn5a31 TDn13a31 1.302320e-014
Cn5an13a17 TDn5a33 TDn13a33 1.690880e-014
Cn5an14a1 TDn5a1 TDn14a1 1.690880e-014
Cn5an14a2 TDn5a3 TDn14a3 1.302320e-014
Cn5an14a3 TDn5a5 TDn14a5 1.302320e-014
Cn5an14a4 TDn5a7 TDn14a7 1.302320e-014
Cn5an14a5 TDn5a9 TDn14a9 1.302320e-014
Cn5an14a6 TDn5a11 TDn14a11 1.302320e-014
Cn5an14a7 TDn5a13 TDn14a13 1.302320e-014
Cn5an14a8 TDn5a15 TDn14a15 1.302320e-014
Cn5an14a9 TDn5a17 TDn14a17 1.302320e-014
Cn5an14a10 TDn5a19 TDn14a19 1.302320e-014
Cn5an14a11 TDn5a21 TDn14a21 1.302320e-014
Cn5an14a12 TDn5a23 TDn14a23 1.302320e-014
Cn5an14a13 TDn5a25 TDn14a25 1.302320e-014
Cn5an14a14 TDn5a27 TDn14a27 1.302320e-014
Cn5an14a15 TDn5a29 TDn14a29 1.302320e-014
Cn5an14a16 TDn5a31 TDn14a31 1.302320e-014
Cn5an14a17 TDn5a33 TDn14a33 1.690880e-014
Cn5an15a1 TDn5a1 TDn15a1 1.690880e-014
Cn5an15a2 TDn5a3 TDn15a3 1.302320e-014
Cn5an15a3 TDn5a5 TDn15a5 1.302320e-014
Cn5an15a4 TDn5a7 TDn15a7 1.302320e-014
Cn5an15a5 TDn5a9 TDn15a9 1.302320e-014
Cn5an15a6 TDn5a11 TDn15a11 1.302320e-014
Cn5an15a7 TDn5a13 TDn15a13 1.302320e-014
Cn5an15a8 TDn5a15 TDn15a15 1.302320e-014
Cn5an15a9 TDn5a17 TDn15a17 1.302320e-014
Cn5an15a10 TDn5a19 TDn15a19 1.302320e-014
Cn5an15a11 TDn5a21 TDn15a21 1.302320e-014
Cn5an15a12 TDn5a23 TDn15a23 1.302320e-014
Cn5an15a13 TDn5a25 TDn15a25 1.302320e-014
Cn5an15a14 TDn5a27 TDn15a27 1.302320e-014
Cn5an15a15 TDn5a29 TDn15a29 1.302320e-014
Cn5an15a16 TDn5a31 TDn15a31 1.302320e-014
Cn5an15a17 TDn5a33 TDn15a33 1.690880e-014
Cn5an16a1 TDn5a1 TDn16a1 1.690880e-014
Cn5an16a2 TDn5a3 TDn16a3 1.302320e-014
Cn5an16a3 TDn5a5 TDn16a5 1.302320e-014
Cn5an16a4 TDn5a7 TDn16a7 1.302320e-014
Cn5an16a5 TDn5a9 TDn16a9 1.302320e-014
Cn5an16a6 TDn5a11 TDn16a11 1.302320e-014
Cn5an16a7 TDn5a13 TDn16a13 1.302320e-014
Cn5an16a8 TDn5a15 TDn16a15 1.302320e-014
Cn5an16a9 TDn5a17 TDn16a17 1.302320e-014
Cn5an16a10 TDn5a19 TDn16a19 1.302320e-014
Cn5an16a11 TDn5a21 TDn16a21 1.302320e-014
Cn5an16a12 TDn5a23 TDn16a23 1.302320e-014
Cn5an16a13 TDn5a25 TDn16a25 1.302320e-014
Cn5an16a14 TDn5a27 TDn16a27 1.302320e-014
Cn5an16a15 TDn5a29 TDn16a29 1.302320e-014
Cn5an16a16 TDn5a31 TDn16a31 1.302320e-014
Cn5an16a17 TDn5a33 TDn16a33 1.690880e-014
Cn5an17a1 TDn5a1 TDn17a1 1.690880e-014
Cn5an17a2 TDn5a3 TDn17a3 1.302320e-014
Cn5an17a3 TDn5a5 TDn17a5 1.302320e-014
Cn5an17a4 TDn5a7 TDn17a7 1.302320e-014
Cn5an17a5 TDn5a9 TDn17a9 1.302320e-014
Cn5an17a6 TDn5a11 TDn17a11 1.302320e-014
Cn5an17a7 TDn5a13 TDn17a13 1.302320e-014
Cn5an17a8 TDn5a15 TDn17a15 1.302320e-014
Cn5an17a9 TDn5a17 TDn17a17 1.302320e-014
Cn5an17a10 TDn5a19 TDn17a19 1.302320e-014
Cn5an17a11 TDn5a21 TDn17a21 1.302320e-014
Cn5an17a12 TDn5a23 TDn17a23 1.302320e-014
Cn5an17a13 TDn5a25 TDn17a25 1.302320e-014
Cn5an17a14 TDn5a27 TDn17a27 1.302320e-014
Cn5an17a15 TDn5a29 TDn17a29 1.302320e-014
Cn5an17a16 TDn5a31 TDn17a31 1.302320e-014
Cn5an17a17 TDn5a33 TDn17a33 1.690880e-014
Cn5an18a1 TDn5a1 TDn18a1 1.690880e-014
Cn5an18a2 TDn5a3 TDn18a3 1.302320e-014
Cn5an18a3 TDn5a5 TDn18a5 1.302320e-014
Cn5an18a4 TDn5a7 TDn18a7 1.302320e-014
Cn5an18a5 TDn5a9 TDn18a9 1.302320e-014
Cn5an18a6 TDn5a11 TDn18a11 1.302320e-014
Cn5an18a7 TDn5a13 TDn18a13 1.302320e-014
Cn5an18a8 TDn5a15 TDn18a15 1.302320e-014
Cn5an18a9 TDn5a17 TDn18a17 1.302320e-014
Cn5an18a10 TDn5a19 TDn18a19 1.302320e-014
Cn5an18a11 TDn5a21 TDn18a21 1.302320e-014
Cn5an18a12 TDn5a23 TDn18a23 1.302320e-014
Cn5an18a13 TDn5a25 TDn18a25 1.302320e-014
Cn5an18a14 TDn5a27 TDn18a27 1.302320e-014
Cn5an18a15 TDn5a29 TDn18a29 1.302320e-014
Cn5an18a16 TDn5a31 TDn18a31 1.302320e-014
Cn5an18a17 TDn5a33 TDn18a33 1.690880e-014
Cn5an19a1 TDn5a1 TDn19a1 1.690880e-014
Cn5an19a2 TDn5a3 TDn19a3 1.302320e-014
Cn5an19a3 TDn5a5 TDn19a5 1.302320e-014
Cn5an19a4 TDn5a7 TDn19a7 1.302320e-014
Cn5an19a5 TDn5a9 TDn19a9 1.302320e-014
Cn5an19a6 TDn5a11 TDn19a11 1.302320e-014
Cn5an19a7 TDn5a13 TDn19a13 1.302320e-014
Cn5an19a8 TDn5a15 TDn19a15 1.302320e-014
Cn5an19a9 TDn5a17 TDn19a17 1.302320e-014
Cn5an19a10 TDn5a19 TDn19a19 1.302320e-014
Cn5an19a11 TDn5a21 TDn19a21 1.302320e-014
Cn5an19a12 TDn5a23 TDn19a23 1.302320e-014
Cn5an19a13 TDn5a25 TDn19a25 1.302320e-014
Cn5an19a14 TDn5a27 TDn19a27 1.302320e-014
Cn5an19a15 TDn5a29 TDn19a29 1.302320e-014
Cn5an19a16 TDn5a31 TDn19a31 1.302320e-014
Cn5an19a17 TDn5a33 TDn19a33 1.690880e-014
Cn5an20a1 TDn5a1 TDn20a1 1.690880e-014
Cn5an20a2 TDn5a3 TDn20a3 1.302320e-014
Cn5an20a3 TDn5a5 TDn20a5 1.302320e-014
Cn5an20a4 TDn5a7 TDn20a7 1.302320e-014
Cn5an20a5 TDn5a9 TDn20a9 1.302320e-014
Cn5an20a6 TDn5a11 TDn20a11 1.302320e-014
Cn5an20a7 TDn5a13 TDn20a13 1.302320e-014
Cn5an20a8 TDn5a15 TDn20a15 1.302320e-014
Cn5an20a9 TDn5a17 TDn20a17 1.302320e-014
Cn5an20a10 TDn5a19 TDn20a19 1.302320e-014
Cn5an20a11 TDn5a21 TDn20a21 1.302320e-014
Cn5an20a12 TDn5a23 TDn20a23 1.302320e-014
Cn5an20a13 TDn5a25 TDn20a25 1.302320e-014
Cn5an20a14 TDn5a27 TDn20a27 1.302320e-014
Cn5an20a15 TDn5a29 TDn20a29 1.302320e-014
Cn5an20a16 TDn5a31 TDn20a31 1.302320e-014
Cn5an20a17 TDn5a33 TDn20a33 1.690880e-014
Cn5an21a1 TDn5a1 TDn21a1 1.690880e-014
Cn5an21a2 TDn5a3 TDn21a3 1.302320e-014
Cn5an21a3 TDn5a5 TDn21a5 1.302320e-014
Cn5an21a4 TDn5a7 TDn21a7 1.302320e-014
Cn5an21a5 TDn5a9 TDn21a9 1.302320e-014
Cn5an21a6 TDn5a11 TDn21a11 1.302320e-014
Cn5an21a7 TDn5a13 TDn21a13 1.302320e-014
Cn5an21a8 TDn5a15 TDn21a15 1.302320e-014
Cn5an21a9 TDn5a17 TDn21a17 1.302320e-014
Cn5an21a10 TDn5a19 TDn21a19 1.302320e-014
Cn5an21a11 TDn5a21 TDn21a21 1.302320e-014
Cn5an21a12 TDn5a23 TDn21a23 1.302320e-014
Cn5an21a13 TDn5a25 TDn21a25 1.302320e-014
Cn5an21a14 TDn5a27 TDn21a27 1.302320e-014
Cn5an21a15 TDn5a29 TDn21a29 1.302320e-014
Cn5an21a16 TDn5a31 TDn21a31 1.302320e-014
Cn5an21a17 TDn5a33 TDn21a33 1.690880e-014
Cn5an22a1 TDn5a1 TDn22a1 1.690880e-014
Cn5an22a2 TDn5a3 TDn22a3 1.302320e-014
Cn5an22a3 TDn5a5 TDn22a5 1.302320e-014
Cn5an22a4 TDn5a7 TDn22a7 1.302320e-014
Cn5an22a5 TDn5a9 TDn22a9 1.302320e-014
Cn5an22a6 TDn5a11 TDn22a11 1.302320e-014
Cn5an22a7 TDn5a13 TDn22a13 1.302320e-014
Cn5an22a8 TDn5a15 TDn22a15 1.302320e-014
Cn5an22a9 TDn5a17 TDn22a17 1.302320e-014
Cn5an22a10 TDn5a19 TDn22a19 1.302320e-014
Cn5an22a11 TDn5a21 TDn22a21 1.302320e-014
Cn5an22a12 TDn5a23 TDn22a23 1.302320e-014
Cn5an22a13 TDn5a25 TDn22a25 1.302320e-014
Cn5an22a14 TDn5a27 TDn22a27 1.302320e-014
Cn5an22a15 TDn5a29 TDn22a29 1.302320e-014
Cn5an22a16 TDn5a31 TDn22a31 1.302320e-014
Cn5an22a17 TDn5a33 TDn22a33 1.690880e-014
Cn5an23a1 TDn5a1 TDn23a1 1.690880e-014
Cn5an23a2 TDn5a3 TDn23a3 1.302320e-014
Cn5an23a3 TDn5a5 TDn23a5 1.302320e-014
Cn5an23a4 TDn5a7 TDn23a7 1.302320e-014
Cn5an23a5 TDn5a9 TDn23a9 1.302320e-014
Cn5an23a6 TDn5a11 TDn23a11 1.302320e-014
Cn5an23a7 TDn5a13 TDn23a13 1.302320e-014
Cn5an23a8 TDn5a15 TDn23a15 1.302320e-014
Cn5an23a9 TDn5a17 TDn23a17 1.302320e-014
Cn5an23a10 TDn5a19 TDn23a19 1.302320e-014
Cn5an23a11 TDn5a21 TDn23a21 1.302320e-014
Cn5an23a12 TDn5a23 TDn23a23 1.302320e-014
Cn5an23a13 TDn5a25 TDn23a25 1.302320e-014
Cn5an23a14 TDn5a27 TDn23a27 1.302320e-014
Cn5an23a15 TDn5a29 TDn23a29 1.302320e-014
Cn5an23a16 TDn5a31 TDn23a31 1.302320e-014
Cn5an23a17 TDn5a33 TDn23a33 1.690880e-014
Cn5an24a1 TDn5a1 TDn24a1 1.690880e-014
Cn5an24a2 TDn5a3 TDn24a3 1.302320e-014
Cn5an24a3 TDn5a5 TDn24a5 1.302320e-014
Cn5an24a4 TDn5a7 TDn24a7 1.302320e-014
Cn5an24a5 TDn5a9 TDn24a9 1.302320e-014
Cn5an24a6 TDn5a11 TDn24a11 1.302320e-014
Cn5an24a7 TDn5a13 TDn24a13 1.302320e-014
Cn5an24a8 TDn5a15 TDn24a15 1.302320e-014
Cn5an24a9 TDn5a17 TDn24a17 1.302320e-014
Cn5an24a10 TDn5a19 TDn24a19 1.302320e-014
Cn5an24a11 TDn5a21 TDn24a21 1.302320e-014
Cn5an24a12 TDn5a23 TDn24a23 1.302320e-014
Cn5an24a13 TDn5a25 TDn24a25 1.302320e-014
Cn5an24a14 TDn5a27 TDn24a27 1.302320e-014
Cn5an24a15 TDn5a29 TDn24a29 1.302320e-014
Cn5an24a16 TDn5a31 TDn24a31 1.302320e-014
Cn5an24a17 TDn5a33 TDn24a33 1.690880e-014
Cn5an25a1 TDn5a1 TDn25a1 1.690880e-014
Cn5an25a2 TDn5a3 TDn25a3 1.302320e-014
Cn5an25a3 TDn5a5 TDn25a5 1.302320e-014
Cn5an25a4 TDn5a7 TDn25a7 1.302320e-014
Cn5an25a5 TDn5a9 TDn25a9 1.302320e-014
Cn5an25a6 TDn5a11 TDn25a11 1.302320e-014
Cn5an25a7 TDn5a13 TDn25a13 1.302320e-014
Cn5an25a8 TDn5a15 TDn25a15 1.302320e-014
Cn5an25a9 TDn5a17 TDn25a17 1.302320e-014
Cn5an25a10 TDn5a19 TDn25a19 1.302320e-014
Cn5an25a11 TDn5a21 TDn25a21 1.302320e-014
Cn5an25a12 TDn5a23 TDn25a23 1.302320e-014
Cn5an25a13 TDn5a25 TDn25a25 1.302320e-014
Cn5an25a14 TDn5a27 TDn25a27 1.302320e-014
Cn5an25a15 TDn5a29 TDn25a29 1.302320e-014
Cn5an25a16 TDn5a31 TDn25a31 1.302320e-014
Cn5an25a17 TDn5a33 TDn25a33 1.690880e-014
Cn5an26a1 TDn5a1 TDn26a1 1.690880e-014
Cn5an26a2 TDn5a3 TDn26a3 1.302320e-014
Cn5an26a3 TDn5a5 TDn26a5 1.302320e-014
Cn5an26a4 TDn5a7 TDn26a7 1.302320e-014
Cn5an26a5 TDn5a9 TDn26a9 1.302320e-014
Cn5an26a6 TDn5a11 TDn26a11 1.302320e-014
Cn5an26a7 TDn5a13 TDn26a13 1.302320e-014
Cn5an26a8 TDn5a15 TDn26a15 1.302320e-014
Cn5an26a9 TDn5a17 TDn26a17 1.302320e-014
Cn5an26a10 TDn5a19 TDn26a19 1.302320e-014
Cn5an26a11 TDn5a21 TDn26a21 1.302320e-014
Cn5an26a12 TDn5a23 TDn26a23 1.302320e-014
Cn5an26a13 TDn5a25 TDn26a25 1.302320e-014
Cn5an26a14 TDn5a27 TDn26a27 1.302320e-014
Cn5an26a15 TDn5a29 TDn26a29 1.302320e-014
Cn5an26a16 TDn5a31 TDn26a31 1.302320e-014
Cn5an26a17 TDn5a33 TDn26a33 1.690880e-014
Cn5an27a1 TDn5a1 TDn27a1 1.690880e-014
Cn5an27a2 TDn5a3 TDn27a3 1.302320e-014
Cn5an27a3 TDn5a5 TDn27a5 1.302320e-014
Cn5an27a4 TDn5a7 TDn27a7 1.302320e-014
Cn5an27a5 TDn5a9 TDn27a9 1.302320e-014
Cn5an27a6 TDn5a11 TDn27a11 1.302320e-014
Cn5an27a7 TDn5a13 TDn27a13 1.302320e-014
Cn5an27a8 TDn5a15 TDn27a15 1.302320e-014
Cn5an27a9 TDn5a17 TDn27a17 1.302320e-014
Cn5an27a10 TDn5a19 TDn27a19 1.302320e-014
Cn5an27a11 TDn5a21 TDn27a21 1.302320e-014
Cn5an27a12 TDn5a23 TDn27a23 1.302320e-014
Cn5an27a13 TDn5a25 TDn27a25 1.302320e-014
Cn5an27a14 TDn5a27 TDn27a27 1.302320e-014
Cn5an27a15 TDn5a29 TDn27a29 1.302320e-014
Cn5an27a16 TDn5a31 TDn27a31 1.302320e-014
Cn5an27a17 TDn5a33 TDn27a33 1.690880e-014
Cn5an28a1 TDn5a1 TDn28a1 1.690880e-014
Cn5an28a2 TDn5a3 TDn28a3 1.302320e-014
Cn5an28a3 TDn5a5 TDn28a5 1.302320e-014
Cn5an28a4 TDn5a7 TDn28a7 1.302320e-014
Cn5an28a5 TDn5a9 TDn28a9 1.302320e-014
Cn5an28a6 TDn5a11 TDn28a11 1.302320e-014
Cn5an28a7 TDn5a13 TDn28a13 1.302320e-014
Cn5an28a8 TDn5a15 TDn28a15 1.302320e-014
Cn5an28a9 TDn5a17 TDn28a17 1.302320e-014
Cn5an28a10 TDn5a19 TDn28a19 1.302320e-014
Cn5an28a11 TDn5a21 TDn28a21 1.302320e-014
Cn5an28a12 TDn5a23 TDn28a23 1.302320e-014
Cn5an28a13 TDn5a25 TDn28a25 1.302320e-014
Cn5an28a14 TDn5a27 TDn28a27 1.302320e-014
Cn5an28a15 TDn5a29 TDn28a29 1.302320e-014
Cn5an28a16 TDn5a31 TDn28a31 1.302320e-014
Cn5an28a17 TDn5a33 TDn28a33 1.690880e-014
Cn5an29a1 TDn5a1 TDn29a1 1.690880e-014
Cn5an29a2 TDn5a3 TDn29a3 1.302320e-014
Cn5an29a3 TDn5a5 TDn29a5 1.302320e-014
Cn5an29a4 TDn5a7 TDn29a7 1.302320e-014
Cn5an29a5 TDn5a9 TDn29a9 1.302320e-014
Cn5an29a6 TDn5a11 TDn29a11 1.302320e-014
Cn5an29a7 TDn5a13 TDn29a13 1.302320e-014
Cn5an29a8 TDn5a15 TDn29a15 1.302320e-014
Cn5an29a9 TDn5a17 TDn29a17 1.302320e-014
Cn5an29a10 TDn5a19 TDn29a19 1.302320e-014
Cn5an29a11 TDn5a21 TDn29a21 1.302320e-014
Cn5an29a12 TDn5a23 TDn29a23 1.302320e-014
Cn5an29a13 TDn5a25 TDn29a25 1.302320e-014
Cn5an29a14 TDn5a27 TDn29a27 1.302320e-014
Cn5an29a15 TDn5a29 TDn29a29 1.302320e-014
Cn5an29a16 TDn5a31 TDn29a31 1.302320e-014
Cn5an29a17 TDn5a33 TDn29a33 1.690880e-014
Cn5an30a1 TDn5a1 TDn30a1 1.690880e-014
Cn5an30a2 TDn5a3 TDn30a3 1.302320e-014
Cn5an30a3 TDn5a5 TDn30a5 1.302320e-014
Cn5an30a4 TDn5a7 TDn30a7 1.302320e-014
Cn5an30a5 TDn5a9 TDn30a9 1.302320e-014
Cn5an30a6 TDn5a11 TDn30a11 1.302320e-014
Cn5an30a7 TDn5a13 TDn30a13 1.302320e-014
Cn5an30a8 TDn5a15 TDn30a15 1.302320e-014
Cn5an30a9 TDn5a17 TDn30a17 1.302320e-014
Cn5an30a10 TDn5a19 TDn30a19 1.302320e-014
Cn5an30a11 TDn5a21 TDn30a21 1.302320e-014
Cn5an30a12 TDn5a23 TDn30a23 1.302320e-014
Cn5an30a13 TDn5a25 TDn30a25 1.302320e-014
Cn5an30a14 TDn5a27 TDn30a27 1.302320e-014
Cn5an30a15 TDn5a29 TDn30a29 1.302320e-014
Cn5an30a16 TDn5a31 TDn30a31 1.302320e-014
Cn5an30a17 TDn5a33 TDn30a33 1.690880e-014
Cn5an31a1 TDn5a1 TDn31a1 1.690880e-014
Cn5an31a2 TDn5a3 TDn31a3 1.302320e-014
Cn5an31a3 TDn5a5 TDn31a5 1.302320e-014
Cn5an31a4 TDn5a7 TDn31a7 1.302320e-014
Cn5an31a5 TDn5a9 TDn31a9 1.302320e-014
Cn5an31a6 TDn5a11 TDn31a11 1.302320e-014
Cn5an31a7 TDn5a13 TDn31a13 1.302320e-014
Cn5an31a8 TDn5a15 TDn31a15 1.302320e-014
Cn5an31a9 TDn5a17 TDn31a17 1.302320e-014
Cn5an31a10 TDn5a19 TDn31a19 1.302320e-014
Cn5an31a11 TDn5a21 TDn31a21 1.302320e-014
Cn5an31a12 TDn5a23 TDn31a23 1.302320e-014
Cn5an31a13 TDn5a25 TDn31a25 1.302320e-014
Cn5an31a14 TDn5a27 TDn31a27 1.302320e-014
Cn5an31a15 TDn5a29 TDn31a29 1.302320e-014
Cn5an31a16 TDn5a31 TDn31a31 1.302320e-014
Cn5an31a17 TDn5a33 TDn31a33 1.690880e-014
Cn5an32a1 TDn5a1 TDn32a1 1.690880e-014
Cn5an32a2 TDn5a3 TDn32a3 1.302320e-014
Cn5an32a3 TDn5a5 TDn32a5 1.302320e-014
Cn5an32a4 TDn5a7 TDn32a7 1.302320e-014
Cn5an32a5 TDn5a9 TDn32a9 1.302320e-014
Cn5an32a6 TDn5a11 TDn32a11 1.302320e-014
Cn5an32a7 TDn5a13 TDn32a13 1.302320e-014
Cn5an32a8 TDn5a15 TDn32a15 1.302320e-014
Cn5an32a9 TDn5a17 TDn32a17 1.302320e-014
Cn5an32a10 TDn5a19 TDn32a19 1.302320e-014
Cn5an32a11 TDn5a21 TDn32a21 1.302320e-014
Cn5an32a12 TDn5a23 TDn32a23 1.302320e-014
Cn5an32a13 TDn5a25 TDn32a25 1.302320e-014
Cn5an32a14 TDn5a27 TDn32a27 1.302320e-014
Cn5an32a15 TDn5a29 TDn32a29 1.302320e-014
Cn5an32a16 TDn5a31 TDn32a31 1.302320e-014
Cn5an32a17 TDn5a33 TDn32a33 1.690880e-014
Cn5anva1 TDn5a1 TDnva1 1.690880e-014
Cn5anva2 TDn5a3 TDnva3 1.690880e-014
Cn5anva3 TDn5a5 TDnva5 1.690880e-014
Cn5anva4 TDn5a7 TDnva7 1.690880e-014
Cn5anva5 TDn5a9 TDnva9 1.690880e-014
Cn5anva6 TDn5a11 TDnva11 1.690880e-014
Cn5anva7 TDn5a13 TDnva13 1.690880e-014
Cn5anva8 TDn5a15 TDnva15 1.690880e-014
Cn5anva9 TDn5a17 TDnva17 1.690880e-014
Cn5anva10 TDn5a19 TDnva19 1.690880e-014
Cn5anva11 TDn5a21 TDnva21 1.690880e-014
Cn5anva12 TDn5a23 TDnva23 1.690880e-014
Cn5anva13 TDn5a25 TDnva25 1.690880e-014
Cn5anva14 TDn5a27 TDnva27 1.690880e-014
Cn5anva15 TDn5a29 TDnva29 1.690880e-014
Cn5anva16 TDn5a31 TDnva31 1.690880e-014
Cn5anva17 TDn5a33 TDnva33 1.690880e-014
Cn6an7a1 TDn6a1 TDn7a1 1.578870e-014
Cn6an7a2 TDn6a3 TDn7a3 3.157750e-014
Cn6an7a3 TDn6a5 TDn7a5 3.157750e-014
Cn6an7a4 TDn6a7 TDn7a7 3.157750e-014
Cn6an7a5 TDn6a9 TDn7a9 3.157750e-014
Cn6an7a6 TDn6a11 TDn7a11 3.157750e-014
Cn6an7a7 TDn6a13 TDn7a13 3.157750e-014
Cn6an7a8 TDn6a15 TDn7a15 3.157750e-014
Cn6an7a9 TDn6a17 TDn7a17 3.157750e-014
Cn6an7a10 TDn6a19 TDn7a19 3.157750e-014
Cn6an7a11 TDn6a21 TDn7a21 3.157750e-014
Cn6an7a12 TDn6a23 TDn7a23 3.157750e-014
Cn6an7a13 TDn6a25 TDn7a25 3.157750e-014
Cn6an7a14 TDn6a27 TDn7a27 3.157750e-014
Cn6an7a15 TDn6a29 TDn7a29 3.157750e-014
Cn6an7a16 TDn6a31 TDn7a31 3.157750e-014
Cn6an7a17 TDn6a33 TDn7a33 1.578870e-014
Cn6an8a1 TDn6a1 TDn8a1 5.673080e-015
Cn6an8a2 TDn6a3 TDn8a3 1.134620e-014
Cn6an8a3 TDn6a5 TDn8a5 1.134620e-014
Cn6an8a4 TDn6a7 TDn8a7 1.134620e-014
Cn6an8a5 TDn6a9 TDn8a9 1.134620e-014
Cn6an8a6 TDn6a11 TDn8a11 1.134620e-014
Cn6an8a7 TDn6a13 TDn8a13 1.134620e-014
Cn6an8a8 TDn6a15 TDn8a15 1.134620e-014
Cn6an8a9 TDn6a17 TDn8a17 1.134620e-014
Cn6an8a10 TDn6a19 TDn8a19 1.134620e-014
Cn6an8a11 TDn6a21 TDn8a21 1.134620e-014
Cn6an8a12 TDn6a23 TDn8a23 1.134620e-014
Cn6an8a13 TDn6a25 TDn8a25 1.134620e-014
Cn6an8a14 TDn6a27 TDn8a27 1.134620e-014
Cn6an8a15 TDn6a29 TDn8a29 1.134620e-014
Cn6an8a16 TDn6a31 TDn8a31 1.134620e-014
Cn6an8a17 TDn6a33 TDn8a33 5.673080e-015
Cn6an9a1 TDn6a1 TDn9a1 6.001130e-015
Cn6an9a2 TDn6a3 TDn9a3 1.200230e-014
Cn6an9a3 TDn6a5 TDn9a5 1.200230e-014
Cn6an9a4 TDn6a7 TDn9a7 1.200230e-014
Cn6an9a5 TDn6a9 TDn9a9 1.200230e-014
Cn6an9a6 TDn6a11 TDn9a11 1.200230e-014
Cn6an9a7 TDn6a13 TDn9a13 1.200230e-014
Cn6an9a8 TDn6a15 TDn9a15 1.200230e-014
Cn6an9a9 TDn6a17 TDn9a17 1.200230e-014
Cn6an9a10 TDn6a19 TDn9a19 1.200230e-014
Cn6an9a11 TDn6a21 TDn9a21 1.200230e-014
Cn6an9a12 TDn6a23 TDn9a23 1.200230e-014
Cn6an9a13 TDn6a25 TDn9a25 1.200230e-014
Cn6an9a14 TDn6a27 TDn9a27 1.200230e-014
Cn6an9a15 TDn6a29 TDn9a29 1.200230e-014
Cn6an9a16 TDn6a31 TDn9a31 1.200230e-014
Cn6an9a17 TDn6a33 TDn9a33 6.001130e-015
Cn6an10a1 TDn6a1 TDn10a1 1.690880e-014
Cn6an10a2 TDn6a3 TDn10a3 1.302320e-014
Cn6an10a3 TDn6a5 TDn10a5 1.302320e-014
Cn6an10a4 TDn6a7 TDn10a7 1.302320e-014
Cn6an10a5 TDn6a9 TDn10a9 1.302320e-014
Cn6an10a6 TDn6a11 TDn10a11 1.302320e-014
Cn6an10a7 TDn6a13 TDn10a13 1.302320e-014
Cn6an10a8 TDn6a15 TDn10a15 1.302320e-014
Cn6an10a9 TDn6a17 TDn10a17 1.302320e-014
Cn6an10a10 TDn6a19 TDn10a19 1.302320e-014
Cn6an10a11 TDn6a21 TDn10a21 1.302320e-014
Cn6an10a12 TDn6a23 TDn10a23 1.302320e-014
Cn6an10a13 TDn6a25 TDn10a25 1.302320e-014
Cn6an10a14 TDn6a27 TDn10a27 1.302320e-014
Cn6an10a15 TDn6a29 TDn10a29 1.302320e-014
Cn6an10a16 TDn6a31 TDn10a31 1.302320e-014
Cn6an10a17 TDn6a33 TDn10a33 1.690880e-014
Cn6an11a1 TDn6a1 TDn11a1 1.690880e-014
Cn6an11a2 TDn6a3 TDn11a3 1.302320e-014
Cn6an11a3 TDn6a5 TDn11a5 1.302320e-014
Cn6an11a4 TDn6a7 TDn11a7 1.302320e-014
Cn6an11a5 TDn6a9 TDn11a9 1.302320e-014
Cn6an11a6 TDn6a11 TDn11a11 1.302320e-014
Cn6an11a7 TDn6a13 TDn11a13 1.302320e-014
Cn6an11a8 TDn6a15 TDn11a15 1.302320e-014
Cn6an11a9 TDn6a17 TDn11a17 1.302320e-014
Cn6an11a10 TDn6a19 TDn11a19 1.302320e-014
Cn6an11a11 TDn6a21 TDn11a21 1.302320e-014
Cn6an11a12 TDn6a23 TDn11a23 1.302320e-014
Cn6an11a13 TDn6a25 TDn11a25 1.302320e-014
Cn6an11a14 TDn6a27 TDn11a27 1.302320e-014
Cn6an11a15 TDn6a29 TDn11a29 1.302320e-014
Cn6an11a16 TDn6a31 TDn11a31 1.302320e-014
Cn6an11a17 TDn6a33 TDn11a33 1.690880e-014
Cn6an12a1 TDn6a1 TDn12a1 1.690880e-014
Cn6an12a2 TDn6a3 TDn12a3 1.302320e-014
Cn6an12a3 TDn6a5 TDn12a5 1.302320e-014
Cn6an12a4 TDn6a7 TDn12a7 1.302320e-014
Cn6an12a5 TDn6a9 TDn12a9 1.302320e-014
Cn6an12a6 TDn6a11 TDn12a11 1.302320e-014
Cn6an12a7 TDn6a13 TDn12a13 1.302320e-014
Cn6an12a8 TDn6a15 TDn12a15 1.302320e-014
Cn6an12a9 TDn6a17 TDn12a17 1.302320e-014
Cn6an12a10 TDn6a19 TDn12a19 1.302320e-014
Cn6an12a11 TDn6a21 TDn12a21 1.302320e-014
Cn6an12a12 TDn6a23 TDn12a23 1.302320e-014
Cn6an12a13 TDn6a25 TDn12a25 1.302320e-014
Cn6an12a14 TDn6a27 TDn12a27 1.302320e-014
Cn6an12a15 TDn6a29 TDn12a29 1.302320e-014
Cn6an12a16 TDn6a31 TDn12a31 1.302320e-014
Cn6an12a17 TDn6a33 TDn12a33 1.690880e-014
Cn6an13a1 TDn6a1 TDn13a1 1.690880e-014
Cn6an13a2 TDn6a3 TDn13a3 1.302320e-014
Cn6an13a3 TDn6a5 TDn13a5 1.302320e-014
Cn6an13a4 TDn6a7 TDn13a7 1.302320e-014
Cn6an13a5 TDn6a9 TDn13a9 1.302320e-014
Cn6an13a6 TDn6a11 TDn13a11 1.302320e-014
Cn6an13a7 TDn6a13 TDn13a13 1.302320e-014
Cn6an13a8 TDn6a15 TDn13a15 1.302320e-014
Cn6an13a9 TDn6a17 TDn13a17 1.302320e-014
Cn6an13a10 TDn6a19 TDn13a19 1.302320e-014
Cn6an13a11 TDn6a21 TDn13a21 1.302320e-014
Cn6an13a12 TDn6a23 TDn13a23 1.302320e-014
Cn6an13a13 TDn6a25 TDn13a25 1.302320e-014
Cn6an13a14 TDn6a27 TDn13a27 1.302320e-014
Cn6an13a15 TDn6a29 TDn13a29 1.302320e-014
Cn6an13a16 TDn6a31 TDn13a31 1.302320e-014
Cn6an13a17 TDn6a33 TDn13a33 1.690880e-014
Cn6an14a1 TDn6a1 TDn14a1 1.690880e-014
Cn6an14a2 TDn6a3 TDn14a3 1.302320e-014
Cn6an14a3 TDn6a5 TDn14a5 1.302320e-014
Cn6an14a4 TDn6a7 TDn14a7 1.302320e-014
Cn6an14a5 TDn6a9 TDn14a9 1.302320e-014
Cn6an14a6 TDn6a11 TDn14a11 1.302320e-014
Cn6an14a7 TDn6a13 TDn14a13 1.302320e-014
Cn6an14a8 TDn6a15 TDn14a15 1.302320e-014
Cn6an14a9 TDn6a17 TDn14a17 1.302320e-014
Cn6an14a10 TDn6a19 TDn14a19 1.302320e-014
Cn6an14a11 TDn6a21 TDn14a21 1.302320e-014
Cn6an14a12 TDn6a23 TDn14a23 1.302320e-014
Cn6an14a13 TDn6a25 TDn14a25 1.302320e-014
Cn6an14a14 TDn6a27 TDn14a27 1.302320e-014
Cn6an14a15 TDn6a29 TDn14a29 1.302320e-014
Cn6an14a16 TDn6a31 TDn14a31 1.302320e-014
Cn6an14a17 TDn6a33 TDn14a33 1.690880e-014
Cn6an15a1 TDn6a1 TDn15a1 1.690880e-014
Cn6an15a2 TDn6a3 TDn15a3 1.302320e-014
Cn6an15a3 TDn6a5 TDn15a5 1.302320e-014
Cn6an15a4 TDn6a7 TDn15a7 1.302320e-014
Cn6an15a5 TDn6a9 TDn15a9 1.302320e-014
Cn6an15a6 TDn6a11 TDn15a11 1.302320e-014
Cn6an15a7 TDn6a13 TDn15a13 1.302320e-014
Cn6an15a8 TDn6a15 TDn15a15 1.302320e-014
Cn6an15a9 TDn6a17 TDn15a17 1.302320e-014
Cn6an15a10 TDn6a19 TDn15a19 1.302320e-014
Cn6an15a11 TDn6a21 TDn15a21 1.302320e-014
Cn6an15a12 TDn6a23 TDn15a23 1.302320e-014
Cn6an15a13 TDn6a25 TDn15a25 1.302320e-014
Cn6an15a14 TDn6a27 TDn15a27 1.302320e-014
Cn6an15a15 TDn6a29 TDn15a29 1.302320e-014
Cn6an15a16 TDn6a31 TDn15a31 1.302320e-014
Cn6an15a17 TDn6a33 TDn15a33 1.690880e-014
Cn6an16a1 TDn6a1 TDn16a1 1.690880e-014
Cn6an16a2 TDn6a3 TDn16a3 1.302320e-014
Cn6an16a3 TDn6a5 TDn16a5 1.302320e-014
Cn6an16a4 TDn6a7 TDn16a7 1.302320e-014
Cn6an16a5 TDn6a9 TDn16a9 1.302320e-014
Cn6an16a6 TDn6a11 TDn16a11 1.302320e-014
Cn6an16a7 TDn6a13 TDn16a13 1.302320e-014
Cn6an16a8 TDn6a15 TDn16a15 1.302320e-014
Cn6an16a9 TDn6a17 TDn16a17 1.302320e-014
Cn6an16a10 TDn6a19 TDn16a19 1.302320e-014
Cn6an16a11 TDn6a21 TDn16a21 1.302320e-014
Cn6an16a12 TDn6a23 TDn16a23 1.302320e-014
Cn6an16a13 TDn6a25 TDn16a25 1.302320e-014
Cn6an16a14 TDn6a27 TDn16a27 1.302320e-014
Cn6an16a15 TDn6a29 TDn16a29 1.302320e-014
Cn6an16a16 TDn6a31 TDn16a31 1.302320e-014
Cn6an16a17 TDn6a33 TDn16a33 1.690880e-014
Cn6an17a1 TDn6a1 TDn17a1 1.690880e-014
Cn6an17a2 TDn6a3 TDn17a3 1.302320e-014
Cn6an17a3 TDn6a5 TDn17a5 1.302320e-014
Cn6an17a4 TDn6a7 TDn17a7 1.302320e-014
Cn6an17a5 TDn6a9 TDn17a9 1.302320e-014
Cn6an17a6 TDn6a11 TDn17a11 1.302320e-014
Cn6an17a7 TDn6a13 TDn17a13 1.302320e-014
Cn6an17a8 TDn6a15 TDn17a15 1.302320e-014
Cn6an17a9 TDn6a17 TDn17a17 1.302320e-014
Cn6an17a10 TDn6a19 TDn17a19 1.302320e-014
Cn6an17a11 TDn6a21 TDn17a21 1.302320e-014
Cn6an17a12 TDn6a23 TDn17a23 1.302320e-014
Cn6an17a13 TDn6a25 TDn17a25 1.302320e-014
Cn6an17a14 TDn6a27 TDn17a27 1.302320e-014
Cn6an17a15 TDn6a29 TDn17a29 1.302320e-014
Cn6an17a16 TDn6a31 TDn17a31 1.302320e-014
Cn6an17a17 TDn6a33 TDn17a33 1.690880e-014
Cn6an18a1 TDn6a1 TDn18a1 1.690880e-014
Cn6an18a2 TDn6a3 TDn18a3 1.302320e-014
Cn6an18a3 TDn6a5 TDn18a5 1.302320e-014
Cn6an18a4 TDn6a7 TDn18a7 1.302320e-014
Cn6an18a5 TDn6a9 TDn18a9 1.302320e-014
Cn6an18a6 TDn6a11 TDn18a11 1.302320e-014
Cn6an18a7 TDn6a13 TDn18a13 1.302320e-014
Cn6an18a8 TDn6a15 TDn18a15 1.302320e-014
Cn6an18a9 TDn6a17 TDn18a17 1.302320e-014
Cn6an18a10 TDn6a19 TDn18a19 1.302320e-014
Cn6an18a11 TDn6a21 TDn18a21 1.302320e-014
Cn6an18a12 TDn6a23 TDn18a23 1.302320e-014
Cn6an18a13 TDn6a25 TDn18a25 1.302320e-014
Cn6an18a14 TDn6a27 TDn18a27 1.302320e-014
Cn6an18a15 TDn6a29 TDn18a29 1.302320e-014
Cn6an18a16 TDn6a31 TDn18a31 1.302320e-014
Cn6an18a17 TDn6a33 TDn18a33 1.690880e-014
Cn6an19a1 TDn6a1 TDn19a1 1.690880e-014
Cn6an19a2 TDn6a3 TDn19a3 1.302320e-014
Cn6an19a3 TDn6a5 TDn19a5 1.302320e-014
Cn6an19a4 TDn6a7 TDn19a7 1.302320e-014
Cn6an19a5 TDn6a9 TDn19a9 1.302320e-014
Cn6an19a6 TDn6a11 TDn19a11 1.302320e-014
Cn6an19a7 TDn6a13 TDn19a13 1.302320e-014
Cn6an19a8 TDn6a15 TDn19a15 1.302320e-014
Cn6an19a9 TDn6a17 TDn19a17 1.302320e-014
Cn6an19a10 TDn6a19 TDn19a19 1.302320e-014
Cn6an19a11 TDn6a21 TDn19a21 1.302320e-014
Cn6an19a12 TDn6a23 TDn19a23 1.302320e-014
Cn6an19a13 TDn6a25 TDn19a25 1.302320e-014
Cn6an19a14 TDn6a27 TDn19a27 1.302320e-014
Cn6an19a15 TDn6a29 TDn19a29 1.302320e-014
Cn6an19a16 TDn6a31 TDn19a31 1.302320e-014
Cn6an19a17 TDn6a33 TDn19a33 1.690880e-014
Cn6an20a1 TDn6a1 TDn20a1 1.690880e-014
Cn6an20a2 TDn6a3 TDn20a3 1.302320e-014
Cn6an20a3 TDn6a5 TDn20a5 1.302320e-014
Cn6an20a4 TDn6a7 TDn20a7 1.302320e-014
Cn6an20a5 TDn6a9 TDn20a9 1.302320e-014
Cn6an20a6 TDn6a11 TDn20a11 1.302320e-014
Cn6an20a7 TDn6a13 TDn20a13 1.302320e-014
Cn6an20a8 TDn6a15 TDn20a15 1.302320e-014
Cn6an20a9 TDn6a17 TDn20a17 1.302320e-014
Cn6an20a10 TDn6a19 TDn20a19 1.302320e-014
Cn6an20a11 TDn6a21 TDn20a21 1.302320e-014
Cn6an20a12 TDn6a23 TDn20a23 1.302320e-014
Cn6an20a13 TDn6a25 TDn20a25 1.302320e-014
Cn6an20a14 TDn6a27 TDn20a27 1.302320e-014
Cn6an20a15 TDn6a29 TDn20a29 1.302320e-014
Cn6an20a16 TDn6a31 TDn20a31 1.302320e-014
Cn6an20a17 TDn6a33 TDn20a33 1.690880e-014
Cn6an21a1 TDn6a1 TDn21a1 1.690880e-014
Cn6an21a2 TDn6a3 TDn21a3 1.302320e-014
Cn6an21a3 TDn6a5 TDn21a5 1.302320e-014
Cn6an21a4 TDn6a7 TDn21a7 1.302320e-014
Cn6an21a5 TDn6a9 TDn21a9 1.302320e-014
Cn6an21a6 TDn6a11 TDn21a11 1.302320e-014
Cn6an21a7 TDn6a13 TDn21a13 1.302320e-014
Cn6an21a8 TDn6a15 TDn21a15 1.302320e-014
Cn6an21a9 TDn6a17 TDn21a17 1.302320e-014
Cn6an21a10 TDn6a19 TDn21a19 1.302320e-014
Cn6an21a11 TDn6a21 TDn21a21 1.302320e-014
Cn6an21a12 TDn6a23 TDn21a23 1.302320e-014
Cn6an21a13 TDn6a25 TDn21a25 1.302320e-014
Cn6an21a14 TDn6a27 TDn21a27 1.302320e-014
Cn6an21a15 TDn6a29 TDn21a29 1.302320e-014
Cn6an21a16 TDn6a31 TDn21a31 1.302320e-014
Cn6an21a17 TDn6a33 TDn21a33 1.690880e-014
Cn6an22a1 TDn6a1 TDn22a1 1.690880e-014
Cn6an22a2 TDn6a3 TDn22a3 1.302320e-014
Cn6an22a3 TDn6a5 TDn22a5 1.302320e-014
Cn6an22a4 TDn6a7 TDn22a7 1.302320e-014
Cn6an22a5 TDn6a9 TDn22a9 1.302320e-014
Cn6an22a6 TDn6a11 TDn22a11 1.302320e-014
Cn6an22a7 TDn6a13 TDn22a13 1.302320e-014
Cn6an22a8 TDn6a15 TDn22a15 1.302320e-014
Cn6an22a9 TDn6a17 TDn22a17 1.302320e-014
Cn6an22a10 TDn6a19 TDn22a19 1.302320e-014
Cn6an22a11 TDn6a21 TDn22a21 1.302320e-014
Cn6an22a12 TDn6a23 TDn22a23 1.302320e-014
Cn6an22a13 TDn6a25 TDn22a25 1.302320e-014
Cn6an22a14 TDn6a27 TDn22a27 1.302320e-014
Cn6an22a15 TDn6a29 TDn22a29 1.302320e-014
Cn6an22a16 TDn6a31 TDn22a31 1.302320e-014
Cn6an22a17 TDn6a33 TDn22a33 1.690880e-014
Cn6an23a1 TDn6a1 TDn23a1 1.690880e-014
Cn6an23a2 TDn6a3 TDn23a3 1.302320e-014
Cn6an23a3 TDn6a5 TDn23a5 1.302320e-014
Cn6an23a4 TDn6a7 TDn23a7 1.302320e-014
Cn6an23a5 TDn6a9 TDn23a9 1.302320e-014
Cn6an23a6 TDn6a11 TDn23a11 1.302320e-014
Cn6an23a7 TDn6a13 TDn23a13 1.302320e-014
Cn6an23a8 TDn6a15 TDn23a15 1.302320e-014
Cn6an23a9 TDn6a17 TDn23a17 1.302320e-014
Cn6an23a10 TDn6a19 TDn23a19 1.302320e-014
Cn6an23a11 TDn6a21 TDn23a21 1.302320e-014
Cn6an23a12 TDn6a23 TDn23a23 1.302320e-014
Cn6an23a13 TDn6a25 TDn23a25 1.302320e-014
Cn6an23a14 TDn6a27 TDn23a27 1.302320e-014
Cn6an23a15 TDn6a29 TDn23a29 1.302320e-014
Cn6an23a16 TDn6a31 TDn23a31 1.302320e-014
Cn6an23a17 TDn6a33 TDn23a33 1.690880e-014
Cn6an24a1 TDn6a1 TDn24a1 1.690880e-014
Cn6an24a2 TDn6a3 TDn24a3 1.302320e-014
Cn6an24a3 TDn6a5 TDn24a5 1.302320e-014
Cn6an24a4 TDn6a7 TDn24a7 1.302320e-014
Cn6an24a5 TDn6a9 TDn24a9 1.302320e-014
Cn6an24a6 TDn6a11 TDn24a11 1.302320e-014
Cn6an24a7 TDn6a13 TDn24a13 1.302320e-014
Cn6an24a8 TDn6a15 TDn24a15 1.302320e-014
Cn6an24a9 TDn6a17 TDn24a17 1.302320e-014
Cn6an24a10 TDn6a19 TDn24a19 1.302320e-014
Cn6an24a11 TDn6a21 TDn24a21 1.302320e-014
Cn6an24a12 TDn6a23 TDn24a23 1.302320e-014
Cn6an24a13 TDn6a25 TDn24a25 1.302320e-014
Cn6an24a14 TDn6a27 TDn24a27 1.302320e-014
Cn6an24a15 TDn6a29 TDn24a29 1.302320e-014
Cn6an24a16 TDn6a31 TDn24a31 1.302320e-014
Cn6an24a17 TDn6a33 TDn24a33 1.690880e-014
Cn6an25a1 TDn6a1 TDn25a1 1.690880e-014
Cn6an25a2 TDn6a3 TDn25a3 1.302320e-014
Cn6an25a3 TDn6a5 TDn25a5 1.302320e-014
Cn6an25a4 TDn6a7 TDn25a7 1.302320e-014
Cn6an25a5 TDn6a9 TDn25a9 1.302320e-014
Cn6an25a6 TDn6a11 TDn25a11 1.302320e-014
Cn6an25a7 TDn6a13 TDn25a13 1.302320e-014
Cn6an25a8 TDn6a15 TDn25a15 1.302320e-014
Cn6an25a9 TDn6a17 TDn25a17 1.302320e-014
Cn6an25a10 TDn6a19 TDn25a19 1.302320e-014
Cn6an25a11 TDn6a21 TDn25a21 1.302320e-014
Cn6an25a12 TDn6a23 TDn25a23 1.302320e-014
Cn6an25a13 TDn6a25 TDn25a25 1.302320e-014
Cn6an25a14 TDn6a27 TDn25a27 1.302320e-014
Cn6an25a15 TDn6a29 TDn25a29 1.302320e-014
Cn6an25a16 TDn6a31 TDn25a31 1.302320e-014
Cn6an25a17 TDn6a33 TDn25a33 1.690880e-014
Cn6an26a1 TDn6a1 TDn26a1 1.690880e-014
Cn6an26a2 TDn6a3 TDn26a3 1.302320e-014
Cn6an26a3 TDn6a5 TDn26a5 1.302320e-014
Cn6an26a4 TDn6a7 TDn26a7 1.302320e-014
Cn6an26a5 TDn6a9 TDn26a9 1.302320e-014
Cn6an26a6 TDn6a11 TDn26a11 1.302320e-014
Cn6an26a7 TDn6a13 TDn26a13 1.302320e-014
Cn6an26a8 TDn6a15 TDn26a15 1.302320e-014
Cn6an26a9 TDn6a17 TDn26a17 1.302320e-014
Cn6an26a10 TDn6a19 TDn26a19 1.302320e-014
Cn6an26a11 TDn6a21 TDn26a21 1.302320e-014
Cn6an26a12 TDn6a23 TDn26a23 1.302320e-014
Cn6an26a13 TDn6a25 TDn26a25 1.302320e-014
Cn6an26a14 TDn6a27 TDn26a27 1.302320e-014
Cn6an26a15 TDn6a29 TDn26a29 1.302320e-014
Cn6an26a16 TDn6a31 TDn26a31 1.302320e-014
Cn6an26a17 TDn6a33 TDn26a33 1.690880e-014
Cn6an27a1 TDn6a1 TDn27a1 1.690880e-014
Cn6an27a2 TDn6a3 TDn27a3 1.302320e-014
Cn6an27a3 TDn6a5 TDn27a5 1.302320e-014
Cn6an27a4 TDn6a7 TDn27a7 1.302320e-014
Cn6an27a5 TDn6a9 TDn27a9 1.302320e-014
Cn6an27a6 TDn6a11 TDn27a11 1.302320e-014
Cn6an27a7 TDn6a13 TDn27a13 1.302320e-014
Cn6an27a8 TDn6a15 TDn27a15 1.302320e-014
Cn6an27a9 TDn6a17 TDn27a17 1.302320e-014
Cn6an27a10 TDn6a19 TDn27a19 1.302320e-014
Cn6an27a11 TDn6a21 TDn27a21 1.302320e-014
Cn6an27a12 TDn6a23 TDn27a23 1.302320e-014
Cn6an27a13 TDn6a25 TDn27a25 1.302320e-014
Cn6an27a14 TDn6a27 TDn27a27 1.302320e-014
Cn6an27a15 TDn6a29 TDn27a29 1.302320e-014
Cn6an27a16 TDn6a31 TDn27a31 1.302320e-014
Cn6an27a17 TDn6a33 TDn27a33 1.690880e-014
Cn6an28a1 TDn6a1 TDn28a1 1.690880e-014
Cn6an28a2 TDn6a3 TDn28a3 1.302320e-014
Cn6an28a3 TDn6a5 TDn28a5 1.302320e-014
Cn6an28a4 TDn6a7 TDn28a7 1.302320e-014
Cn6an28a5 TDn6a9 TDn28a9 1.302320e-014
Cn6an28a6 TDn6a11 TDn28a11 1.302320e-014
Cn6an28a7 TDn6a13 TDn28a13 1.302320e-014
Cn6an28a8 TDn6a15 TDn28a15 1.302320e-014
Cn6an28a9 TDn6a17 TDn28a17 1.302320e-014
Cn6an28a10 TDn6a19 TDn28a19 1.302320e-014
Cn6an28a11 TDn6a21 TDn28a21 1.302320e-014
Cn6an28a12 TDn6a23 TDn28a23 1.302320e-014
Cn6an28a13 TDn6a25 TDn28a25 1.302320e-014
Cn6an28a14 TDn6a27 TDn28a27 1.302320e-014
Cn6an28a15 TDn6a29 TDn28a29 1.302320e-014
Cn6an28a16 TDn6a31 TDn28a31 1.302320e-014
Cn6an28a17 TDn6a33 TDn28a33 1.690880e-014
Cn6an29a1 TDn6a1 TDn29a1 1.690880e-014
Cn6an29a2 TDn6a3 TDn29a3 1.302320e-014
Cn6an29a3 TDn6a5 TDn29a5 1.302320e-014
Cn6an29a4 TDn6a7 TDn29a7 1.302320e-014
Cn6an29a5 TDn6a9 TDn29a9 1.302320e-014
Cn6an29a6 TDn6a11 TDn29a11 1.302320e-014
Cn6an29a7 TDn6a13 TDn29a13 1.302320e-014
Cn6an29a8 TDn6a15 TDn29a15 1.302320e-014
Cn6an29a9 TDn6a17 TDn29a17 1.302320e-014
Cn6an29a10 TDn6a19 TDn29a19 1.302320e-014
Cn6an29a11 TDn6a21 TDn29a21 1.302320e-014
Cn6an29a12 TDn6a23 TDn29a23 1.302320e-014
Cn6an29a13 TDn6a25 TDn29a25 1.302320e-014
Cn6an29a14 TDn6a27 TDn29a27 1.302320e-014
Cn6an29a15 TDn6a29 TDn29a29 1.302320e-014
Cn6an29a16 TDn6a31 TDn29a31 1.302320e-014
Cn6an29a17 TDn6a33 TDn29a33 1.690880e-014
Cn6an30a1 TDn6a1 TDn30a1 1.690880e-014
Cn6an30a2 TDn6a3 TDn30a3 1.302320e-014
Cn6an30a3 TDn6a5 TDn30a5 1.302320e-014
Cn6an30a4 TDn6a7 TDn30a7 1.302320e-014
Cn6an30a5 TDn6a9 TDn30a9 1.302320e-014
Cn6an30a6 TDn6a11 TDn30a11 1.302320e-014
Cn6an30a7 TDn6a13 TDn30a13 1.302320e-014
Cn6an30a8 TDn6a15 TDn30a15 1.302320e-014
Cn6an30a9 TDn6a17 TDn30a17 1.302320e-014
Cn6an30a10 TDn6a19 TDn30a19 1.302320e-014
Cn6an30a11 TDn6a21 TDn30a21 1.302320e-014
Cn6an30a12 TDn6a23 TDn30a23 1.302320e-014
Cn6an30a13 TDn6a25 TDn30a25 1.302320e-014
Cn6an30a14 TDn6a27 TDn30a27 1.302320e-014
Cn6an30a15 TDn6a29 TDn30a29 1.302320e-014
Cn6an30a16 TDn6a31 TDn30a31 1.302320e-014
Cn6an30a17 TDn6a33 TDn30a33 1.690880e-014
Cn6an31a1 TDn6a1 TDn31a1 1.690880e-014
Cn6an31a2 TDn6a3 TDn31a3 1.302320e-014
Cn6an31a3 TDn6a5 TDn31a5 1.302320e-014
Cn6an31a4 TDn6a7 TDn31a7 1.302320e-014
Cn6an31a5 TDn6a9 TDn31a9 1.302320e-014
Cn6an31a6 TDn6a11 TDn31a11 1.302320e-014
Cn6an31a7 TDn6a13 TDn31a13 1.302320e-014
Cn6an31a8 TDn6a15 TDn31a15 1.302320e-014
Cn6an31a9 TDn6a17 TDn31a17 1.302320e-014
Cn6an31a10 TDn6a19 TDn31a19 1.302320e-014
Cn6an31a11 TDn6a21 TDn31a21 1.302320e-014
Cn6an31a12 TDn6a23 TDn31a23 1.302320e-014
Cn6an31a13 TDn6a25 TDn31a25 1.302320e-014
Cn6an31a14 TDn6a27 TDn31a27 1.302320e-014
Cn6an31a15 TDn6a29 TDn31a29 1.302320e-014
Cn6an31a16 TDn6a31 TDn31a31 1.302320e-014
Cn6an31a17 TDn6a33 TDn31a33 1.690880e-014
Cn6an32a1 TDn6a1 TDn32a1 1.690880e-014
Cn6an32a2 TDn6a3 TDn32a3 1.302320e-014
Cn6an32a3 TDn6a5 TDn32a5 1.302320e-014
Cn6an32a4 TDn6a7 TDn32a7 1.302320e-014
Cn6an32a5 TDn6a9 TDn32a9 1.302320e-014
Cn6an32a6 TDn6a11 TDn32a11 1.302320e-014
Cn6an32a7 TDn6a13 TDn32a13 1.302320e-014
Cn6an32a8 TDn6a15 TDn32a15 1.302320e-014
Cn6an32a9 TDn6a17 TDn32a17 1.302320e-014
Cn6an32a10 TDn6a19 TDn32a19 1.302320e-014
Cn6an32a11 TDn6a21 TDn32a21 1.302320e-014
Cn6an32a12 TDn6a23 TDn32a23 1.302320e-014
Cn6an32a13 TDn6a25 TDn32a25 1.302320e-014
Cn6an32a14 TDn6a27 TDn32a27 1.302320e-014
Cn6an32a15 TDn6a29 TDn32a29 1.302320e-014
Cn6an32a16 TDn6a31 TDn32a31 1.302320e-014
Cn6an32a17 TDn6a33 TDn32a33 1.690880e-014
Cn6anva1 TDn6a1 TDnva1 1.690880e-014
Cn6anva2 TDn6a3 TDnva3 1.690880e-014
Cn6anva3 TDn6a5 TDnva5 1.690880e-014
Cn6anva4 TDn6a7 TDnva7 1.690880e-014
Cn6anva5 TDn6a9 TDnva9 1.690880e-014
Cn6anva6 TDn6a11 TDnva11 1.690880e-014
Cn6anva7 TDn6a13 TDnva13 1.690880e-014
Cn6anva8 TDn6a15 TDnva15 1.690880e-014
Cn6anva9 TDn6a17 TDnva17 1.690880e-014
Cn6anva10 TDn6a19 TDnva19 1.690880e-014
Cn6anva11 TDn6a21 TDnva21 1.690880e-014
Cn6anva12 TDn6a23 TDnva23 1.690880e-014
Cn6anva13 TDn6a25 TDnva25 1.690880e-014
Cn6anva14 TDn6a27 TDnva27 1.690880e-014
Cn6anva15 TDn6a29 TDnva29 1.690880e-014
Cn6anva16 TDn6a31 TDnva31 1.690880e-014
Cn6anva17 TDn6a33 TDnva33 1.690880e-014
Cn7an8a1 TDn7a1 TDn8a1 1.587490e-014
Cn7an8a2 TDn7a3 TDn8a3 3.174970e-014
Cn7an8a3 TDn7a5 TDn8a5 3.174970e-014
Cn7an8a4 TDn7a7 TDn8a7 3.174970e-014
Cn7an8a5 TDn7a9 TDn8a9 3.174970e-014
Cn7an8a6 TDn7a11 TDn8a11 3.174970e-014
Cn7an8a7 TDn7a13 TDn8a13 3.174970e-014
Cn7an8a8 TDn7a15 TDn8a15 3.174970e-014
Cn7an8a9 TDn7a17 TDn8a17 3.174970e-014
Cn7an8a10 TDn7a19 TDn8a19 3.174970e-014
Cn7an8a11 TDn7a21 TDn8a21 3.174970e-014
Cn7an8a12 TDn7a23 TDn8a23 3.174970e-014
Cn7an8a13 TDn7a25 TDn8a25 3.174970e-014
Cn7an8a14 TDn7a27 TDn8a27 3.174970e-014
Cn7an8a15 TDn7a29 TDn8a29 3.174970e-014
Cn7an8a16 TDn7a31 TDn8a31 3.174970e-014
Cn7an8a17 TDn7a33 TDn8a33 1.587490e-014
Cn7an9a1 TDn7a1 TDn9a1 6.511580e-015
Cn7an9a2 TDn7a3 TDn9a3 1.302320e-014
Cn7an9a3 TDn7a5 TDn9a5 1.302320e-014
Cn7an9a4 TDn7a7 TDn9a7 1.302320e-014
Cn7an9a5 TDn7a9 TDn9a9 1.302320e-014
Cn7an9a6 TDn7a11 TDn9a11 1.302320e-014
Cn7an9a7 TDn7a13 TDn9a13 1.302320e-014
Cn7an9a8 TDn7a15 TDn9a15 1.302320e-014
Cn7an9a9 TDn7a17 TDn9a17 1.302320e-014
Cn7an9a10 TDn7a19 TDn9a19 1.302320e-014
Cn7an9a11 TDn7a21 TDn9a21 1.302320e-014
Cn7an9a12 TDn7a23 TDn9a23 1.302320e-014
Cn7an9a13 TDn7a25 TDn9a25 1.302320e-014
Cn7an9a14 TDn7a27 TDn9a27 1.302320e-014
Cn7an9a15 TDn7a29 TDn9a29 1.302320e-014
Cn7an9a16 TDn7a31 TDn9a31 1.302320e-014
Cn7an9a17 TDn7a33 TDn9a33 6.511580e-015
Cn7an10a1 TDn7a1 TDn10a1 1.690880e-014
Cn7an10a2 TDn7a3 TDn10a3 1.302320e-014
Cn7an10a3 TDn7a5 TDn10a5 1.302320e-014
Cn7an10a4 TDn7a7 TDn10a7 1.302320e-014
Cn7an10a5 TDn7a9 TDn10a9 1.302320e-014
Cn7an10a6 TDn7a11 TDn10a11 1.302320e-014
Cn7an10a7 TDn7a13 TDn10a13 1.302320e-014
Cn7an10a8 TDn7a15 TDn10a15 1.302320e-014
Cn7an10a9 TDn7a17 TDn10a17 1.302320e-014
Cn7an10a10 TDn7a19 TDn10a19 1.302320e-014
Cn7an10a11 TDn7a21 TDn10a21 1.302320e-014
Cn7an10a12 TDn7a23 TDn10a23 1.302320e-014
Cn7an10a13 TDn7a25 TDn10a25 1.302320e-014
Cn7an10a14 TDn7a27 TDn10a27 1.302320e-014
Cn7an10a15 TDn7a29 TDn10a29 1.302320e-014
Cn7an10a16 TDn7a31 TDn10a31 1.302320e-014
Cn7an10a17 TDn7a33 TDn10a33 1.690880e-014
Cn7an11a1 TDn7a1 TDn11a1 1.690880e-014
Cn7an11a2 TDn7a3 TDn11a3 1.302320e-014
Cn7an11a3 TDn7a5 TDn11a5 1.302320e-014
Cn7an11a4 TDn7a7 TDn11a7 1.302320e-014
Cn7an11a5 TDn7a9 TDn11a9 1.302320e-014
Cn7an11a6 TDn7a11 TDn11a11 1.302320e-014
Cn7an11a7 TDn7a13 TDn11a13 1.302320e-014
Cn7an11a8 TDn7a15 TDn11a15 1.302320e-014
Cn7an11a9 TDn7a17 TDn11a17 1.302320e-014
Cn7an11a10 TDn7a19 TDn11a19 1.302320e-014
Cn7an11a11 TDn7a21 TDn11a21 1.302320e-014
Cn7an11a12 TDn7a23 TDn11a23 1.302320e-014
Cn7an11a13 TDn7a25 TDn11a25 1.302320e-014
Cn7an11a14 TDn7a27 TDn11a27 1.302320e-014
Cn7an11a15 TDn7a29 TDn11a29 1.302320e-014
Cn7an11a16 TDn7a31 TDn11a31 1.302320e-014
Cn7an11a17 TDn7a33 TDn11a33 1.690880e-014
Cn7an12a1 TDn7a1 TDn12a1 1.690880e-014
Cn7an12a2 TDn7a3 TDn12a3 1.302320e-014
Cn7an12a3 TDn7a5 TDn12a5 1.302320e-014
Cn7an12a4 TDn7a7 TDn12a7 1.302320e-014
Cn7an12a5 TDn7a9 TDn12a9 1.302320e-014
Cn7an12a6 TDn7a11 TDn12a11 1.302320e-014
Cn7an12a7 TDn7a13 TDn12a13 1.302320e-014
Cn7an12a8 TDn7a15 TDn12a15 1.302320e-014
Cn7an12a9 TDn7a17 TDn12a17 1.302320e-014
Cn7an12a10 TDn7a19 TDn12a19 1.302320e-014
Cn7an12a11 TDn7a21 TDn12a21 1.302320e-014
Cn7an12a12 TDn7a23 TDn12a23 1.302320e-014
Cn7an12a13 TDn7a25 TDn12a25 1.302320e-014
Cn7an12a14 TDn7a27 TDn12a27 1.302320e-014
Cn7an12a15 TDn7a29 TDn12a29 1.302320e-014
Cn7an12a16 TDn7a31 TDn12a31 1.302320e-014
Cn7an12a17 TDn7a33 TDn12a33 1.690880e-014
Cn7an13a1 TDn7a1 TDn13a1 1.690880e-014
Cn7an13a2 TDn7a3 TDn13a3 1.302320e-014
Cn7an13a3 TDn7a5 TDn13a5 1.302320e-014
Cn7an13a4 TDn7a7 TDn13a7 1.302320e-014
Cn7an13a5 TDn7a9 TDn13a9 1.302320e-014
Cn7an13a6 TDn7a11 TDn13a11 1.302320e-014
Cn7an13a7 TDn7a13 TDn13a13 1.302320e-014
Cn7an13a8 TDn7a15 TDn13a15 1.302320e-014
Cn7an13a9 TDn7a17 TDn13a17 1.302320e-014
Cn7an13a10 TDn7a19 TDn13a19 1.302320e-014
Cn7an13a11 TDn7a21 TDn13a21 1.302320e-014
Cn7an13a12 TDn7a23 TDn13a23 1.302320e-014
Cn7an13a13 TDn7a25 TDn13a25 1.302320e-014
Cn7an13a14 TDn7a27 TDn13a27 1.302320e-014
Cn7an13a15 TDn7a29 TDn13a29 1.302320e-014
Cn7an13a16 TDn7a31 TDn13a31 1.302320e-014
Cn7an13a17 TDn7a33 TDn13a33 1.690880e-014
Cn7an14a1 TDn7a1 TDn14a1 1.690880e-014
Cn7an14a2 TDn7a3 TDn14a3 1.302320e-014
Cn7an14a3 TDn7a5 TDn14a5 1.302320e-014
Cn7an14a4 TDn7a7 TDn14a7 1.302320e-014
Cn7an14a5 TDn7a9 TDn14a9 1.302320e-014
Cn7an14a6 TDn7a11 TDn14a11 1.302320e-014
Cn7an14a7 TDn7a13 TDn14a13 1.302320e-014
Cn7an14a8 TDn7a15 TDn14a15 1.302320e-014
Cn7an14a9 TDn7a17 TDn14a17 1.302320e-014
Cn7an14a10 TDn7a19 TDn14a19 1.302320e-014
Cn7an14a11 TDn7a21 TDn14a21 1.302320e-014
Cn7an14a12 TDn7a23 TDn14a23 1.302320e-014
Cn7an14a13 TDn7a25 TDn14a25 1.302320e-014
Cn7an14a14 TDn7a27 TDn14a27 1.302320e-014
Cn7an14a15 TDn7a29 TDn14a29 1.302320e-014
Cn7an14a16 TDn7a31 TDn14a31 1.302320e-014
Cn7an14a17 TDn7a33 TDn14a33 1.690880e-014
Cn7an15a1 TDn7a1 TDn15a1 1.690880e-014
Cn7an15a2 TDn7a3 TDn15a3 1.302320e-014
Cn7an15a3 TDn7a5 TDn15a5 1.302320e-014
Cn7an15a4 TDn7a7 TDn15a7 1.302320e-014
Cn7an15a5 TDn7a9 TDn15a9 1.302320e-014
Cn7an15a6 TDn7a11 TDn15a11 1.302320e-014
Cn7an15a7 TDn7a13 TDn15a13 1.302320e-014
Cn7an15a8 TDn7a15 TDn15a15 1.302320e-014
Cn7an15a9 TDn7a17 TDn15a17 1.302320e-014
Cn7an15a10 TDn7a19 TDn15a19 1.302320e-014
Cn7an15a11 TDn7a21 TDn15a21 1.302320e-014
Cn7an15a12 TDn7a23 TDn15a23 1.302320e-014
Cn7an15a13 TDn7a25 TDn15a25 1.302320e-014
Cn7an15a14 TDn7a27 TDn15a27 1.302320e-014
Cn7an15a15 TDn7a29 TDn15a29 1.302320e-014
Cn7an15a16 TDn7a31 TDn15a31 1.302320e-014
Cn7an15a17 TDn7a33 TDn15a33 1.690880e-014
Cn7an16a1 TDn7a1 TDn16a1 1.690880e-014
Cn7an16a2 TDn7a3 TDn16a3 1.302320e-014
Cn7an16a3 TDn7a5 TDn16a5 1.302320e-014
Cn7an16a4 TDn7a7 TDn16a7 1.302320e-014
Cn7an16a5 TDn7a9 TDn16a9 1.302320e-014
Cn7an16a6 TDn7a11 TDn16a11 1.302320e-014
Cn7an16a7 TDn7a13 TDn16a13 1.302320e-014
Cn7an16a8 TDn7a15 TDn16a15 1.302320e-014
Cn7an16a9 TDn7a17 TDn16a17 1.302320e-014
Cn7an16a10 TDn7a19 TDn16a19 1.302320e-014
Cn7an16a11 TDn7a21 TDn16a21 1.302320e-014
Cn7an16a12 TDn7a23 TDn16a23 1.302320e-014
Cn7an16a13 TDn7a25 TDn16a25 1.302320e-014
Cn7an16a14 TDn7a27 TDn16a27 1.302320e-014
Cn7an16a15 TDn7a29 TDn16a29 1.302320e-014
Cn7an16a16 TDn7a31 TDn16a31 1.302320e-014
Cn7an16a17 TDn7a33 TDn16a33 1.690880e-014
Cn7an17a1 TDn7a1 TDn17a1 1.690880e-014
Cn7an17a2 TDn7a3 TDn17a3 1.302320e-014
Cn7an17a3 TDn7a5 TDn17a5 1.302320e-014
Cn7an17a4 TDn7a7 TDn17a7 1.302320e-014
Cn7an17a5 TDn7a9 TDn17a9 1.302320e-014
Cn7an17a6 TDn7a11 TDn17a11 1.302320e-014
Cn7an17a7 TDn7a13 TDn17a13 1.302320e-014
Cn7an17a8 TDn7a15 TDn17a15 1.302320e-014
Cn7an17a9 TDn7a17 TDn17a17 1.302320e-014
Cn7an17a10 TDn7a19 TDn17a19 1.302320e-014
Cn7an17a11 TDn7a21 TDn17a21 1.302320e-014
Cn7an17a12 TDn7a23 TDn17a23 1.302320e-014
Cn7an17a13 TDn7a25 TDn17a25 1.302320e-014
Cn7an17a14 TDn7a27 TDn17a27 1.302320e-014
Cn7an17a15 TDn7a29 TDn17a29 1.302320e-014
Cn7an17a16 TDn7a31 TDn17a31 1.302320e-014
Cn7an17a17 TDn7a33 TDn17a33 1.690880e-014
Cn7an18a1 TDn7a1 TDn18a1 1.690880e-014
Cn7an18a2 TDn7a3 TDn18a3 1.302320e-014
Cn7an18a3 TDn7a5 TDn18a5 1.302320e-014
Cn7an18a4 TDn7a7 TDn18a7 1.302320e-014
Cn7an18a5 TDn7a9 TDn18a9 1.302320e-014
Cn7an18a6 TDn7a11 TDn18a11 1.302320e-014
Cn7an18a7 TDn7a13 TDn18a13 1.302320e-014
Cn7an18a8 TDn7a15 TDn18a15 1.302320e-014
Cn7an18a9 TDn7a17 TDn18a17 1.302320e-014
Cn7an18a10 TDn7a19 TDn18a19 1.302320e-014
Cn7an18a11 TDn7a21 TDn18a21 1.302320e-014
Cn7an18a12 TDn7a23 TDn18a23 1.302320e-014
Cn7an18a13 TDn7a25 TDn18a25 1.302320e-014
Cn7an18a14 TDn7a27 TDn18a27 1.302320e-014
Cn7an18a15 TDn7a29 TDn18a29 1.302320e-014
Cn7an18a16 TDn7a31 TDn18a31 1.302320e-014
Cn7an18a17 TDn7a33 TDn18a33 1.690880e-014
Cn7an19a1 TDn7a1 TDn19a1 1.690880e-014
Cn7an19a2 TDn7a3 TDn19a3 1.302320e-014
Cn7an19a3 TDn7a5 TDn19a5 1.302320e-014
Cn7an19a4 TDn7a7 TDn19a7 1.302320e-014
Cn7an19a5 TDn7a9 TDn19a9 1.302320e-014
Cn7an19a6 TDn7a11 TDn19a11 1.302320e-014
Cn7an19a7 TDn7a13 TDn19a13 1.302320e-014
Cn7an19a8 TDn7a15 TDn19a15 1.302320e-014
Cn7an19a9 TDn7a17 TDn19a17 1.302320e-014
Cn7an19a10 TDn7a19 TDn19a19 1.302320e-014
Cn7an19a11 TDn7a21 TDn19a21 1.302320e-014
Cn7an19a12 TDn7a23 TDn19a23 1.302320e-014
Cn7an19a13 TDn7a25 TDn19a25 1.302320e-014
Cn7an19a14 TDn7a27 TDn19a27 1.302320e-014
Cn7an19a15 TDn7a29 TDn19a29 1.302320e-014
Cn7an19a16 TDn7a31 TDn19a31 1.302320e-014
Cn7an19a17 TDn7a33 TDn19a33 1.690880e-014
Cn7an20a1 TDn7a1 TDn20a1 1.690880e-014
Cn7an20a2 TDn7a3 TDn20a3 1.302320e-014
Cn7an20a3 TDn7a5 TDn20a5 1.302320e-014
Cn7an20a4 TDn7a7 TDn20a7 1.302320e-014
Cn7an20a5 TDn7a9 TDn20a9 1.302320e-014
Cn7an20a6 TDn7a11 TDn20a11 1.302320e-014
Cn7an20a7 TDn7a13 TDn20a13 1.302320e-014
Cn7an20a8 TDn7a15 TDn20a15 1.302320e-014
Cn7an20a9 TDn7a17 TDn20a17 1.302320e-014
Cn7an20a10 TDn7a19 TDn20a19 1.302320e-014
Cn7an20a11 TDn7a21 TDn20a21 1.302320e-014
Cn7an20a12 TDn7a23 TDn20a23 1.302320e-014
Cn7an20a13 TDn7a25 TDn20a25 1.302320e-014
Cn7an20a14 TDn7a27 TDn20a27 1.302320e-014
Cn7an20a15 TDn7a29 TDn20a29 1.302320e-014
Cn7an20a16 TDn7a31 TDn20a31 1.302320e-014
Cn7an20a17 TDn7a33 TDn20a33 1.690880e-014
Cn7an21a1 TDn7a1 TDn21a1 1.690880e-014
Cn7an21a2 TDn7a3 TDn21a3 1.302320e-014
Cn7an21a3 TDn7a5 TDn21a5 1.302320e-014
Cn7an21a4 TDn7a7 TDn21a7 1.302320e-014
Cn7an21a5 TDn7a9 TDn21a9 1.302320e-014
Cn7an21a6 TDn7a11 TDn21a11 1.302320e-014
Cn7an21a7 TDn7a13 TDn21a13 1.302320e-014
Cn7an21a8 TDn7a15 TDn21a15 1.302320e-014
Cn7an21a9 TDn7a17 TDn21a17 1.302320e-014
Cn7an21a10 TDn7a19 TDn21a19 1.302320e-014
Cn7an21a11 TDn7a21 TDn21a21 1.302320e-014
Cn7an21a12 TDn7a23 TDn21a23 1.302320e-014
Cn7an21a13 TDn7a25 TDn21a25 1.302320e-014
Cn7an21a14 TDn7a27 TDn21a27 1.302320e-014
Cn7an21a15 TDn7a29 TDn21a29 1.302320e-014
Cn7an21a16 TDn7a31 TDn21a31 1.302320e-014
Cn7an21a17 TDn7a33 TDn21a33 1.690880e-014
Cn7an22a1 TDn7a1 TDn22a1 1.690880e-014
Cn7an22a2 TDn7a3 TDn22a3 1.302320e-014
Cn7an22a3 TDn7a5 TDn22a5 1.302320e-014
Cn7an22a4 TDn7a7 TDn22a7 1.302320e-014
Cn7an22a5 TDn7a9 TDn22a9 1.302320e-014
Cn7an22a6 TDn7a11 TDn22a11 1.302320e-014
Cn7an22a7 TDn7a13 TDn22a13 1.302320e-014
Cn7an22a8 TDn7a15 TDn22a15 1.302320e-014
Cn7an22a9 TDn7a17 TDn22a17 1.302320e-014
Cn7an22a10 TDn7a19 TDn22a19 1.302320e-014
Cn7an22a11 TDn7a21 TDn22a21 1.302320e-014
Cn7an22a12 TDn7a23 TDn22a23 1.302320e-014
Cn7an22a13 TDn7a25 TDn22a25 1.302320e-014
Cn7an22a14 TDn7a27 TDn22a27 1.302320e-014
Cn7an22a15 TDn7a29 TDn22a29 1.302320e-014
Cn7an22a16 TDn7a31 TDn22a31 1.302320e-014
Cn7an22a17 TDn7a33 TDn22a33 1.690880e-014
Cn7an23a1 TDn7a1 TDn23a1 1.690880e-014
Cn7an23a2 TDn7a3 TDn23a3 1.302320e-014
Cn7an23a3 TDn7a5 TDn23a5 1.302320e-014
Cn7an23a4 TDn7a7 TDn23a7 1.302320e-014
Cn7an23a5 TDn7a9 TDn23a9 1.302320e-014
Cn7an23a6 TDn7a11 TDn23a11 1.302320e-014
Cn7an23a7 TDn7a13 TDn23a13 1.302320e-014
Cn7an23a8 TDn7a15 TDn23a15 1.302320e-014
Cn7an23a9 TDn7a17 TDn23a17 1.302320e-014
Cn7an23a10 TDn7a19 TDn23a19 1.302320e-014
Cn7an23a11 TDn7a21 TDn23a21 1.302320e-014
Cn7an23a12 TDn7a23 TDn23a23 1.302320e-014
Cn7an23a13 TDn7a25 TDn23a25 1.302320e-014
Cn7an23a14 TDn7a27 TDn23a27 1.302320e-014
Cn7an23a15 TDn7a29 TDn23a29 1.302320e-014
Cn7an23a16 TDn7a31 TDn23a31 1.302320e-014
Cn7an23a17 TDn7a33 TDn23a33 1.690880e-014
Cn7an24a1 TDn7a1 TDn24a1 1.690880e-014
Cn7an24a2 TDn7a3 TDn24a3 1.302320e-014
Cn7an24a3 TDn7a5 TDn24a5 1.302320e-014
Cn7an24a4 TDn7a7 TDn24a7 1.302320e-014
Cn7an24a5 TDn7a9 TDn24a9 1.302320e-014
Cn7an24a6 TDn7a11 TDn24a11 1.302320e-014
Cn7an24a7 TDn7a13 TDn24a13 1.302320e-014
Cn7an24a8 TDn7a15 TDn24a15 1.302320e-014
Cn7an24a9 TDn7a17 TDn24a17 1.302320e-014
Cn7an24a10 TDn7a19 TDn24a19 1.302320e-014
Cn7an24a11 TDn7a21 TDn24a21 1.302320e-014
Cn7an24a12 TDn7a23 TDn24a23 1.302320e-014
Cn7an24a13 TDn7a25 TDn24a25 1.302320e-014
Cn7an24a14 TDn7a27 TDn24a27 1.302320e-014
Cn7an24a15 TDn7a29 TDn24a29 1.302320e-014
Cn7an24a16 TDn7a31 TDn24a31 1.302320e-014
Cn7an24a17 TDn7a33 TDn24a33 1.690880e-014
Cn7an25a1 TDn7a1 TDn25a1 1.690880e-014
Cn7an25a2 TDn7a3 TDn25a3 1.302320e-014
Cn7an25a3 TDn7a5 TDn25a5 1.302320e-014
Cn7an25a4 TDn7a7 TDn25a7 1.302320e-014
Cn7an25a5 TDn7a9 TDn25a9 1.302320e-014
Cn7an25a6 TDn7a11 TDn25a11 1.302320e-014
Cn7an25a7 TDn7a13 TDn25a13 1.302320e-014
Cn7an25a8 TDn7a15 TDn25a15 1.302320e-014
Cn7an25a9 TDn7a17 TDn25a17 1.302320e-014
Cn7an25a10 TDn7a19 TDn25a19 1.302320e-014
Cn7an25a11 TDn7a21 TDn25a21 1.302320e-014
Cn7an25a12 TDn7a23 TDn25a23 1.302320e-014
Cn7an25a13 TDn7a25 TDn25a25 1.302320e-014
Cn7an25a14 TDn7a27 TDn25a27 1.302320e-014
Cn7an25a15 TDn7a29 TDn25a29 1.302320e-014
Cn7an25a16 TDn7a31 TDn25a31 1.302320e-014
Cn7an25a17 TDn7a33 TDn25a33 1.690880e-014
Cn7an26a1 TDn7a1 TDn26a1 1.690880e-014
Cn7an26a2 TDn7a3 TDn26a3 1.302320e-014
Cn7an26a3 TDn7a5 TDn26a5 1.302320e-014
Cn7an26a4 TDn7a7 TDn26a7 1.302320e-014
Cn7an26a5 TDn7a9 TDn26a9 1.302320e-014
Cn7an26a6 TDn7a11 TDn26a11 1.302320e-014
Cn7an26a7 TDn7a13 TDn26a13 1.302320e-014
Cn7an26a8 TDn7a15 TDn26a15 1.302320e-014
Cn7an26a9 TDn7a17 TDn26a17 1.302320e-014
Cn7an26a10 TDn7a19 TDn26a19 1.302320e-014
Cn7an26a11 TDn7a21 TDn26a21 1.302320e-014
Cn7an26a12 TDn7a23 TDn26a23 1.302320e-014
Cn7an26a13 TDn7a25 TDn26a25 1.302320e-014
Cn7an26a14 TDn7a27 TDn26a27 1.302320e-014
Cn7an26a15 TDn7a29 TDn26a29 1.302320e-014
Cn7an26a16 TDn7a31 TDn26a31 1.302320e-014
Cn7an26a17 TDn7a33 TDn26a33 1.690880e-014
Cn7an27a1 TDn7a1 TDn27a1 1.690880e-014
Cn7an27a2 TDn7a3 TDn27a3 1.302320e-014
Cn7an27a3 TDn7a5 TDn27a5 1.302320e-014
Cn7an27a4 TDn7a7 TDn27a7 1.302320e-014
Cn7an27a5 TDn7a9 TDn27a9 1.302320e-014
Cn7an27a6 TDn7a11 TDn27a11 1.302320e-014
Cn7an27a7 TDn7a13 TDn27a13 1.302320e-014
Cn7an27a8 TDn7a15 TDn27a15 1.302320e-014
Cn7an27a9 TDn7a17 TDn27a17 1.302320e-014
Cn7an27a10 TDn7a19 TDn27a19 1.302320e-014
Cn7an27a11 TDn7a21 TDn27a21 1.302320e-014
Cn7an27a12 TDn7a23 TDn27a23 1.302320e-014
Cn7an27a13 TDn7a25 TDn27a25 1.302320e-014
Cn7an27a14 TDn7a27 TDn27a27 1.302320e-014
Cn7an27a15 TDn7a29 TDn27a29 1.302320e-014
Cn7an27a16 TDn7a31 TDn27a31 1.302320e-014
Cn7an27a17 TDn7a33 TDn27a33 1.690880e-014
Cn7an28a1 TDn7a1 TDn28a1 1.690880e-014
Cn7an28a2 TDn7a3 TDn28a3 1.302320e-014
Cn7an28a3 TDn7a5 TDn28a5 1.302320e-014
Cn7an28a4 TDn7a7 TDn28a7 1.302320e-014
Cn7an28a5 TDn7a9 TDn28a9 1.302320e-014
Cn7an28a6 TDn7a11 TDn28a11 1.302320e-014
Cn7an28a7 TDn7a13 TDn28a13 1.302320e-014
Cn7an28a8 TDn7a15 TDn28a15 1.302320e-014
Cn7an28a9 TDn7a17 TDn28a17 1.302320e-014
Cn7an28a10 TDn7a19 TDn28a19 1.302320e-014
Cn7an28a11 TDn7a21 TDn28a21 1.302320e-014
Cn7an28a12 TDn7a23 TDn28a23 1.302320e-014
Cn7an28a13 TDn7a25 TDn28a25 1.302320e-014
Cn7an28a14 TDn7a27 TDn28a27 1.302320e-014
Cn7an28a15 TDn7a29 TDn28a29 1.302320e-014
Cn7an28a16 TDn7a31 TDn28a31 1.302320e-014
Cn7an28a17 TDn7a33 TDn28a33 1.690880e-014
Cn7an29a1 TDn7a1 TDn29a1 1.690880e-014
Cn7an29a2 TDn7a3 TDn29a3 1.302320e-014
Cn7an29a3 TDn7a5 TDn29a5 1.302320e-014
Cn7an29a4 TDn7a7 TDn29a7 1.302320e-014
Cn7an29a5 TDn7a9 TDn29a9 1.302320e-014
Cn7an29a6 TDn7a11 TDn29a11 1.302320e-014
Cn7an29a7 TDn7a13 TDn29a13 1.302320e-014
Cn7an29a8 TDn7a15 TDn29a15 1.302320e-014
Cn7an29a9 TDn7a17 TDn29a17 1.302320e-014
Cn7an29a10 TDn7a19 TDn29a19 1.302320e-014
Cn7an29a11 TDn7a21 TDn29a21 1.302320e-014
Cn7an29a12 TDn7a23 TDn29a23 1.302320e-014
Cn7an29a13 TDn7a25 TDn29a25 1.302320e-014
Cn7an29a14 TDn7a27 TDn29a27 1.302320e-014
Cn7an29a15 TDn7a29 TDn29a29 1.302320e-014
Cn7an29a16 TDn7a31 TDn29a31 1.302320e-014
Cn7an29a17 TDn7a33 TDn29a33 1.690880e-014
Cn7an30a1 TDn7a1 TDn30a1 1.690880e-014
Cn7an30a2 TDn7a3 TDn30a3 1.302320e-014
Cn7an30a3 TDn7a5 TDn30a5 1.302320e-014
Cn7an30a4 TDn7a7 TDn30a7 1.302320e-014
Cn7an30a5 TDn7a9 TDn30a9 1.302320e-014
Cn7an30a6 TDn7a11 TDn30a11 1.302320e-014
Cn7an30a7 TDn7a13 TDn30a13 1.302320e-014
Cn7an30a8 TDn7a15 TDn30a15 1.302320e-014
Cn7an30a9 TDn7a17 TDn30a17 1.302320e-014
Cn7an30a10 TDn7a19 TDn30a19 1.302320e-014
Cn7an30a11 TDn7a21 TDn30a21 1.302320e-014
Cn7an30a12 TDn7a23 TDn30a23 1.302320e-014
Cn7an30a13 TDn7a25 TDn30a25 1.302320e-014
Cn7an30a14 TDn7a27 TDn30a27 1.302320e-014
Cn7an30a15 TDn7a29 TDn30a29 1.302320e-014
Cn7an30a16 TDn7a31 TDn30a31 1.302320e-014
Cn7an30a17 TDn7a33 TDn30a33 1.690880e-014
Cn7an31a1 TDn7a1 TDn31a1 1.690880e-014
Cn7an31a2 TDn7a3 TDn31a3 1.302320e-014
Cn7an31a3 TDn7a5 TDn31a5 1.302320e-014
Cn7an31a4 TDn7a7 TDn31a7 1.302320e-014
Cn7an31a5 TDn7a9 TDn31a9 1.302320e-014
Cn7an31a6 TDn7a11 TDn31a11 1.302320e-014
Cn7an31a7 TDn7a13 TDn31a13 1.302320e-014
Cn7an31a8 TDn7a15 TDn31a15 1.302320e-014
Cn7an31a9 TDn7a17 TDn31a17 1.302320e-014
Cn7an31a10 TDn7a19 TDn31a19 1.302320e-014
Cn7an31a11 TDn7a21 TDn31a21 1.302320e-014
Cn7an31a12 TDn7a23 TDn31a23 1.302320e-014
Cn7an31a13 TDn7a25 TDn31a25 1.302320e-014
Cn7an31a14 TDn7a27 TDn31a27 1.302320e-014
Cn7an31a15 TDn7a29 TDn31a29 1.302320e-014
Cn7an31a16 TDn7a31 TDn31a31 1.302320e-014
Cn7an31a17 TDn7a33 TDn31a33 1.690880e-014
Cn7an32a1 TDn7a1 TDn32a1 1.690880e-014
Cn7an32a2 TDn7a3 TDn32a3 1.302320e-014
Cn7an32a3 TDn7a5 TDn32a5 1.302320e-014
Cn7an32a4 TDn7a7 TDn32a7 1.302320e-014
Cn7an32a5 TDn7a9 TDn32a9 1.302320e-014
Cn7an32a6 TDn7a11 TDn32a11 1.302320e-014
Cn7an32a7 TDn7a13 TDn32a13 1.302320e-014
Cn7an32a8 TDn7a15 TDn32a15 1.302320e-014
Cn7an32a9 TDn7a17 TDn32a17 1.302320e-014
Cn7an32a10 TDn7a19 TDn32a19 1.302320e-014
Cn7an32a11 TDn7a21 TDn32a21 1.302320e-014
Cn7an32a12 TDn7a23 TDn32a23 1.302320e-014
Cn7an32a13 TDn7a25 TDn32a25 1.302320e-014
Cn7an32a14 TDn7a27 TDn32a27 1.302320e-014
Cn7an32a15 TDn7a29 TDn32a29 1.302320e-014
Cn7an32a16 TDn7a31 TDn32a31 1.302320e-014
Cn7an32a17 TDn7a33 TDn32a33 1.690880e-014
Cn7anva1 TDn7a1 TDnva1 1.690880e-014
Cn7anva2 TDn7a3 TDnva3 1.690880e-014
Cn7anva3 TDn7a5 TDnva5 1.690880e-014
Cn7anva4 TDn7a7 TDnva7 1.690880e-014
Cn7anva5 TDn7a9 TDnva9 1.690880e-014
Cn7anva6 TDn7a11 TDnva11 1.690880e-014
Cn7anva7 TDn7a13 TDnva13 1.690880e-014
Cn7anva8 TDn7a15 TDnva15 1.690880e-014
Cn7anva9 TDn7a17 TDnva17 1.690880e-014
Cn7anva10 TDn7a19 TDnva19 1.690880e-014
Cn7anva11 TDn7a21 TDnva21 1.690880e-014
Cn7anva12 TDn7a23 TDnva23 1.690880e-014
Cn7anva13 TDn7a25 TDnva25 1.690880e-014
Cn7anva14 TDn7a27 TDnva27 1.690880e-014
Cn7anva15 TDn7a29 TDnva29 1.690880e-014
Cn7anva16 TDn7a31 TDnva31 1.690880e-014
Cn7anva17 TDn7a33 TDnva33 1.690880e-014
Cn8an9a1 TDn8a1 TDn9a1 1.690880e-014
Cn8an9a2 TDn8a3 TDn9a3 3.381750e-014
Cn8an9a3 TDn8a5 TDn9a5 3.381750e-014
Cn8an9a4 TDn8a7 TDn9a7 3.381750e-014
Cn8an9a5 TDn8a9 TDn9a9 3.381750e-014
Cn8an9a6 TDn8a11 TDn9a11 3.381750e-014
Cn8an9a7 TDn8a13 TDn9a13 3.381750e-014
Cn8an9a8 TDn8a15 TDn9a15 3.381750e-014
Cn8an9a9 TDn8a17 TDn9a17 3.381750e-014
Cn8an9a10 TDn8a19 TDn9a19 3.381750e-014
Cn8an9a11 TDn8a21 TDn9a21 3.381750e-014
Cn8an9a12 TDn8a23 TDn9a23 3.381750e-014
Cn8an9a13 TDn8a25 TDn9a25 3.381750e-014
Cn8an9a14 TDn8a27 TDn9a27 3.381750e-014
Cn8an9a15 TDn8a29 TDn9a29 3.381750e-014
Cn8an9a16 TDn8a31 TDn9a31 3.381750e-014
Cn8an9a17 TDn8a33 TDn9a33 1.690880e-014
Cn8an10a1 TDn8a1 TDn10a1 1.690880e-014
Cn8an10a2 TDn8a3 TDn10a3 1.302320e-014
Cn8an10a3 TDn8a5 TDn10a5 1.302320e-014
Cn8an10a4 TDn8a7 TDn10a7 1.302320e-014
Cn8an10a5 TDn8a9 TDn10a9 1.302320e-014
Cn8an10a6 TDn8a11 TDn10a11 1.302320e-014
Cn8an10a7 TDn8a13 TDn10a13 1.302320e-014
Cn8an10a8 TDn8a15 TDn10a15 1.302320e-014
Cn8an10a9 TDn8a17 TDn10a17 1.302320e-014
Cn8an10a10 TDn8a19 TDn10a19 1.302320e-014
Cn8an10a11 TDn8a21 TDn10a21 1.302320e-014
Cn8an10a12 TDn8a23 TDn10a23 1.302320e-014
Cn8an10a13 TDn8a25 TDn10a25 1.302320e-014
Cn8an10a14 TDn8a27 TDn10a27 1.302320e-014
Cn8an10a15 TDn8a29 TDn10a29 1.302320e-014
Cn8an10a16 TDn8a31 TDn10a31 1.302320e-014
Cn8an10a17 TDn8a33 TDn10a33 1.690880e-014
Cn8an11a1 TDn8a1 TDn11a1 1.690880e-014
Cn8an11a2 TDn8a3 TDn11a3 1.302320e-014
Cn8an11a3 TDn8a5 TDn11a5 1.302320e-014
Cn8an11a4 TDn8a7 TDn11a7 1.302320e-014
Cn8an11a5 TDn8a9 TDn11a9 1.302320e-014
Cn8an11a6 TDn8a11 TDn11a11 1.302320e-014
Cn8an11a7 TDn8a13 TDn11a13 1.302320e-014
Cn8an11a8 TDn8a15 TDn11a15 1.302320e-014
Cn8an11a9 TDn8a17 TDn11a17 1.302320e-014
Cn8an11a10 TDn8a19 TDn11a19 1.302320e-014
Cn8an11a11 TDn8a21 TDn11a21 1.302320e-014
Cn8an11a12 TDn8a23 TDn11a23 1.302320e-014
Cn8an11a13 TDn8a25 TDn11a25 1.302320e-014
Cn8an11a14 TDn8a27 TDn11a27 1.302320e-014
Cn8an11a15 TDn8a29 TDn11a29 1.302320e-014
Cn8an11a16 TDn8a31 TDn11a31 1.302320e-014
Cn8an11a17 TDn8a33 TDn11a33 1.690880e-014
Cn8an12a1 TDn8a1 TDn12a1 1.690880e-014
Cn8an12a2 TDn8a3 TDn12a3 1.302320e-014
Cn8an12a3 TDn8a5 TDn12a5 1.302320e-014
Cn8an12a4 TDn8a7 TDn12a7 1.302320e-014
Cn8an12a5 TDn8a9 TDn12a9 1.302320e-014
Cn8an12a6 TDn8a11 TDn12a11 1.302320e-014
Cn8an12a7 TDn8a13 TDn12a13 1.302320e-014
Cn8an12a8 TDn8a15 TDn12a15 1.302320e-014
Cn8an12a9 TDn8a17 TDn12a17 1.302320e-014
Cn8an12a10 TDn8a19 TDn12a19 1.302320e-014
Cn8an12a11 TDn8a21 TDn12a21 1.302320e-014
Cn8an12a12 TDn8a23 TDn12a23 1.302320e-014
Cn8an12a13 TDn8a25 TDn12a25 1.302320e-014
Cn8an12a14 TDn8a27 TDn12a27 1.302320e-014
Cn8an12a15 TDn8a29 TDn12a29 1.302320e-014
Cn8an12a16 TDn8a31 TDn12a31 1.302320e-014
Cn8an12a17 TDn8a33 TDn12a33 1.690880e-014
Cn8an13a1 TDn8a1 TDn13a1 1.690880e-014
Cn8an13a2 TDn8a3 TDn13a3 1.302320e-014
Cn8an13a3 TDn8a5 TDn13a5 1.302320e-014
Cn8an13a4 TDn8a7 TDn13a7 1.302320e-014
Cn8an13a5 TDn8a9 TDn13a9 1.302320e-014
Cn8an13a6 TDn8a11 TDn13a11 1.302320e-014
Cn8an13a7 TDn8a13 TDn13a13 1.302320e-014
Cn8an13a8 TDn8a15 TDn13a15 1.302320e-014
Cn8an13a9 TDn8a17 TDn13a17 1.302320e-014
Cn8an13a10 TDn8a19 TDn13a19 1.302320e-014
Cn8an13a11 TDn8a21 TDn13a21 1.302320e-014
Cn8an13a12 TDn8a23 TDn13a23 1.302320e-014
Cn8an13a13 TDn8a25 TDn13a25 1.302320e-014
Cn8an13a14 TDn8a27 TDn13a27 1.302320e-014
Cn8an13a15 TDn8a29 TDn13a29 1.302320e-014
Cn8an13a16 TDn8a31 TDn13a31 1.302320e-014
Cn8an13a17 TDn8a33 TDn13a33 1.690880e-014
Cn8an14a1 TDn8a1 TDn14a1 1.690880e-014
Cn8an14a2 TDn8a3 TDn14a3 1.302320e-014
Cn8an14a3 TDn8a5 TDn14a5 1.302320e-014
Cn8an14a4 TDn8a7 TDn14a7 1.302320e-014
Cn8an14a5 TDn8a9 TDn14a9 1.302320e-014
Cn8an14a6 TDn8a11 TDn14a11 1.302320e-014
Cn8an14a7 TDn8a13 TDn14a13 1.302320e-014
Cn8an14a8 TDn8a15 TDn14a15 1.302320e-014
Cn8an14a9 TDn8a17 TDn14a17 1.302320e-014
Cn8an14a10 TDn8a19 TDn14a19 1.302320e-014
Cn8an14a11 TDn8a21 TDn14a21 1.302320e-014
Cn8an14a12 TDn8a23 TDn14a23 1.302320e-014
Cn8an14a13 TDn8a25 TDn14a25 1.302320e-014
Cn8an14a14 TDn8a27 TDn14a27 1.302320e-014
Cn8an14a15 TDn8a29 TDn14a29 1.302320e-014
Cn8an14a16 TDn8a31 TDn14a31 1.302320e-014
Cn8an14a17 TDn8a33 TDn14a33 1.690880e-014
Cn8an15a1 TDn8a1 TDn15a1 1.690880e-014
Cn8an15a2 TDn8a3 TDn15a3 1.302320e-014
Cn8an15a3 TDn8a5 TDn15a5 1.302320e-014
Cn8an15a4 TDn8a7 TDn15a7 1.302320e-014
Cn8an15a5 TDn8a9 TDn15a9 1.302320e-014
Cn8an15a6 TDn8a11 TDn15a11 1.302320e-014
Cn8an15a7 TDn8a13 TDn15a13 1.302320e-014
Cn8an15a8 TDn8a15 TDn15a15 1.302320e-014
Cn8an15a9 TDn8a17 TDn15a17 1.302320e-014
Cn8an15a10 TDn8a19 TDn15a19 1.302320e-014
Cn8an15a11 TDn8a21 TDn15a21 1.302320e-014
Cn8an15a12 TDn8a23 TDn15a23 1.302320e-014
Cn8an15a13 TDn8a25 TDn15a25 1.302320e-014
Cn8an15a14 TDn8a27 TDn15a27 1.302320e-014
Cn8an15a15 TDn8a29 TDn15a29 1.302320e-014
Cn8an15a16 TDn8a31 TDn15a31 1.302320e-014
Cn8an15a17 TDn8a33 TDn15a33 1.690880e-014
Cn8an16a1 TDn8a1 TDn16a1 1.690880e-014
Cn8an16a2 TDn8a3 TDn16a3 1.302320e-014
Cn8an16a3 TDn8a5 TDn16a5 1.302320e-014
Cn8an16a4 TDn8a7 TDn16a7 1.302320e-014
Cn8an16a5 TDn8a9 TDn16a9 1.302320e-014
Cn8an16a6 TDn8a11 TDn16a11 1.302320e-014
Cn8an16a7 TDn8a13 TDn16a13 1.302320e-014
Cn8an16a8 TDn8a15 TDn16a15 1.302320e-014
Cn8an16a9 TDn8a17 TDn16a17 1.302320e-014
Cn8an16a10 TDn8a19 TDn16a19 1.302320e-014
Cn8an16a11 TDn8a21 TDn16a21 1.302320e-014
Cn8an16a12 TDn8a23 TDn16a23 1.302320e-014
Cn8an16a13 TDn8a25 TDn16a25 1.302320e-014
Cn8an16a14 TDn8a27 TDn16a27 1.302320e-014
Cn8an16a15 TDn8a29 TDn16a29 1.302320e-014
Cn8an16a16 TDn8a31 TDn16a31 1.302320e-014
Cn8an16a17 TDn8a33 TDn16a33 1.690880e-014
Cn8an17a1 TDn8a1 TDn17a1 1.690880e-014
Cn8an17a2 TDn8a3 TDn17a3 1.302320e-014
Cn8an17a3 TDn8a5 TDn17a5 1.302320e-014
Cn8an17a4 TDn8a7 TDn17a7 1.302320e-014
Cn8an17a5 TDn8a9 TDn17a9 1.302320e-014
Cn8an17a6 TDn8a11 TDn17a11 1.302320e-014
Cn8an17a7 TDn8a13 TDn17a13 1.302320e-014
Cn8an17a8 TDn8a15 TDn17a15 1.302320e-014
Cn8an17a9 TDn8a17 TDn17a17 1.302320e-014
Cn8an17a10 TDn8a19 TDn17a19 1.302320e-014
Cn8an17a11 TDn8a21 TDn17a21 1.302320e-014
Cn8an17a12 TDn8a23 TDn17a23 1.302320e-014
Cn8an17a13 TDn8a25 TDn17a25 1.302320e-014
Cn8an17a14 TDn8a27 TDn17a27 1.302320e-014
Cn8an17a15 TDn8a29 TDn17a29 1.302320e-014
Cn8an17a16 TDn8a31 TDn17a31 1.302320e-014
Cn8an17a17 TDn8a33 TDn17a33 1.690880e-014
Cn8an18a1 TDn8a1 TDn18a1 1.690880e-014
Cn8an18a2 TDn8a3 TDn18a3 1.302320e-014
Cn8an18a3 TDn8a5 TDn18a5 1.302320e-014
Cn8an18a4 TDn8a7 TDn18a7 1.302320e-014
Cn8an18a5 TDn8a9 TDn18a9 1.302320e-014
Cn8an18a6 TDn8a11 TDn18a11 1.302320e-014
Cn8an18a7 TDn8a13 TDn18a13 1.302320e-014
Cn8an18a8 TDn8a15 TDn18a15 1.302320e-014
Cn8an18a9 TDn8a17 TDn18a17 1.302320e-014
Cn8an18a10 TDn8a19 TDn18a19 1.302320e-014
Cn8an18a11 TDn8a21 TDn18a21 1.302320e-014
Cn8an18a12 TDn8a23 TDn18a23 1.302320e-014
Cn8an18a13 TDn8a25 TDn18a25 1.302320e-014
Cn8an18a14 TDn8a27 TDn18a27 1.302320e-014
Cn8an18a15 TDn8a29 TDn18a29 1.302320e-014
Cn8an18a16 TDn8a31 TDn18a31 1.302320e-014
Cn8an18a17 TDn8a33 TDn18a33 1.690880e-014
Cn8an19a1 TDn8a1 TDn19a1 1.690880e-014
Cn8an19a2 TDn8a3 TDn19a3 1.302320e-014
Cn8an19a3 TDn8a5 TDn19a5 1.302320e-014
Cn8an19a4 TDn8a7 TDn19a7 1.302320e-014
Cn8an19a5 TDn8a9 TDn19a9 1.302320e-014
Cn8an19a6 TDn8a11 TDn19a11 1.302320e-014
Cn8an19a7 TDn8a13 TDn19a13 1.302320e-014
Cn8an19a8 TDn8a15 TDn19a15 1.302320e-014
Cn8an19a9 TDn8a17 TDn19a17 1.302320e-014
Cn8an19a10 TDn8a19 TDn19a19 1.302320e-014
Cn8an19a11 TDn8a21 TDn19a21 1.302320e-014
Cn8an19a12 TDn8a23 TDn19a23 1.302320e-014
Cn8an19a13 TDn8a25 TDn19a25 1.302320e-014
Cn8an19a14 TDn8a27 TDn19a27 1.302320e-014
Cn8an19a15 TDn8a29 TDn19a29 1.302320e-014
Cn8an19a16 TDn8a31 TDn19a31 1.302320e-014
Cn8an19a17 TDn8a33 TDn19a33 1.690880e-014
Cn8an20a1 TDn8a1 TDn20a1 1.690880e-014
Cn8an20a2 TDn8a3 TDn20a3 1.302320e-014
Cn8an20a3 TDn8a5 TDn20a5 1.302320e-014
Cn8an20a4 TDn8a7 TDn20a7 1.302320e-014
Cn8an20a5 TDn8a9 TDn20a9 1.302320e-014
Cn8an20a6 TDn8a11 TDn20a11 1.302320e-014
Cn8an20a7 TDn8a13 TDn20a13 1.302320e-014
Cn8an20a8 TDn8a15 TDn20a15 1.302320e-014
Cn8an20a9 TDn8a17 TDn20a17 1.302320e-014
Cn8an20a10 TDn8a19 TDn20a19 1.302320e-014
Cn8an20a11 TDn8a21 TDn20a21 1.302320e-014
Cn8an20a12 TDn8a23 TDn20a23 1.302320e-014
Cn8an20a13 TDn8a25 TDn20a25 1.302320e-014
Cn8an20a14 TDn8a27 TDn20a27 1.302320e-014
Cn8an20a15 TDn8a29 TDn20a29 1.302320e-014
Cn8an20a16 TDn8a31 TDn20a31 1.302320e-014
Cn8an20a17 TDn8a33 TDn20a33 1.690880e-014
Cn8an21a1 TDn8a1 TDn21a1 1.690880e-014
Cn8an21a2 TDn8a3 TDn21a3 1.302320e-014
Cn8an21a3 TDn8a5 TDn21a5 1.302320e-014
Cn8an21a4 TDn8a7 TDn21a7 1.302320e-014
Cn8an21a5 TDn8a9 TDn21a9 1.302320e-014
Cn8an21a6 TDn8a11 TDn21a11 1.302320e-014
Cn8an21a7 TDn8a13 TDn21a13 1.302320e-014
Cn8an21a8 TDn8a15 TDn21a15 1.302320e-014
Cn8an21a9 TDn8a17 TDn21a17 1.302320e-014
Cn8an21a10 TDn8a19 TDn21a19 1.302320e-014
Cn8an21a11 TDn8a21 TDn21a21 1.302320e-014
Cn8an21a12 TDn8a23 TDn21a23 1.302320e-014
Cn8an21a13 TDn8a25 TDn21a25 1.302320e-014
Cn8an21a14 TDn8a27 TDn21a27 1.302320e-014
Cn8an21a15 TDn8a29 TDn21a29 1.302320e-014
Cn8an21a16 TDn8a31 TDn21a31 1.302320e-014
Cn8an21a17 TDn8a33 TDn21a33 1.690880e-014
Cn8an22a1 TDn8a1 TDn22a1 1.690880e-014
Cn8an22a2 TDn8a3 TDn22a3 1.302320e-014
Cn8an22a3 TDn8a5 TDn22a5 1.302320e-014
Cn8an22a4 TDn8a7 TDn22a7 1.302320e-014
Cn8an22a5 TDn8a9 TDn22a9 1.302320e-014
Cn8an22a6 TDn8a11 TDn22a11 1.302320e-014
Cn8an22a7 TDn8a13 TDn22a13 1.302320e-014
Cn8an22a8 TDn8a15 TDn22a15 1.302320e-014
Cn8an22a9 TDn8a17 TDn22a17 1.302320e-014
Cn8an22a10 TDn8a19 TDn22a19 1.302320e-014
Cn8an22a11 TDn8a21 TDn22a21 1.302320e-014
Cn8an22a12 TDn8a23 TDn22a23 1.302320e-014
Cn8an22a13 TDn8a25 TDn22a25 1.302320e-014
Cn8an22a14 TDn8a27 TDn22a27 1.302320e-014
Cn8an22a15 TDn8a29 TDn22a29 1.302320e-014
Cn8an22a16 TDn8a31 TDn22a31 1.302320e-014
Cn8an22a17 TDn8a33 TDn22a33 1.690880e-014
Cn8an23a1 TDn8a1 TDn23a1 1.690880e-014
Cn8an23a2 TDn8a3 TDn23a3 1.302320e-014
Cn8an23a3 TDn8a5 TDn23a5 1.302320e-014
Cn8an23a4 TDn8a7 TDn23a7 1.302320e-014
Cn8an23a5 TDn8a9 TDn23a9 1.302320e-014
Cn8an23a6 TDn8a11 TDn23a11 1.302320e-014
Cn8an23a7 TDn8a13 TDn23a13 1.302320e-014
Cn8an23a8 TDn8a15 TDn23a15 1.302320e-014
Cn8an23a9 TDn8a17 TDn23a17 1.302320e-014
Cn8an23a10 TDn8a19 TDn23a19 1.302320e-014
Cn8an23a11 TDn8a21 TDn23a21 1.302320e-014
Cn8an23a12 TDn8a23 TDn23a23 1.302320e-014
Cn8an23a13 TDn8a25 TDn23a25 1.302320e-014
Cn8an23a14 TDn8a27 TDn23a27 1.302320e-014
Cn8an23a15 TDn8a29 TDn23a29 1.302320e-014
Cn8an23a16 TDn8a31 TDn23a31 1.302320e-014
Cn8an23a17 TDn8a33 TDn23a33 1.690880e-014
Cn8an24a1 TDn8a1 TDn24a1 1.690880e-014
Cn8an24a2 TDn8a3 TDn24a3 1.302320e-014
Cn8an24a3 TDn8a5 TDn24a5 1.302320e-014
Cn8an24a4 TDn8a7 TDn24a7 1.302320e-014
Cn8an24a5 TDn8a9 TDn24a9 1.302320e-014
Cn8an24a6 TDn8a11 TDn24a11 1.302320e-014
Cn8an24a7 TDn8a13 TDn24a13 1.302320e-014
Cn8an24a8 TDn8a15 TDn24a15 1.302320e-014
Cn8an24a9 TDn8a17 TDn24a17 1.302320e-014
Cn8an24a10 TDn8a19 TDn24a19 1.302320e-014
Cn8an24a11 TDn8a21 TDn24a21 1.302320e-014
Cn8an24a12 TDn8a23 TDn24a23 1.302320e-014
Cn8an24a13 TDn8a25 TDn24a25 1.302320e-014
Cn8an24a14 TDn8a27 TDn24a27 1.302320e-014
Cn8an24a15 TDn8a29 TDn24a29 1.302320e-014
Cn8an24a16 TDn8a31 TDn24a31 1.302320e-014
Cn8an24a17 TDn8a33 TDn24a33 1.690880e-014
Cn8an25a1 TDn8a1 TDn25a1 1.690880e-014
Cn8an25a2 TDn8a3 TDn25a3 1.302320e-014
Cn8an25a3 TDn8a5 TDn25a5 1.302320e-014
Cn8an25a4 TDn8a7 TDn25a7 1.302320e-014
Cn8an25a5 TDn8a9 TDn25a9 1.302320e-014
Cn8an25a6 TDn8a11 TDn25a11 1.302320e-014
Cn8an25a7 TDn8a13 TDn25a13 1.302320e-014
Cn8an25a8 TDn8a15 TDn25a15 1.302320e-014
Cn8an25a9 TDn8a17 TDn25a17 1.302320e-014
Cn8an25a10 TDn8a19 TDn25a19 1.302320e-014
Cn8an25a11 TDn8a21 TDn25a21 1.302320e-014
Cn8an25a12 TDn8a23 TDn25a23 1.302320e-014
Cn8an25a13 TDn8a25 TDn25a25 1.302320e-014
Cn8an25a14 TDn8a27 TDn25a27 1.302320e-014
Cn8an25a15 TDn8a29 TDn25a29 1.302320e-014
Cn8an25a16 TDn8a31 TDn25a31 1.302320e-014
Cn8an25a17 TDn8a33 TDn25a33 1.690880e-014
Cn8an26a1 TDn8a1 TDn26a1 1.690880e-014
Cn8an26a2 TDn8a3 TDn26a3 1.302320e-014
Cn8an26a3 TDn8a5 TDn26a5 1.302320e-014
Cn8an26a4 TDn8a7 TDn26a7 1.302320e-014
Cn8an26a5 TDn8a9 TDn26a9 1.302320e-014
Cn8an26a6 TDn8a11 TDn26a11 1.302320e-014
Cn8an26a7 TDn8a13 TDn26a13 1.302320e-014
Cn8an26a8 TDn8a15 TDn26a15 1.302320e-014
Cn8an26a9 TDn8a17 TDn26a17 1.302320e-014
Cn8an26a10 TDn8a19 TDn26a19 1.302320e-014
Cn8an26a11 TDn8a21 TDn26a21 1.302320e-014
Cn8an26a12 TDn8a23 TDn26a23 1.302320e-014
Cn8an26a13 TDn8a25 TDn26a25 1.302320e-014
Cn8an26a14 TDn8a27 TDn26a27 1.302320e-014
Cn8an26a15 TDn8a29 TDn26a29 1.302320e-014
Cn8an26a16 TDn8a31 TDn26a31 1.302320e-014
Cn8an26a17 TDn8a33 TDn26a33 1.690880e-014
Cn8an27a1 TDn8a1 TDn27a1 1.690880e-014
Cn8an27a2 TDn8a3 TDn27a3 1.302320e-014
Cn8an27a3 TDn8a5 TDn27a5 1.302320e-014
Cn8an27a4 TDn8a7 TDn27a7 1.302320e-014
Cn8an27a5 TDn8a9 TDn27a9 1.302320e-014
Cn8an27a6 TDn8a11 TDn27a11 1.302320e-014
Cn8an27a7 TDn8a13 TDn27a13 1.302320e-014
Cn8an27a8 TDn8a15 TDn27a15 1.302320e-014
Cn8an27a9 TDn8a17 TDn27a17 1.302320e-014
Cn8an27a10 TDn8a19 TDn27a19 1.302320e-014
Cn8an27a11 TDn8a21 TDn27a21 1.302320e-014
Cn8an27a12 TDn8a23 TDn27a23 1.302320e-014
Cn8an27a13 TDn8a25 TDn27a25 1.302320e-014
Cn8an27a14 TDn8a27 TDn27a27 1.302320e-014
Cn8an27a15 TDn8a29 TDn27a29 1.302320e-014
Cn8an27a16 TDn8a31 TDn27a31 1.302320e-014
Cn8an27a17 TDn8a33 TDn27a33 1.690880e-014
Cn8an28a1 TDn8a1 TDn28a1 1.690880e-014
Cn8an28a2 TDn8a3 TDn28a3 1.302320e-014
Cn8an28a3 TDn8a5 TDn28a5 1.302320e-014
Cn8an28a4 TDn8a7 TDn28a7 1.302320e-014
Cn8an28a5 TDn8a9 TDn28a9 1.302320e-014
Cn8an28a6 TDn8a11 TDn28a11 1.302320e-014
Cn8an28a7 TDn8a13 TDn28a13 1.302320e-014
Cn8an28a8 TDn8a15 TDn28a15 1.302320e-014
Cn8an28a9 TDn8a17 TDn28a17 1.302320e-014
Cn8an28a10 TDn8a19 TDn28a19 1.302320e-014
Cn8an28a11 TDn8a21 TDn28a21 1.302320e-014
Cn8an28a12 TDn8a23 TDn28a23 1.302320e-014
Cn8an28a13 TDn8a25 TDn28a25 1.302320e-014
Cn8an28a14 TDn8a27 TDn28a27 1.302320e-014
Cn8an28a15 TDn8a29 TDn28a29 1.302320e-014
Cn8an28a16 TDn8a31 TDn28a31 1.302320e-014
Cn8an28a17 TDn8a33 TDn28a33 1.690880e-014
Cn8an29a1 TDn8a1 TDn29a1 1.690880e-014
Cn8an29a2 TDn8a3 TDn29a3 1.302320e-014
Cn8an29a3 TDn8a5 TDn29a5 1.302320e-014
Cn8an29a4 TDn8a7 TDn29a7 1.302320e-014
Cn8an29a5 TDn8a9 TDn29a9 1.302320e-014
Cn8an29a6 TDn8a11 TDn29a11 1.302320e-014
Cn8an29a7 TDn8a13 TDn29a13 1.302320e-014
Cn8an29a8 TDn8a15 TDn29a15 1.302320e-014
Cn8an29a9 TDn8a17 TDn29a17 1.302320e-014
Cn8an29a10 TDn8a19 TDn29a19 1.302320e-014
Cn8an29a11 TDn8a21 TDn29a21 1.302320e-014
Cn8an29a12 TDn8a23 TDn29a23 1.302320e-014
Cn8an29a13 TDn8a25 TDn29a25 1.302320e-014
Cn8an29a14 TDn8a27 TDn29a27 1.302320e-014
Cn8an29a15 TDn8a29 TDn29a29 1.302320e-014
Cn8an29a16 TDn8a31 TDn29a31 1.302320e-014
Cn8an29a17 TDn8a33 TDn29a33 1.690880e-014
Cn8an30a1 TDn8a1 TDn30a1 1.690880e-014
Cn8an30a2 TDn8a3 TDn30a3 1.302320e-014
Cn8an30a3 TDn8a5 TDn30a5 1.302320e-014
Cn8an30a4 TDn8a7 TDn30a7 1.302320e-014
Cn8an30a5 TDn8a9 TDn30a9 1.302320e-014
Cn8an30a6 TDn8a11 TDn30a11 1.302320e-014
Cn8an30a7 TDn8a13 TDn30a13 1.302320e-014
Cn8an30a8 TDn8a15 TDn30a15 1.302320e-014
Cn8an30a9 TDn8a17 TDn30a17 1.302320e-014
Cn8an30a10 TDn8a19 TDn30a19 1.302320e-014
Cn8an30a11 TDn8a21 TDn30a21 1.302320e-014
Cn8an30a12 TDn8a23 TDn30a23 1.302320e-014
Cn8an30a13 TDn8a25 TDn30a25 1.302320e-014
Cn8an30a14 TDn8a27 TDn30a27 1.302320e-014
Cn8an30a15 TDn8a29 TDn30a29 1.302320e-014
Cn8an30a16 TDn8a31 TDn30a31 1.302320e-014
Cn8an30a17 TDn8a33 TDn30a33 1.690880e-014
Cn8an31a1 TDn8a1 TDn31a1 1.690880e-014
Cn8an31a2 TDn8a3 TDn31a3 1.302320e-014
Cn8an31a3 TDn8a5 TDn31a5 1.302320e-014
Cn8an31a4 TDn8a7 TDn31a7 1.302320e-014
Cn8an31a5 TDn8a9 TDn31a9 1.302320e-014
Cn8an31a6 TDn8a11 TDn31a11 1.302320e-014
Cn8an31a7 TDn8a13 TDn31a13 1.302320e-014
Cn8an31a8 TDn8a15 TDn31a15 1.302320e-014
Cn8an31a9 TDn8a17 TDn31a17 1.302320e-014
Cn8an31a10 TDn8a19 TDn31a19 1.302320e-014
Cn8an31a11 TDn8a21 TDn31a21 1.302320e-014
Cn8an31a12 TDn8a23 TDn31a23 1.302320e-014
Cn8an31a13 TDn8a25 TDn31a25 1.302320e-014
Cn8an31a14 TDn8a27 TDn31a27 1.302320e-014
Cn8an31a15 TDn8a29 TDn31a29 1.302320e-014
Cn8an31a16 TDn8a31 TDn31a31 1.302320e-014
Cn8an31a17 TDn8a33 TDn31a33 1.690880e-014
Cn8an32a1 TDn8a1 TDn32a1 1.690880e-014
Cn8an32a2 TDn8a3 TDn32a3 1.302320e-014
Cn8an32a3 TDn8a5 TDn32a5 1.302320e-014
Cn8an32a4 TDn8a7 TDn32a7 1.302320e-014
Cn8an32a5 TDn8a9 TDn32a9 1.302320e-014
Cn8an32a6 TDn8a11 TDn32a11 1.302320e-014
Cn8an32a7 TDn8a13 TDn32a13 1.302320e-014
Cn8an32a8 TDn8a15 TDn32a15 1.302320e-014
Cn8an32a9 TDn8a17 TDn32a17 1.302320e-014
Cn8an32a10 TDn8a19 TDn32a19 1.302320e-014
Cn8an32a11 TDn8a21 TDn32a21 1.302320e-014
Cn8an32a12 TDn8a23 TDn32a23 1.302320e-014
Cn8an32a13 TDn8a25 TDn32a25 1.302320e-014
Cn8an32a14 TDn8a27 TDn32a27 1.302320e-014
Cn8an32a15 TDn8a29 TDn32a29 1.302320e-014
Cn8an32a16 TDn8a31 TDn32a31 1.302320e-014
Cn8an32a17 TDn8a33 TDn32a33 1.690880e-014
Cn8anva1 TDn8a1 TDnva1 1.690880e-014
Cn8anva2 TDn8a3 TDnva3 1.690880e-014
Cn8anva3 TDn8a5 TDnva5 1.690880e-014
Cn8anva4 TDn8a7 TDnva7 1.690880e-014
Cn8anva5 TDn8a9 TDnva9 1.690880e-014
Cn8anva6 TDn8a11 TDnva11 1.690880e-014
Cn8anva7 TDn8a13 TDnva13 1.690880e-014
Cn8anva8 TDn8a15 TDnva15 1.690880e-014
Cn8anva9 TDn8a17 TDnva17 1.690880e-014
Cn8anva10 TDn8a19 TDnva19 1.690880e-014
Cn8anva11 TDn8a21 TDnva21 1.690880e-014
Cn8anva12 TDn8a23 TDnva23 1.690880e-014
Cn8anva13 TDn8a25 TDnva25 1.690880e-014
Cn8anva14 TDn8a27 TDnva27 1.690880e-014
Cn8anva15 TDn8a29 TDnva29 1.690880e-014
Cn8anva16 TDn8a31 TDnva31 1.690880e-014
Cn8anva17 TDn8a33 TDnva33 1.690880e-014
Cn9an10a1 TDn9a1 TDn10a1 1.690880e-014
Cn9an10a2 TDn9a3 TDn10a3 1.302320e-014
Cn9an10a3 TDn9a5 TDn10a5 1.302320e-014
Cn9an10a4 TDn9a7 TDn10a7 1.302320e-014
Cn9an10a5 TDn9a9 TDn10a9 1.302320e-014
Cn9an10a6 TDn9a11 TDn10a11 1.302320e-014
Cn9an10a7 TDn9a13 TDn10a13 1.302320e-014
Cn9an10a8 TDn9a15 TDn10a15 1.302320e-014
Cn9an10a9 TDn9a17 TDn10a17 1.302320e-014
Cn9an10a10 TDn9a19 TDn10a19 1.302320e-014
Cn9an10a11 TDn9a21 TDn10a21 1.302320e-014
Cn9an10a12 TDn9a23 TDn10a23 1.302320e-014
Cn9an10a13 TDn9a25 TDn10a25 1.302320e-014
Cn9an10a14 TDn9a27 TDn10a27 1.302320e-014
Cn9an10a15 TDn9a29 TDn10a29 1.302320e-014
Cn9an10a16 TDn9a31 TDn10a31 1.302320e-014
Cn9an10a17 TDn9a33 TDn10a33 1.690880e-014
Cn9an11a1 TDn9a1 TDn11a1 1.690880e-014
Cn9an11a2 TDn9a3 TDn11a3 1.302320e-014
Cn9an11a3 TDn9a5 TDn11a5 1.302320e-014
Cn9an11a4 TDn9a7 TDn11a7 1.302320e-014
Cn9an11a5 TDn9a9 TDn11a9 1.302320e-014
Cn9an11a6 TDn9a11 TDn11a11 1.302320e-014
Cn9an11a7 TDn9a13 TDn11a13 1.302320e-014
Cn9an11a8 TDn9a15 TDn11a15 1.302320e-014
Cn9an11a9 TDn9a17 TDn11a17 1.302320e-014
Cn9an11a10 TDn9a19 TDn11a19 1.302320e-014
Cn9an11a11 TDn9a21 TDn11a21 1.302320e-014
Cn9an11a12 TDn9a23 TDn11a23 1.302320e-014
Cn9an11a13 TDn9a25 TDn11a25 1.302320e-014
Cn9an11a14 TDn9a27 TDn11a27 1.302320e-014
Cn9an11a15 TDn9a29 TDn11a29 1.302320e-014
Cn9an11a16 TDn9a31 TDn11a31 1.302320e-014
Cn9an11a17 TDn9a33 TDn11a33 1.690880e-014
Cn9an12a1 TDn9a1 TDn12a1 1.690880e-014
Cn9an12a2 TDn9a3 TDn12a3 1.302320e-014
Cn9an12a3 TDn9a5 TDn12a5 1.302320e-014
Cn9an12a4 TDn9a7 TDn12a7 1.302320e-014
Cn9an12a5 TDn9a9 TDn12a9 1.302320e-014
Cn9an12a6 TDn9a11 TDn12a11 1.302320e-014
Cn9an12a7 TDn9a13 TDn12a13 1.302320e-014
Cn9an12a8 TDn9a15 TDn12a15 1.302320e-014
Cn9an12a9 TDn9a17 TDn12a17 1.302320e-014
Cn9an12a10 TDn9a19 TDn12a19 1.302320e-014
Cn9an12a11 TDn9a21 TDn12a21 1.302320e-014
Cn9an12a12 TDn9a23 TDn12a23 1.302320e-014
Cn9an12a13 TDn9a25 TDn12a25 1.302320e-014
Cn9an12a14 TDn9a27 TDn12a27 1.302320e-014
Cn9an12a15 TDn9a29 TDn12a29 1.302320e-014
Cn9an12a16 TDn9a31 TDn12a31 1.302320e-014
Cn9an12a17 TDn9a33 TDn12a33 1.690880e-014
Cn9an13a1 TDn9a1 TDn13a1 1.690880e-014
Cn9an13a2 TDn9a3 TDn13a3 1.302320e-014
Cn9an13a3 TDn9a5 TDn13a5 1.302320e-014
Cn9an13a4 TDn9a7 TDn13a7 1.302320e-014
Cn9an13a5 TDn9a9 TDn13a9 1.302320e-014
Cn9an13a6 TDn9a11 TDn13a11 1.302320e-014
Cn9an13a7 TDn9a13 TDn13a13 1.302320e-014
Cn9an13a8 TDn9a15 TDn13a15 1.302320e-014
Cn9an13a9 TDn9a17 TDn13a17 1.302320e-014
Cn9an13a10 TDn9a19 TDn13a19 1.302320e-014
Cn9an13a11 TDn9a21 TDn13a21 1.302320e-014
Cn9an13a12 TDn9a23 TDn13a23 1.302320e-014
Cn9an13a13 TDn9a25 TDn13a25 1.302320e-014
Cn9an13a14 TDn9a27 TDn13a27 1.302320e-014
Cn9an13a15 TDn9a29 TDn13a29 1.302320e-014
Cn9an13a16 TDn9a31 TDn13a31 1.302320e-014
Cn9an13a17 TDn9a33 TDn13a33 1.690880e-014
Cn9an14a1 TDn9a1 TDn14a1 1.690880e-014
Cn9an14a2 TDn9a3 TDn14a3 1.302320e-014
Cn9an14a3 TDn9a5 TDn14a5 1.302320e-014
Cn9an14a4 TDn9a7 TDn14a7 1.302320e-014
Cn9an14a5 TDn9a9 TDn14a9 1.302320e-014
Cn9an14a6 TDn9a11 TDn14a11 1.302320e-014
Cn9an14a7 TDn9a13 TDn14a13 1.302320e-014
Cn9an14a8 TDn9a15 TDn14a15 1.302320e-014
Cn9an14a9 TDn9a17 TDn14a17 1.302320e-014
Cn9an14a10 TDn9a19 TDn14a19 1.302320e-014
Cn9an14a11 TDn9a21 TDn14a21 1.302320e-014
Cn9an14a12 TDn9a23 TDn14a23 1.302320e-014
Cn9an14a13 TDn9a25 TDn14a25 1.302320e-014
Cn9an14a14 TDn9a27 TDn14a27 1.302320e-014
Cn9an14a15 TDn9a29 TDn14a29 1.302320e-014
Cn9an14a16 TDn9a31 TDn14a31 1.302320e-014
Cn9an14a17 TDn9a33 TDn14a33 1.690880e-014
Cn9an15a1 TDn9a1 TDn15a1 1.690880e-014
Cn9an15a2 TDn9a3 TDn15a3 1.302320e-014
Cn9an15a3 TDn9a5 TDn15a5 1.302320e-014
Cn9an15a4 TDn9a7 TDn15a7 1.302320e-014
Cn9an15a5 TDn9a9 TDn15a9 1.302320e-014
Cn9an15a6 TDn9a11 TDn15a11 1.302320e-014
Cn9an15a7 TDn9a13 TDn15a13 1.302320e-014
Cn9an15a8 TDn9a15 TDn15a15 1.302320e-014
Cn9an15a9 TDn9a17 TDn15a17 1.302320e-014
Cn9an15a10 TDn9a19 TDn15a19 1.302320e-014
Cn9an15a11 TDn9a21 TDn15a21 1.302320e-014
Cn9an15a12 TDn9a23 TDn15a23 1.302320e-014
Cn9an15a13 TDn9a25 TDn15a25 1.302320e-014
Cn9an15a14 TDn9a27 TDn15a27 1.302320e-014
Cn9an15a15 TDn9a29 TDn15a29 1.302320e-014
Cn9an15a16 TDn9a31 TDn15a31 1.302320e-014
Cn9an15a17 TDn9a33 TDn15a33 1.690880e-014
Cn9an16a1 TDn9a1 TDn16a1 1.690880e-014
Cn9an16a2 TDn9a3 TDn16a3 1.302320e-014
Cn9an16a3 TDn9a5 TDn16a5 1.302320e-014
Cn9an16a4 TDn9a7 TDn16a7 1.302320e-014
Cn9an16a5 TDn9a9 TDn16a9 1.302320e-014
Cn9an16a6 TDn9a11 TDn16a11 1.302320e-014
Cn9an16a7 TDn9a13 TDn16a13 1.302320e-014
Cn9an16a8 TDn9a15 TDn16a15 1.302320e-014
Cn9an16a9 TDn9a17 TDn16a17 1.302320e-014
Cn9an16a10 TDn9a19 TDn16a19 1.302320e-014
Cn9an16a11 TDn9a21 TDn16a21 1.302320e-014
Cn9an16a12 TDn9a23 TDn16a23 1.302320e-014
Cn9an16a13 TDn9a25 TDn16a25 1.302320e-014
Cn9an16a14 TDn9a27 TDn16a27 1.302320e-014
Cn9an16a15 TDn9a29 TDn16a29 1.302320e-014
Cn9an16a16 TDn9a31 TDn16a31 1.302320e-014
Cn9an16a17 TDn9a33 TDn16a33 1.690880e-014
Cn9an17a1 TDn9a1 TDn17a1 1.690880e-014
Cn9an17a2 TDn9a3 TDn17a3 1.302320e-014
Cn9an17a3 TDn9a5 TDn17a5 1.302320e-014
Cn9an17a4 TDn9a7 TDn17a7 1.302320e-014
Cn9an17a5 TDn9a9 TDn17a9 1.302320e-014
Cn9an17a6 TDn9a11 TDn17a11 1.302320e-014
Cn9an17a7 TDn9a13 TDn17a13 1.302320e-014
Cn9an17a8 TDn9a15 TDn17a15 1.302320e-014
Cn9an17a9 TDn9a17 TDn17a17 1.302320e-014
Cn9an17a10 TDn9a19 TDn17a19 1.302320e-014
Cn9an17a11 TDn9a21 TDn17a21 1.302320e-014
Cn9an17a12 TDn9a23 TDn17a23 1.302320e-014
Cn9an17a13 TDn9a25 TDn17a25 1.302320e-014
Cn9an17a14 TDn9a27 TDn17a27 1.302320e-014
Cn9an17a15 TDn9a29 TDn17a29 1.302320e-014
Cn9an17a16 TDn9a31 TDn17a31 1.302320e-014
Cn9an17a17 TDn9a33 TDn17a33 1.690880e-014
Cn9an18a1 TDn9a1 TDn18a1 1.690880e-014
Cn9an18a2 TDn9a3 TDn18a3 1.302320e-014
Cn9an18a3 TDn9a5 TDn18a5 1.302320e-014
Cn9an18a4 TDn9a7 TDn18a7 1.302320e-014
Cn9an18a5 TDn9a9 TDn18a9 1.302320e-014
Cn9an18a6 TDn9a11 TDn18a11 1.302320e-014
Cn9an18a7 TDn9a13 TDn18a13 1.302320e-014
Cn9an18a8 TDn9a15 TDn18a15 1.302320e-014
Cn9an18a9 TDn9a17 TDn18a17 1.302320e-014
Cn9an18a10 TDn9a19 TDn18a19 1.302320e-014
Cn9an18a11 TDn9a21 TDn18a21 1.302320e-014
Cn9an18a12 TDn9a23 TDn18a23 1.302320e-014
Cn9an18a13 TDn9a25 TDn18a25 1.302320e-014
Cn9an18a14 TDn9a27 TDn18a27 1.302320e-014
Cn9an18a15 TDn9a29 TDn18a29 1.302320e-014
Cn9an18a16 TDn9a31 TDn18a31 1.302320e-014
Cn9an18a17 TDn9a33 TDn18a33 1.690880e-014
Cn9an19a1 TDn9a1 TDn19a1 1.690880e-014
Cn9an19a2 TDn9a3 TDn19a3 1.302320e-014
Cn9an19a3 TDn9a5 TDn19a5 1.302320e-014
Cn9an19a4 TDn9a7 TDn19a7 1.302320e-014
Cn9an19a5 TDn9a9 TDn19a9 1.302320e-014
Cn9an19a6 TDn9a11 TDn19a11 1.302320e-014
Cn9an19a7 TDn9a13 TDn19a13 1.302320e-014
Cn9an19a8 TDn9a15 TDn19a15 1.302320e-014
Cn9an19a9 TDn9a17 TDn19a17 1.302320e-014
Cn9an19a10 TDn9a19 TDn19a19 1.302320e-014
Cn9an19a11 TDn9a21 TDn19a21 1.302320e-014
Cn9an19a12 TDn9a23 TDn19a23 1.302320e-014
Cn9an19a13 TDn9a25 TDn19a25 1.302320e-014
Cn9an19a14 TDn9a27 TDn19a27 1.302320e-014
Cn9an19a15 TDn9a29 TDn19a29 1.302320e-014
Cn9an19a16 TDn9a31 TDn19a31 1.302320e-014
Cn9an19a17 TDn9a33 TDn19a33 1.690880e-014
Cn9an20a1 TDn9a1 TDn20a1 1.690880e-014
Cn9an20a2 TDn9a3 TDn20a3 1.302320e-014
Cn9an20a3 TDn9a5 TDn20a5 1.302320e-014
Cn9an20a4 TDn9a7 TDn20a7 1.302320e-014
Cn9an20a5 TDn9a9 TDn20a9 1.302320e-014
Cn9an20a6 TDn9a11 TDn20a11 1.302320e-014
Cn9an20a7 TDn9a13 TDn20a13 1.302320e-014
Cn9an20a8 TDn9a15 TDn20a15 1.302320e-014
Cn9an20a9 TDn9a17 TDn20a17 1.302320e-014
Cn9an20a10 TDn9a19 TDn20a19 1.302320e-014
Cn9an20a11 TDn9a21 TDn20a21 1.302320e-014
Cn9an20a12 TDn9a23 TDn20a23 1.302320e-014
Cn9an20a13 TDn9a25 TDn20a25 1.302320e-014
Cn9an20a14 TDn9a27 TDn20a27 1.302320e-014
Cn9an20a15 TDn9a29 TDn20a29 1.302320e-014
Cn9an20a16 TDn9a31 TDn20a31 1.302320e-014
Cn9an20a17 TDn9a33 TDn20a33 1.690880e-014
Cn9an21a1 TDn9a1 TDn21a1 1.690880e-014
Cn9an21a2 TDn9a3 TDn21a3 1.302320e-014
Cn9an21a3 TDn9a5 TDn21a5 1.302320e-014
Cn9an21a4 TDn9a7 TDn21a7 1.302320e-014
Cn9an21a5 TDn9a9 TDn21a9 1.302320e-014
Cn9an21a6 TDn9a11 TDn21a11 1.302320e-014
Cn9an21a7 TDn9a13 TDn21a13 1.302320e-014
Cn9an21a8 TDn9a15 TDn21a15 1.302320e-014
Cn9an21a9 TDn9a17 TDn21a17 1.302320e-014
Cn9an21a10 TDn9a19 TDn21a19 1.302320e-014
Cn9an21a11 TDn9a21 TDn21a21 1.302320e-014
Cn9an21a12 TDn9a23 TDn21a23 1.302320e-014
Cn9an21a13 TDn9a25 TDn21a25 1.302320e-014
Cn9an21a14 TDn9a27 TDn21a27 1.302320e-014
Cn9an21a15 TDn9a29 TDn21a29 1.302320e-014
Cn9an21a16 TDn9a31 TDn21a31 1.302320e-014
Cn9an21a17 TDn9a33 TDn21a33 1.690880e-014
Cn9an22a1 TDn9a1 TDn22a1 1.690880e-014
Cn9an22a2 TDn9a3 TDn22a3 1.302320e-014
Cn9an22a3 TDn9a5 TDn22a5 1.302320e-014
Cn9an22a4 TDn9a7 TDn22a7 1.302320e-014
Cn9an22a5 TDn9a9 TDn22a9 1.302320e-014
Cn9an22a6 TDn9a11 TDn22a11 1.302320e-014
Cn9an22a7 TDn9a13 TDn22a13 1.302320e-014
Cn9an22a8 TDn9a15 TDn22a15 1.302320e-014
Cn9an22a9 TDn9a17 TDn22a17 1.302320e-014
Cn9an22a10 TDn9a19 TDn22a19 1.302320e-014
Cn9an22a11 TDn9a21 TDn22a21 1.302320e-014
Cn9an22a12 TDn9a23 TDn22a23 1.302320e-014
Cn9an22a13 TDn9a25 TDn22a25 1.302320e-014
Cn9an22a14 TDn9a27 TDn22a27 1.302320e-014
Cn9an22a15 TDn9a29 TDn22a29 1.302320e-014
Cn9an22a16 TDn9a31 TDn22a31 1.302320e-014
Cn9an22a17 TDn9a33 TDn22a33 1.690880e-014
Cn9an23a1 TDn9a1 TDn23a1 1.690880e-014
Cn9an23a2 TDn9a3 TDn23a3 1.302320e-014
Cn9an23a3 TDn9a5 TDn23a5 1.302320e-014
Cn9an23a4 TDn9a7 TDn23a7 1.302320e-014
Cn9an23a5 TDn9a9 TDn23a9 1.302320e-014
Cn9an23a6 TDn9a11 TDn23a11 1.302320e-014
Cn9an23a7 TDn9a13 TDn23a13 1.302320e-014
Cn9an23a8 TDn9a15 TDn23a15 1.302320e-014
Cn9an23a9 TDn9a17 TDn23a17 1.302320e-014
Cn9an23a10 TDn9a19 TDn23a19 1.302320e-014
Cn9an23a11 TDn9a21 TDn23a21 1.302320e-014
Cn9an23a12 TDn9a23 TDn23a23 1.302320e-014
Cn9an23a13 TDn9a25 TDn23a25 1.302320e-014
Cn9an23a14 TDn9a27 TDn23a27 1.302320e-014
Cn9an23a15 TDn9a29 TDn23a29 1.302320e-014
Cn9an23a16 TDn9a31 TDn23a31 1.302320e-014
Cn9an23a17 TDn9a33 TDn23a33 1.690880e-014
Cn9an24a1 TDn9a1 TDn24a1 1.690880e-014
Cn9an24a2 TDn9a3 TDn24a3 1.302320e-014
Cn9an24a3 TDn9a5 TDn24a5 1.302320e-014
Cn9an24a4 TDn9a7 TDn24a7 1.302320e-014
Cn9an24a5 TDn9a9 TDn24a9 1.302320e-014
Cn9an24a6 TDn9a11 TDn24a11 1.302320e-014
Cn9an24a7 TDn9a13 TDn24a13 1.302320e-014
Cn9an24a8 TDn9a15 TDn24a15 1.302320e-014
Cn9an24a9 TDn9a17 TDn24a17 1.302320e-014
Cn9an24a10 TDn9a19 TDn24a19 1.302320e-014
Cn9an24a11 TDn9a21 TDn24a21 1.302320e-014
Cn9an24a12 TDn9a23 TDn24a23 1.302320e-014
Cn9an24a13 TDn9a25 TDn24a25 1.302320e-014
Cn9an24a14 TDn9a27 TDn24a27 1.302320e-014
Cn9an24a15 TDn9a29 TDn24a29 1.302320e-014
Cn9an24a16 TDn9a31 TDn24a31 1.302320e-014
Cn9an24a17 TDn9a33 TDn24a33 1.690880e-014
Cn9an25a1 TDn9a1 TDn25a1 1.690880e-014
Cn9an25a2 TDn9a3 TDn25a3 1.302320e-014
Cn9an25a3 TDn9a5 TDn25a5 1.302320e-014
Cn9an25a4 TDn9a7 TDn25a7 1.302320e-014
Cn9an25a5 TDn9a9 TDn25a9 1.302320e-014
Cn9an25a6 TDn9a11 TDn25a11 1.302320e-014
Cn9an25a7 TDn9a13 TDn25a13 1.302320e-014
Cn9an25a8 TDn9a15 TDn25a15 1.302320e-014
Cn9an25a9 TDn9a17 TDn25a17 1.302320e-014
Cn9an25a10 TDn9a19 TDn25a19 1.302320e-014
Cn9an25a11 TDn9a21 TDn25a21 1.302320e-014
Cn9an25a12 TDn9a23 TDn25a23 1.302320e-014
Cn9an25a13 TDn9a25 TDn25a25 1.302320e-014
Cn9an25a14 TDn9a27 TDn25a27 1.302320e-014
Cn9an25a15 TDn9a29 TDn25a29 1.302320e-014
Cn9an25a16 TDn9a31 TDn25a31 1.302320e-014
Cn9an25a17 TDn9a33 TDn25a33 1.690880e-014
Cn9an26a1 TDn9a1 TDn26a1 1.690880e-014
Cn9an26a2 TDn9a3 TDn26a3 1.302320e-014
Cn9an26a3 TDn9a5 TDn26a5 1.302320e-014
Cn9an26a4 TDn9a7 TDn26a7 1.302320e-014
Cn9an26a5 TDn9a9 TDn26a9 1.302320e-014
Cn9an26a6 TDn9a11 TDn26a11 1.302320e-014
Cn9an26a7 TDn9a13 TDn26a13 1.302320e-014
Cn9an26a8 TDn9a15 TDn26a15 1.302320e-014
Cn9an26a9 TDn9a17 TDn26a17 1.302320e-014
Cn9an26a10 TDn9a19 TDn26a19 1.302320e-014
Cn9an26a11 TDn9a21 TDn26a21 1.302320e-014
Cn9an26a12 TDn9a23 TDn26a23 1.302320e-014
Cn9an26a13 TDn9a25 TDn26a25 1.302320e-014
Cn9an26a14 TDn9a27 TDn26a27 1.302320e-014
Cn9an26a15 TDn9a29 TDn26a29 1.302320e-014
Cn9an26a16 TDn9a31 TDn26a31 1.302320e-014
Cn9an26a17 TDn9a33 TDn26a33 1.690880e-014
Cn9an27a1 TDn9a1 TDn27a1 1.690880e-014
Cn9an27a2 TDn9a3 TDn27a3 1.302320e-014
Cn9an27a3 TDn9a5 TDn27a5 1.302320e-014
Cn9an27a4 TDn9a7 TDn27a7 1.302320e-014
Cn9an27a5 TDn9a9 TDn27a9 1.302320e-014
Cn9an27a6 TDn9a11 TDn27a11 1.302320e-014
Cn9an27a7 TDn9a13 TDn27a13 1.302320e-014
Cn9an27a8 TDn9a15 TDn27a15 1.302320e-014
Cn9an27a9 TDn9a17 TDn27a17 1.302320e-014
Cn9an27a10 TDn9a19 TDn27a19 1.302320e-014
Cn9an27a11 TDn9a21 TDn27a21 1.302320e-014
Cn9an27a12 TDn9a23 TDn27a23 1.302320e-014
Cn9an27a13 TDn9a25 TDn27a25 1.302320e-014
Cn9an27a14 TDn9a27 TDn27a27 1.302320e-014
Cn9an27a15 TDn9a29 TDn27a29 1.302320e-014
Cn9an27a16 TDn9a31 TDn27a31 1.302320e-014
Cn9an27a17 TDn9a33 TDn27a33 1.690880e-014
Cn9an28a1 TDn9a1 TDn28a1 1.690880e-014
Cn9an28a2 TDn9a3 TDn28a3 1.302320e-014
Cn9an28a3 TDn9a5 TDn28a5 1.302320e-014
Cn9an28a4 TDn9a7 TDn28a7 1.302320e-014
Cn9an28a5 TDn9a9 TDn28a9 1.302320e-014
Cn9an28a6 TDn9a11 TDn28a11 1.302320e-014
Cn9an28a7 TDn9a13 TDn28a13 1.302320e-014
Cn9an28a8 TDn9a15 TDn28a15 1.302320e-014
Cn9an28a9 TDn9a17 TDn28a17 1.302320e-014
Cn9an28a10 TDn9a19 TDn28a19 1.302320e-014
Cn9an28a11 TDn9a21 TDn28a21 1.302320e-014
Cn9an28a12 TDn9a23 TDn28a23 1.302320e-014
Cn9an28a13 TDn9a25 TDn28a25 1.302320e-014
Cn9an28a14 TDn9a27 TDn28a27 1.302320e-014
Cn9an28a15 TDn9a29 TDn28a29 1.302320e-014
Cn9an28a16 TDn9a31 TDn28a31 1.302320e-014
Cn9an28a17 TDn9a33 TDn28a33 1.690880e-014
Cn9an29a1 TDn9a1 TDn29a1 1.690880e-014
Cn9an29a2 TDn9a3 TDn29a3 1.302320e-014
Cn9an29a3 TDn9a5 TDn29a5 1.302320e-014
Cn9an29a4 TDn9a7 TDn29a7 1.302320e-014
Cn9an29a5 TDn9a9 TDn29a9 1.302320e-014
Cn9an29a6 TDn9a11 TDn29a11 1.302320e-014
Cn9an29a7 TDn9a13 TDn29a13 1.302320e-014
Cn9an29a8 TDn9a15 TDn29a15 1.302320e-014
Cn9an29a9 TDn9a17 TDn29a17 1.302320e-014
Cn9an29a10 TDn9a19 TDn29a19 1.302320e-014
Cn9an29a11 TDn9a21 TDn29a21 1.302320e-014
Cn9an29a12 TDn9a23 TDn29a23 1.302320e-014
Cn9an29a13 TDn9a25 TDn29a25 1.302320e-014
Cn9an29a14 TDn9a27 TDn29a27 1.302320e-014
Cn9an29a15 TDn9a29 TDn29a29 1.302320e-014
Cn9an29a16 TDn9a31 TDn29a31 1.302320e-014
Cn9an29a17 TDn9a33 TDn29a33 1.690880e-014
Cn9an30a1 TDn9a1 TDn30a1 1.690880e-014
Cn9an30a2 TDn9a3 TDn30a3 1.302320e-014
Cn9an30a3 TDn9a5 TDn30a5 1.302320e-014
Cn9an30a4 TDn9a7 TDn30a7 1.302320e-014
Cn9an30a5 TDn9a9 TDn30a9 1.302320e-014
Cn9an30a6 TDn9a11 TDn30a11 1.302320e-014
Cn9an30a7 TDn9a13 TDn30a13 1.302320e-014
Cn9an30a8 TDn9a15 TDn30a15 1.302320e-014
Cn9an30a9 TDn9a17 TDn30a17 1.302320e-014
Cn9an30a10 TDn9a19 TDn30a19 1.302320e-014
Cn9an30a11 TDn9a21 TDn30a21 1.302320e-014
Cn9an30a12 TDn9a23 TDn30a23 1.302320e-014
Cn9an30a13 TDn9a25 TDn30a25 1.302320e-014
Cn9an30a14 TDn9a27 TDn30a27 1.302320e-014
Cn9an30a15 TDn9a29 TDn30a29 1.302320e-014
Cn9an30a16 TDn9a31 TDn30a31 1.302320e-014
Cn9an30a17 TDn9a33 TDn30a33 1.690880e-014
Cn9an31a1 TDn9a1 TDn31a1 1.690880e-014
Cn9an31a2 TDn9a3 TDn31a3 1.302320e-014
Cn9an31a3 TDn9a5 TDn31a5 1.302320e-014
Cn9an31a4 TDn9a7 TDn31a7 1.302320e-014
Cn9an31a5 TDn9a9 TDn31a9 1.302320e-014
Cn9an31a6 TDn9a11 TDn31a11 1.302320e-014
Cn9an31a7 TDn9a13 TDn31a13 1.302320e-014
Cn9an31a8 TDn9a15 TDn31a15 1.302320e-014
Cn9an31a9 TDn9a17 TDn31a17 1.302320e-014
Cn9an31a10 TDn9a19 TDn31a19 1.302320e-014
Cn9an31a11 TDn9a21 TDn31a21 1.302320e-014
Cn9an31a12 TDn9a23 TDn31a23 1.302320e-014
Cn9an31a13 TDn9a25 TDn31a25 1.302320e-014
Cn9an31a14 TDn9a27 TDn31a27 1.302320e-014
Cn9an31a15 TDn9a29 TDn31a29 1.302320e-014
Cn9an31a16 TDn9a31 TDn31a31 1.302320e-014
Cn9an31a17 TDn9a33 TDn31a33 1.690880e-014
Cn9an32a1 TDn9a1 TDn32a1 1.690880e-014
Cn9an32a2 TDn9a3 TDn32a3 1.302320e-014
Cn9an32a3 TDn9a5 TDn32a5 1.302320e-014
Cn9an32a4 TDn9a7 TDn32a7 1.302320e-014
Cn9an32a5 TDn9a9 TDn32a9 1.302320e-014
Cn9an32a6 TDn9a11 TDn32a11 1.302320e-014
Cn9an32a7 TDn9a13 TDn32a13 1.302320e-014
Cn9an32a8 TDn9a15 TDn32a15 1.302320e-014
Cn9an32a9 TDn9a17 TDn32a17 1.302320e-014
Cn9an32a10 TDn9a19 TDn32a19 1.302320e-014
Cn9an32a11 TDn9a21 TDn32a21 1.302320e-014
Cn9an32a12 TDn9a23 TDn32a23 1.302320e-014
Cn9an32a13 TDn9a25 TDn32a25 1.302320e-014
Cn9an32a14 TDn9a27 TDn32a27 1.302320e-014
Cn9an32a15 TDn9a29 TDn32a29 1.302320e-014
Cn9an32a16 TDn9a31 TDn32a31 1.302320e-014
Cn9an32a17 TDn9a33 TDn32a33 1.690880e-014
Cn9anva1 TDn9a1 TDnva1 1.690880e-014
Cn9anva2 TDn9a3 TDnva3 1.690880e-014
Cn9anva3 TDn9a5 TDnva5 1.690880e-014
Cn9anva4 TDn9a7 TDnva7 1.690880e-014
Cn9anva5 TDn9a9 TDnva9 1.690880e-014
Cn9anva6 TDn9a11 TDnva11 1.690880e-014
Cn9anva7 TDn9a13 TDnva13 1.690880e-014
Cn9anva8 TDn9a15 TDnva15 1.690880e-014
Cn9anva9 TDn9a17 TDnva17 1.690880e-014
Cn9anva10 TDn9a19 TDnva19 1.690880e-014
Cn9anva11 TDn9a21 TDnva21 1.690880e-014
Cn9anva12 TDn9a23 TDnva23 1.690880e-014
Cn9anva13 TDn9a25 TDnva25 1.690880e-014
Cn9anva14 TDn9a27 TDnva27 1.690880e-014
Cn9anva15 TDn9a29 TDnva29 1.690880e-014
Cn9anva16 TDn9a31 TDnva31 1.690880e-014
Cn9anva17 TDn9a33 TDnva33 1.690880e-014
Cn10an11a1 TDn10a1 TDn11a1 1.690880e-014
Cn10an11a2 TDn10a3 TDn11a3 1.302320e-014
Cn10an11a3 TDn10a5 TDn11a5 1.302320e-014
Cn10an11a4 TDn10a7 TDn11a7 1.302320e-014
Cn10an11a5 TDn10a9 TDn11a9 1.302320e-014
Cn10an11a6 TDn10a11 TDn11a11 1.302320e-014
Cn10an11a7 TDn10a13 TDn11a13 1.302320e-014
Cn10an11a8 TDn10a15 TDn11a15 1.302320e-014
Cn10an11a9 TDn10a17 TDn11a17 1.302320e-014
Cn10an11a10 TDn10a19 TDn11a19 1.302320e-014
Cn10an11a11 TDn10a21 TDn11a21 1.302320e-014
Cn10an11a12 TDn10a23 TDn11a23 1.302320e-014
Cn10an11a13 TDn10a25 TDn11a25 1.302320e-014
Cn10an11a14 TDn10a27 TDn11a27 1.302320e-014
Cn10an11a15 TDn10a29 TDn11a29 1.302320e-014
Cn10an11a16 TDn10a31 TDn11a31 1.302320e-014
Cn10an11a17 TDn10a33 TDn11a33 1.690880e-014
Cn10an12a1 TDn10a1 TDn12a1 1.690880e-014
Cn10an12a2 TDn10a3 TDn12a3 1.302320e-014
Cn10an12a3 TDn10a5 TDn12a5 1.302320e-014
Cn10an12a4 TDn10a7 TDn12a7 1.302320e-014
Cn10an12a5 TDn10a9 TDn12a9 1.302320e-014
Cn10an12a6 TDn10a11 TDn12a11 1.302320e-014
Cn10an12a7 TDn10a13 TDn12a13 1.302320e-014
Cn10an12a8 TDn10a15 TDn12a15 1.302320e-014
Cn10an12a9 TDn10a17 TDn12a17 1.302320e-014
Cn10an12a10 TDn10a19 TDn12a19 1.302320e-014
Cn10an12a11 TDn10a21 TDn12a21 1.302320e-014
Cn10an12a12 TDn10a23 TDn12a23 1.302320e-014
Cn10an12a13 TDn10a25 TDn12a25 1.302320e-014
Cn10an12a14 TDn10a27 TDn12a27 1.302320e-014
Cn10an12a15 TDn10a29 TDn12a29 1.302320e-014
Cn10an12a16 TDn10a31 TDn12a31 1.302320e-014
Cn10an12a17 TDn10a33 TDn12a33 1.690880e-014
Cn10an13a1 TDn10a1 TDn13a1 1.690880e-014
Cn10an13a2 TDn10a3 TDn13a3 1.302320e-014
Cn10an13a3 TDn10a5 TDn13a5 1.302320e-014
Cn10an13a4 TDn10a7 TDn13a7 1.302320e-014
Cn10an13a5 TDn10a9 TDn13a9 1.302320e-014
Cn10an13a6 TDn10a11 TDn13a11 1.302320e-014
Cn10an13a7 TDn10a13 TDn13a13 1.302320e-014
Cn10an13a8 TDn10a15 TDn13a15 1.302320e-014
Cn10an13a9 TDn10a17 TDn13a17 1.302320e-014
Cn10an13a10 TDn10a19 TDn13a19 1.302320e-014
Cn10an13a11 TDn10a21 TDn13a21 1.302320e-014
Cn10an13a12 TDn10a23 TDn13a23 1.302320e-014
Cn10an13a13 TDn10a25 TDn13a25 1.302320e-014
Cn10an13a14 TDn10a27 TDn13a27 1.302320e-014
Cn10an13a15 TDn10a29 TDn13a29 1.302320e-014
Cn10an13a16 TDn10a31 TDn13a31 1.302320e-014
Cn10an13a17 TDn10a33 TDn13a33 1.690880e-014
Cn10an14a1 TDn10a1 TDn14a1 1.690880e-014
Cn10an14a2 TDn10a3 TDn14a3 1.302320e-014
Cn10an14a3 TDn10a5 TDn14a5 1.302320e-014
Cn10an14a4 TDn10a7 TDn14a7 1.302320e-014
Cn10an14a5 TDn10a9 TDn14a9 1.302320e-014
Cn10an14a6 TDn10a11 TDn14a11 1.302320e-014
Cn10an14a7 TDn10a13 TDn14a13 1.302320e-014
Cn10an14a8 TDn10a15 TDn14a15 1.302320e-014
Cn10an14a9 TDn10a17 TDn14a17 1.302320e-014
Cn10an14a10 TDn10a19 TDn14a19 1.302320e-014
Cn10an14a11 TDn10a21 TDn14a21 1.302320e-014
Cn10an14a12 TDn10a23 TDn14a23 1.302320e-014
Cn10an14a13 TDn10a25 TDn14a25 1.302320e-014
Cn10an14a14 TDn10a27 TDn14a27 1.302320e-014
Cn10an14a15 TDn10a29 TDn14a29 1.302320e-014
Cn10an14a16 TDn10a31 TDn14a31 1.302320e-014
Cn10an14a17 TDn10a33 TDn14a33 1.690880e-014
Cn10an15a1 TDn10a1 TDn15a1 1.690880e-014
Cn10an15a2 TDn10a3 TDn15a3 1.302320e-014
Cn10an15a3 TDn10a5 TDn15a5 1.302320e-014
Cn10an15a4 TDn10a7 TDn15a7 1.302320e-014
Cn10an15a5 TDn10a9 TDn15a9 1.302320e-014
Cn10an15a6 TDn10a11 TDn15a11 1.302320e-014
Cn10an15a7 TDn10a13 TDn15a13 1.302320e-014
Cn10an15a8 TDn10a15 TDn15a15 1.302320e-014
Cn10an15a9 TDn10a17 TDn15a17 1.302320e-014
Cn10an15a10 TDn10a19 TDn15a19 1.302320e-014
Cn10an15a11 TDn10a21 TDn15a21 1.302320e-014
Cn10an15a12 TDn10a23 TDn15a23 1.302320e-014
Cn10an15a13 TDn10a25 TDn15a25 1.302320e-014
Cn10an15a14 TDn10a27 TDn15a27 1.302320e-014
Cn10an15a15 TDn10a29 TDn15a29 1.302320e-014
Cn10an15a16 TDn10a31 TDn15a31 1.302320e-014
Cn10an15a17 TDn10a33 TDn15a33 1.690880e-014
Cn10an16a1 TDn10a1 TDn16a1 1.690880e-014
Cn10an16a2 TDn10a3 TDn16a3 1.302320e-014
Cn10an16a3 TDn10a5 TDn16a5 1.302320e-014
Cn10an16a4 TDn10a7 TDn16a7 1.302320e-014
Cn10an16a5 TDn10a9 TDn16a9 1.302320e-014
Cn10an16a6 TDn10a11 TDn16a11 1.302320e-014
Cn10an16a7 TDn10a13 TDn16a13 1.302320e-014
Cn10an16a8 TDn10a15 TDn16a15 1.302320e-014
Cn10an16a9 TDn10a17 TDn16a17 1.302320e-014
Cn10an16a10 TDn10a19 TDn16a19 1.302320e-014
Cn10an16a11 TDn10a21 TDn16a21 1.302320e-014
Cn10an16a12 TDn10a23 TDn16a23 1.302320e-014
Cn10an16a13 TDn10a25 TDn16a25 1.302320e-014
Cn10an16a14 TDn10a27 TDn16a27 1.302320e-014
Cn10an16a15 TDn10a29 TDn16a29 1.302320e-014
Cn10an16a16 TDn10a31 TDn16a31 1.302320e-014
Cn10an16a17 TDn10a33 TDn16a33 1.690880e-014
Cn10an17a1 TDn10a1 TDn17a1 1.690880e-014
Cn10an17a2 TDn10a3 TDn17a3 1.302320e-014
Cn10an17a3 TDn10a5 TDn17a5 1.302320e-014
Cn10an17a4 TDn10a7 TDn17a7 1.302320e-014
Cn10an17a5 TDn10a9 TDn17a9 1.302320e-014
Cn10an17a6 TDn10a11 TDn17a11 1.302320e-014
Cn10an17a7 TDn10a13 TDn17a13 1.302320e-014
Cn10an17a8 TDn10a15 TDn17a15 1.302320e-014
Cn10an17a9 TDn10a17 TDn17a17 1.302320e-014
Cn10an17a10 TDn10a19 TDn17a19 1.302320e-014
Cn10an17a11 TDn10a21 TDn17a21 1.302320e-014
Cn10an17a12 TDn10a23 TDn17a23 1.302320e-014
Cn10an17a13 TDn10a25 TDn17a25 1.302320e-014
Cn10an17a14 TDn10a27 TDn17a27 1.302320e-014
Cn10an17a15 TDn10a29 TDn17a29 1.302320e-014
Cn10an17a16 TDn10a31 TDn17a31 1.302320e-014
Cn10an17a17 TDn10a33 TDn17a33 1.690880e-014
Cn10an18a1 TDn10a1 TDn18a1 1.690880e-014
Cn10an18a2 TDn10a3 TDn18a3 1.302320e-014
Cn10an18a3 TDn10a5 TDn18a5 1.302320e-014
Cn10an18a4 TDn10a7 TDn18a7 1.302320e-014
Cn10an18a5 TDn10a9 TDn18a9 1.302320e-014
Cn10an18a6 TDn10a11 TDn18a11 1.302320e-014
Cn10an18a7 TDn10a13 TDn18a13 1.302320e-014
Cn10an18a8 TDn10a15 TDn18a15 1.302320e-014
Cn10an18a9 TDn10a17 TDn18a17 1.302320e-014
Cn10an18a10 TDn10a19 TDn18a19 1.302320e-014
Cn10an18a11 TDn10a21 TDn18a21 1.302320e-014
Cn10an18a12 TDn10a23 TDn18a23 1.302320e-014
Cn10an18a13 TDn10a25 TDn18a25 1.302320e-014
Cn10an18a14 TDn10a27 TDn18a27 1.302320e-014
Cn10an18a15 TDn10a29 TDn18a29 1.302320e-014
Cn10an18a16 TDn10a31 TDn18a31 1.302320e-014
Cn10an18a17 TDn10a33 TDn18a33 1.690880e-014
Cn10an19a1 TDn10a1 TDn19a1 1.690880e-014
Cn10an19a2 TDn10a3 TDn19a3 1.302320e-014
Cn10an19a3 TDn10a5 TDn19a5 1.302320e-014
Cn10an19a4 TDn10a7 TDn19a7 1.302320e-014
Cn10an19a5 TDn10a9 TDn19a9 1.302320e-014
Cn10an19a6 TDn10a11 TDn19a11 1.302320e-014
Cn10an19a7 TDn10a13 TDn19a13 1.302320e-014
Cn10an19a8 TDn10a15 TDn19a15 1.302320e-014
Cn10an19a9 TDn10a17 TDn19a17 1.302320e-014
Cn10an19a10 TDn10a19 TDn19a19 1.302320e-014
Cn10an19a11 TDn10a21 TDn19a21 1.302320e-014
Cn10an19a12 TDn10a23 TDn19a23 1.302320e-014
Cn10an19a13 TDn10a25 TDn19a25 1.302320e-014
Cn10an19a14 TDn10a27 TDn19a27 1.302320e-014
Cn10an19a15 TDn10a29 TDn19a29 1.302320e-014
Cn10an19a16 TDn10a31 TDn19a31 1.302320e-014
Cn10an19a17 TDn10a33 TDn19a33 1.690880e-014
Cn10an20a1 TDn10a1 TDn20a1 1.690880e-014
Cn10an20a2 TDn10a3 TDn20a3 1.302320e-014
Cn10an20a3 TDn10a5 TDn20a5 1.302320e-014
Cn10an20a4 TDn10a7 TDn20a7 1.302320e-014
Cn10an20a5 TDn10a9 TDn20a9 1.302320e-014
Cn10an20a6 TDn10a11 TDn20a11 1.302320e-014
Cn10an20a7 TDn10a13 TDn20a13 1.302320e-014
Cn10an20a8 TDn10a15 TDn20a15 1.302320e-014
Cn10an20a9 TDn10a17 TDn20a17 1.302320e-014
Cn10an20a10 TDn10a19 TDn20a19 1.302320e-014
Cn10an20a11 TDn10a21 TDn20a21 1.302320e-014
Cn10an20a12 TDn10a23 TDn20a23 1.302320e-014
Cn10an20a13 TDn10a25 TDn20a25 1.302320e-014
Cn10an20a14 TDn10a27 TDn20a27 1.302320e-014
Cn10an20a15 TDn10a29 TDn20a29 1.302320e-014
Cn10an20a16 TDn10a31 TDn20a31 1.302320e-014
Cn10an20a17 TDn10a33 TDn20a33 1.690880e-014
Cn10an21a1 TDn10a1 TDn21a1 1.690880e-014
Cn10an21a2 TDn10a3 TDn21a3 1.302320e-014
Cn10an21a3 TDn10a5 TDn21a5 1.302320e-014
Cn10an21a4 TDn10a7 TDn21a7 1.302320e-014
Cn10an21a5 TDn10a9 TDn21a9 1.302320e-014
Cn10an21a6 TDn10a11 TDn21a11 1.302320e-014
Cn10an21a7 TDn10a13 TDn21a13 1.302320e-014
Cn10an21a8 TDn10a15 TDn21a15 1.302320e-014
Cn10an21a9 TDn10a17 TDn21a17 1.302320e-014
Cn10an21a10 TDn10a19 TDn21a19 1.302320e-014
Cn10an21a11 TDn10a21 TDn21a21 1.302320e-014
Cn10an21a12 TDn10a23 TDn21a23 1.302320e-014
Cn10an21a13 TDn10a25 TDn21a25 1.302320e-014
Cn10an21a14 TDn10a27 TDn21a27 1.302320e-014
Cn10an21a15 TDn10a29 TDn21a29 1.302320e-014
Cn10an21a16 TDn10a31 TDn21a31 1.302320e-014
Cn10an21a17 TDn10a33 TDn21a33 1.690880e-014
Cn10an22a1 TDn10a1 TDn22a1 1.690880e-014
Cn10an22a2 TDn10a3 TDn22a3 1.302320e-014
Cn10an22a3 TDn10a5 TDn22a5 1.302320e-014
Cn10an22a4 TDn10a7 TDn22a7 1.302320e-014
Cn10an22a5 TDn10a9 TDn22a9 1.302320e-014
Cn10an22a6 TDn10a11 TDn22a11 1.302320e-014
Cn10an22a7 TDn10a13 TDn22a13 1.302320e-014
Cn10an22a8 TDn10a15 TDn22a15 1.302320e-014
Cn10an22a9 TDn10a17 TDn22a17 1.302320e-014
Cn10an22a10 TDn10a19 TDn22a19 1.302320e-014
Cn10an22a11 TDn10a21 TDn22a21 1.302320e-014
Cn10an22a12 TDn10a23 TDn22a23 1.302320e-014
Cn10an22a13 TDn10a25 TDn22a25 1.302320e-014
Cn10an22a14 TDn10a27 TDn22a27 1.302320e-014
Cn10an22a15 TDn10a29 TDn22a29 1.302320e-014
Cn10an22a16 TDn10a31 TDn22a31 1.302320e-014
Cn10an22a17 TDn10a33 TDn22a33 1.690880e-014
Cn10an23a1 TDn10a1 TDn23a1 1.690880e-014
Cn10an23a2 TDn10a3 TDn23a3 1.302320e-014
Cn10an23a3 TDn10a5 TDn23a5 1.302320e-014
Cn10an23a4 TDn10a7 TDn23a7 1.302320e-014
Cn10an23a5 TDn10a9 TDn23a9 1.302320e-014
Cn10an23a6 TDn10a11 TDn23a11 1.302320e-014
Cn10an23a7 TDn10a13 TDn23a13 1.302320e-014
Cn10an23a8 TDn10a15 TDn23a15 1.302320e-014
Cn10an23a9 TDn10a17 TDn23a17 1.302320e-014
Cn10an23a10 TDn10a19 TDn23a19 1.302320e-014
Cn10an23a11 TDn10a21 TDn23a21 1.302320e-014
Cn10an23a12 TDn10a23 TDn23a23 1.302320e-014
Cn10an23a13 TDn10a25 TDn23a25 1.302320e-014
Cn10an23a14 TDn10a27 TDn23a27 1.302320e-014
Cn10an23a15 TDn10a29 TDn23a29 1.302320e-014
Cn10an23a16 TDn10a31 TDn23a31 1.302320e-014
Cn10an23a17 TDn10a33 TDn23a33 1.690880e-014
Cn10an24a1 TDn10a1 TDn24a1 1.690880e-014
Cn10an24a2 TDn10a3 TDn24a3 1.302320e-014
Cn10an24a3 TDn10a5 TDn24a5 1.302320e-014
Cn10an24a4 TDn10a7 TDn24a7 1.302320e-014
Cn10an24a5 TDn10a9 TDn24a9 1.302320e-014
Cn10an24a6 TDn10a11 TDn24a11 1.302320e-014
Cn10an24a7 TDn10a13 TDn24a13 1.302320e-014
Cn10an24a8 TDn10a15 TDn24a15 1.302320e-014
Cn10an24a9 TDn10a17 TDn24a17 1.302320e-014
Cn10an24a10 TDn10a19 TDn24a19 1.302320e-014
Cn10an24a11 TDn10a21 TDn24a21 1.302320e-014
Cn10an24a12 TDn10a23 TDn24a23 1.302320e-014
Cn10an24a13 TDn10a25 TDn24a25 1.302320e-014
Cn10an24a14 TDn10a27 TDn24a27 1.302320e-014
Cn10an24a15 TDn10a29 TDn24a29 1.302320e-014
Cn10an24a16 TDn10a31 TDn24a31 1.302320e-014
Cn10an24a17 TDn10a33 TDn24a33 1.690880e-014
Cn10an25a1 TDn10a1 TDn25a1 1.690880e-014
Cn10an25a2 TDn10a3 TDn25a3 1.302320e-014
Cn10an25a3 TDn10a5 TDn25a5 1.302320e-014
Cn10an25a4 TDn10a7 TDn25a7 1.302320e-014
Cn10an25a5 TDn10a9 TDn25a9 1.302320e-014
Cn10an25a6 TDn10a11 TDn25a11 1.302320e-014
Cn10an25a7 TDn10a13 TDn25a13 1.302320e-014
Cn10an25a8 TDn10a15 TDn25a15 1.302320e-014
Cn10an25a9 TDn10a17 TDn25a17 1.302320e-014
Cn10an25a10 TDn10a19 TDn25a19 1.302320e-014
Cn10an25a11 TDn10a21 TDn25a21 1.302320e-014
Cn10an25a12 TDn10a23 TDn25a23 1.302320e-014
Cn10an25a13 TDn10a25 TDn25a25 1.302320e-014
Cn10an25a14 TDn10a27 TDn25a27 1.302320e-014
Cn10an25a15 TDn10a29 TDn25a29 1.302320e-014
Cn10an25a16 TDn10a31 TDn25a31 1.302320e-014
Cn10an25a17 TDn10a33 TDn25a33 1.690880e-014
Cn10an26a1 TDn10a1 TDn26a1 1.690880e-014
Cn10an26a2 TDn10a3 TDn26a3 1.302320e-014
Cn10an26a3 TDn10a5 TDn26a5 1.302320e-014
Cn10an26a4 TDn10a7 TDn26a7 1.302320e-014
Cn10an26a5 TDn10a9 TDn26a9 1.302320e-014
Cn10an26a6 TDn10a11 TDn26a11 1.302320e-014
Cn10an26a7 TDn10a13 TDn26a13 1.302320e-014
Cn10an26a8 TDn10a15 TDn26a15 1.302320e-014
Cn10an26a9 TDn10a17 TDn26a17 1.302320e-014
Cn10an26a10 TDn10a19 TDn26a19 1.302320e-014
Cn10an26a11 TDn10a21 TDn26a21 1.302320e-014
Cn10an26a12 TDn10a23 TDn26a23 1.302320e-014
Cn10an26a13 TDn10a25 TDn26a25 1.302320e-014
Cn10an26a14 TDn10a27 TDn26a27 1.302320e-014
Cn10an26a15 TDn10a29 TDn26a29 1.302320e-014
Cn10an26a16 TDn10a31 TDn26a31 1.302320e-014
Cn10an26a17 TDn10a33 TDn26a33 1.690880e-014
Cn10an27a1 TDn10a1 TDn27a1 1.690880e-014
Cn10an27a2 TDn10a3 TDn27a3 1.302320e-014
Cn10an27a3 TDn10a5 TDn27a5 1.302320e-014
Cn10an27a4 TDn10a7 TDn27a7 1.302320e-014
Cn10an27a5 TDn10a9 TDn27a9 1.302320e-014
Cn10an27a6 TDn10a11 TDn27a11 1.302320e-014
Cn10an27a7 TDn10a13 TDn27a13 1.302320e-014
Cn10an27a8 TDn10a15 TDn27a15 1.302320e-014
Cn10an27a9 TDn10a17 TDn27a17 1.302320e-014
Cn10an27a10 TDn10a19 TDn27a19 1.302320e-014
Cn10an27a11 TDn10a21 TDn27a21 1.302320e-014
Cn10an27a12 TDn10a23 TDn27a23 1.302320e-014
Cn10an27a13 TDn10a25 TDn27a25 1.302320e-014
Cn10an27a14 TDn10a27 TDn27a27 1.302320e-014
Cn10an27a15 TDn10a29 TDn27a29 1.302320e-014
Cn10an27a16 TDn10a31 TDn27a31 1.302320e-014
Cn10an27a17 TDn10a33 TDn27a33 1.690880e-014
Cn10an28a1 TDn10a1 TDn28a1 1.690880e-014
Cn10an28a2 TDn10a3 TDn28a3 1.302320e-014
Cn10an28a3 TDn10a5 TDn28a5 1.302320e-014
Cn10an28a4 TDn10a7 TDn28a7 1.302320e-014
Cn10an28a5 TDn10a9 TDn28a9 1.302320e-014
Cn10an28a6 TDn10a11 TDn28a11 1.302320e-014
Cn10an28a7 TDn10a13 TDn28a13 1.302320e-014
Cn10an28a8 TDn10a15 TDn28a15 1.302320e-014
Cn10an28a9 TDn10a17 TDn28a17 1.302320e-014
Cn10an28a10 TDn10a19 TDn28a19 1.302320e-014
Cn10an28a11 TDn10a21 TDn28a21 1.302320e-014
Cn10an28a12 TDn10a23 TDn28a23 1.302320e-014
Cn10an28a13 TDn10a25 TDn28a25 1.302320e-014
Cn10an28a14 TDn10a27 TDn28a27 1.302320e-014
Cn10an28a15 TDn10a29 TDn28a29 1.302320e-014
Cn10an28a16 TDn10a31 TDn28a31 1.302320e-014
Cn10an28a17 TDn10a33 TDn28a33 1.690880e-014
Cn10an29a1 TDn10a1 TDn29a1 1.690880e-014
Cn10an29a2 TDn10a3 TDn29a3 1.302320e-014
Cn10an29a3 TDn10a5 TDn29a5 1.302320e-014
Cn10an29a4 TDn10a7 TDn29a7 1.302320e-014
Cn10an29a5 TDn10a9 TDn29a9 1.302320e-014
Cn10an29a6 TDn10a11 TDn29a11 1.302320e-014
Cn10an29a7 TDn10a13 TDn29a13 1.302320e-014
Cn10an29a8 TDn10a15 TDn29a15 1.302320e-014
Cn10an29a9 TDn10a17 TDn29a17 1.302320e-014
Cn10an29a10 TDn10a19 TDn29a19 1.302320e-014
Cn10an29a11 TDn10a21 TDn29a21 1.302320e-014
Cn10an29a12 TDn10a23 TDn29a23 1.302320e-014
Cn10an29a13 TDn10a25 TDn29a25 1.302320e-014
Cn10an29a14 TDn10a27 TDn29a27 1.302320e-014
Cn10an29a15 TDn10a29 TDn29a29 1.302320e-014
Cn10an29a16 TDn10a31 TDn29a31 1.302320e-014
Cn10an29a17 TDn10a33 TDn29a33 1.690880e-014
Cn10an30a1 TDn10a1 TDn30a1 1.690880e-014
Cn10an30a2 TDn10a3 TDn30a3 1.302320e-014
Cn10an30a3 TDn10a5 TDn30a5 1.302320e-014
Cn10an30a4 TDn10a7 TDn30a7 1.302320e-014
Cn10an30a5 TDn10a9 TDn30a9 1.302320e-014
Cn10an30a6 TDn10a11 TDn30a11 1.302320e-014
Cn10an30a7 TDn10a13 TDn30a13 1.302320e-014
Cn10an30a8 TDn10a15 TDn30a15 1.302320e-014
Cn10an30a9 TDn10a17 TDn30a17 1.302320e-014
Cn10an30a10 TDn10a19 TDn30a19 1.302320e-014
Cn10an30a11 TDn10a21 TDn30a21 1.302320e-014
Cn10an30a12 TDn10a23 TDn30a23 1.302320e-014
Cn10an30a13 TDn10a25 TDn30a25 1.302320e-014
Cn10an30a14 TDn10a27 TDn30a27 1.302320e-014
Cn10an30a15 TDn10a29 TDn30a29 1.302320e-014
Cn10an30a16 TDn10a31 TDn30a31 1.302320e-014
Cn10an30a17 TDn10a33 TDn30a33 1.690880e-014
Cn10an31a1 TDn10a1 TDn31a1 1.690880e-014
Cn10an31a2 TDn10a3 TDn31a3 1.302320e-014
Cn10an31a3 TDn10a5 TDn31a5 1.302320e-014
Cn10an31a4 TDn10a7 TDn31a7 1.302320e-014
Cn10an31a5 TDn10a9 TDn31a9 1.302320e-014
Cn10an31a6 TDn10a11 TDn31a11 1.302320e-014
Cn10an31a7 TDn10a13 TDn31a13 1.302320e-014
Cn10an31a8 TDn10a15 TDn31a15 1.302320e-014
Cn10an31a9 TDn10a17 TDn31a17 1.302320e-014
Cn10an31a10 TDn10a19 TDn31a19 1.302320e-014
Cn10an31a11 TDn10a21 TDn31a21 1.302320e-014
Cn10an31a12 TDn10a23 TDn31a23 1.302320e-014
Cn10an31a13 TDn10a25 TDn31a25 1.302320e-014
Cn10an31a14 TDn10a27 TDn31a27 1.302320e-014
Cn10an31a15 TDn10a29 TDn31a29 1.302320e-014
Cn10an31a16 TDn10a31 TDn31a31 1.302320e-014
Cn10an31a17 TDn10a33 TDn31a33 1.690880e-014
Cn10an32a1 TDn10a1 TDn32a1 1.690880e-014
Cn10an32a2 TDn10a3 TDn32a3 1.302320e-014
Cn10an32a3 TDn10a5 TDn32a5 1.302320e-014
Cn10an32a4 TDn10a7 TDn32a7 1.302320e-014
Cn10an32a5 TDn10a9 TDn32a9 1.302320e-014
Cn10an32a6 TDn10a11 TDn32a11 1.302320e-014
Cn10an32a7 TDn10a13 TDn32a13 1.302320e-014
Cn10an32a8 TDn10a15 TDn32a15 1.302320e-014
Cn10an32a9 TDn10a17 TDn32a17 1.302320e-014
Cn10an32a10 TDn10a19 TDn32a19 1.302320e-014
Cn10an32a11 TDn10a21 TDn32a21 1.302320e-014
Cn10an32a12 TDn10a23 TDn32a23 1.302320e-014
Cn10an32a13 TDn10a25 TDn32a25 1.302320e-014
Cn10an32a14 TDn10a27 TDn32a27 1.302320e-014
Cn10an32a15 TDn10a29 TDn32a29 1.302320e-014
Cn10an32a16 TDn10a31 TDn32a31 1.302320e-014
Cn10an32a17 TDn10a33 TDn32a33 1.690880e-014
Cn10anva1 TDn10a1 TDnva1 1.690880e-014
Cn10anva2 TDn10a3 TDnva3 1.690880e-014
Cn10anva3 TDn10a5 TDnva5 1.690880e-014
Cn10anva4 TDn10a7 TDnva7 1.690880e-014
Cn10anva5 TDn10a9 TDnva9 1.690880e-014
Cn10anva6 TDn10a11 TDnva11 1.690880e-014
Cn10anva7 TDn10a13 TDnva13 1.690880e-014
Cn10anva8 TDn10a15 TDnva15 1.690880e-014
Cn10anva9 TDn10a17 TDnva17 1.690880e-014
Cn10anva10 TDn10a19 TDnva19 1.690880e-014
Cn10anva11 TDn10a21 TDnva21 1.690880e-014
Cn10anva12 TDn10a23 TDnva23 1.690880e-014
Cn10anva13 TDn10a25 TDnva25 1.690880e-014
Cn10anva14 TDn10a27 TDnva27 1.690880e-014
Cn10anva15 TDn10a29 TDnva29 1.690880e-014
Cn10anva16 TDn10a31 TDnva31 1.690880e-014
Cn10anva17 TDn10a33 TDnva33 1.690880e-014
Cn11an12a1 TDn11a1 TDn12a1 1.690880e-014
Cn11an12a2 TDn11a3 TDn12a3 1.302320e-014
Cn11an12a3 TDn11a5 TDn12a5 1.302320e-014
Cn11an12a4 TDn11a7 TDn12a7 1.302320e-014
Cn11an12a5 TDn11a9 TDn12a9 1.302320e-014
Cn11an12a6 TDn11a11 TDn12a11 1.302320e-014
Cn11an12a7 TDn11a13 TDn12a13 1.302320e-014
Cn11an12a8 TDn11a15 TDn12a15 1.302320e-014
Cn11an12a9 TDn11a17 TDn12a17 1.302320e-014
Cn11an12a10 TDn11a19 TDn12a19 1.302320e-014
Cn11an12a11 TDn11a21 TDn12a21 1.302320e-014
Cn11an12a12 TDn11a23 TDn12a23 1.302320e-014
Cn11an12a13 TDn11a25 TDn12a25 1.302320e-014
Cn11an12a14 TDn11a27 TDn12a27 1.302320e-014
Cn11an12a15 TDn11a29 TDn12a29 1.302320e-014
Cn11an12a16 TDn11a31 TDn12a31 1.302320e-014
Cn11an12a17 TDn11a33 TDn12a33 1.690880e-014
Cn11an13a1 TDn11a1 TDn13a1 1.690880e-014
Cn11an13a2 TDn11a3 TDn13a3 1.302320e-014
Cn11an13a3 TDn11a5 TDn13a5 1.302320e-014
Cn11an13a4 TDn11a7 TDn13a7 1.302320e-014
Cn11an13a5 TDn11a9 TDn13a9 1.302320e-014
Cn11an13a6 TDn11a11 TDn13a11 1.302320e-014
Cn11an13a7 TDn11a13 TDn13a13 1.302320e-014
Cn11an13a8 TDn11a15 TDn13a15 1.302320e-014
Cn11an13a9 TDn11a17 TDn13a17 1.302320e-014
Cn11an13a10 TDn11a19 TDn13a19 1.302320e-014
Cn11an13a11 TDn11a21 TDn13a21 1.302320e-014
Cn11an13a12 TDn11a23 TDn13a23 1.302320e-014
Cn11an13a13 TDn11a25 TDn13a25 1.302320e-014
Cn11an13a14 TDn11a27 TDn13a27 1.302320e-014
Cn11an13a15 TDn11a29 TDn13a29 1.302320e-014
Cn11an13a16 TDn11a31 TDn13a31 1.302320e-014
Cn11an13a17 TDn11a33 TDn13a33 1.690880e-014
Cn11an14a1 TDn11a1 TDn14a1 1.690880e-014
Cn11an14a2 TDn11a3 TDn14a3 1.302320e-014
Cn11an14a3 TDn11a5 TDn14a5 1.302320e-014
Cn11an14a4 TDn11a7 TDn14a7 1.302320e-014
Cn11an14a5 TDn11a9 TDn14a9 1.302320e-014
Cn11an14a6 TDn11a11 TDn14a11 1.302320e-014
Cn11an14a7 TDn11a13 TDn14a13 1.302320e-014
Cn11an14a8 TDn11a15 TDn14a15 1.302320e-014
Cn11an14a9 TDn11a17 TDn14a17 1.302320e-014
Cn11an14a10 TDn11a19 TDn14a19 1.302320e-014
Cn11an14a11 TDn11a21 TDn14a21 1.302320e-014
Cn11an14a12 TDn11a23 TDn14a23 1.302320e-014
Cn11an14a13 TDn11a25 TDn14a25 1.302320e-014
Cn11an14a14 TDn11a27 TDn14a27 1.302320e-014
Cn11an14a15 TDn11a29 TDn14a29 1.302320e-014
Cn11an14a16 TDn11a31 TDn14a31 1.302320e-014
Cn11an14a17 TDn11a33 TDn14a33 1.690880e-014
Cn11an15a1 TDn11a1 TDn15a1 1.690880e-014
Cn11an15a2 TDn11a3 TDn15a3 1.302320e-014
Cn11an15a3 TDn11a5 TDn15a5 1.302320e-014
Cn11an15a4 TDn11a7 TDn15a7 1.302320e-014
Cn11an15a5 TDn11a9 TDn15a9 1.302320e-014
Cn11an15a6 TDn11a11 TDn15a11 1.302320e-014
Cn11an15a7 TDn11a13 TDn15a13 1.302320e-014
Cn11an15a8 TDn11a15 TDn15a15 1.302320e-014
Cn11an15a9 TDn11a17 TDn15a17 1.302320e-014
Cn11an15a10 TDn11a19 TDn15a19 1.302320e-014
Cn11an15a11 TDn11a21 TDn15a21 1.302320e-014
Cn11an15a12 TDn11a23 TDn15a23 1.302320e-014
Cn11an15a13 TDn11a25 TDn15a25 1.302320e-014
Cn11an15a14 TDn11a27 TDn15a27 1.302320e-014
Cn11an15a15 TDn11a29 TDn15a29 1.302320e-014
Cn11an15a16 TDn11a31 TDn15a31 1.302320e-014
Cn11an15a17 TDn11a33 TDn15a33 1.690880e-014
Cn11an16a1 TDn11a1 TDn16a1 1.690880e-014
Cn11an16a2 TDn11a3 TDn16a3 1.302320e-014
Cn11an16a3 TDn11a5 TDn16a5 1.302320e-014
Cn11an16a4 TDn11a7 TDn16a7 1.302320e-014
Cn11an16a5 TDn11a9 TDn16a9 1.302320e-014
Cn11an16a6 TDn11a11 TDn16a11 1.302320e-014
Cn11an16a7 TDn11a13 TDn16a13 1.302320e-014
Cn11an16a8 TDn11a15 TDn16a15 1.302320e-014
Cn11an16a9 TDn11a17 TDn16a17 1.302320e-014
Cn11an16a10 TDn11a19 TDn16a19 1.302320e-014
Cn11an16a11 TDn11a21 TDn16a21 1.302320e-014
Cn11an16a12 TDn11a23 TDn16a23 1.302320e-014
Cn11an16a13 TDn11a25 TDn16a25 1.302320e-014
Cn11an16a14 TDn11a27 TDn16a27 1.302320e-014
Cn11an16a15 TDn11a29 TDn16a29 1.302320e-014
Cn11an16a16 TDn11a31 TDn16a31 1.302320e-014
Cn11an16a17 TDn11a33 TDn16a33 1.690880e-014
Cn11an17a1 TDn11a1 TDn17a1 1.690880e-014
Cn11an17a2 TDn11a3 TDn17a3 1.302320e-014
Cn11an17a3 TDn11a5 TDn17a5 1.302320e-014
Cn11an17a4 TDn11a7 TDn17a7 1.302320e-014
Cn11an17a5 TDn11a9 TDn17a9 1.302320e-014
Cn11an17a6 TDn11a11 TDn17a11 1.302320e-014
Cn11an17a7 TDn11a13 TDn17a13 1.302320e-014
Cn11an17a8 TDn11a15 TDn17a15 1.302320e-014
Cn11an17a9 TDn11a17 TDn17a17 1.302320e-014
Cn11an17a10 TDn11a19 TDn17a19 1.302320e-014
Cn11an17a11 TDn11a21 TDn17a21 1.302320e-014
Cn11an17a12 TDn11a23 TDn17a23 1.302320e-014
Cn11an17a13 TDn11a25 TDn17a25 1.302320e-014
Cn11an17a14 TDn11a27 TDn17a27 1.302320e-014
Cn11an17a15 TDn11a29 TDn17a29 1.302320e-014
Cn11an17a16 TDn11a31 TDn17a31 1.302320e-014
Cn11an17a17 TDn11a33 TDn17a33 1.690880e-014
Cn11an18a1 TDn11a1 TDn18a1 1.690880e-014
Cn11an18a2 TDn11a3 TDn18a3 1.302320e-014
Cn11an18a3 TDn11a5 TDn18a5 1.302320e-014
Cn11an18a4 TDn11a7 TDn18a7 1.302320e-014
Cn11an18a5 TDn11a9 TDn18a9 1.302320e-014
Cn11an18a6 TDn11a11 TDn18a11 1.302320e-014
Cn11an18a7 TDn11a13 TDn18a13 1.302320e-014
Cn11an18a8 TDn11a15 TDn18a15 1.302320e-014
Cn11an18a9 TDn11a17 TDn18a17 1.302320e-014
Cn11an18a10 TDn11a19 TDn18a19 1.302320e-014
Cn11an18a11 TDn11a21 TDn18a21 1.302320e-014
Cn11an18a12 TDn11a23 TDn18a23 1.302320e-014
Cn11an18a13 TDn11a25 TDn18a25 1.302320e-014
Cn11an18a14 TDn11a27 TDn18a27 1.302320e-014
Cn11an18a15 TDn11a29 TDn18a29 1.302320e-014
Cn11an18a16 TDn11a31 TDn18a31 1.302320e-014
Cn11an18a17 TDn11a33 TDn18a33 1.690880e-014
Cn11an19a1 TDn11a1 TDn19a1 1.690880e-014
Cn11an19a2 TDn11a3 TDn19a3 1.302320e-014
Cn11an19a3 TDn11a5 TDn19a5 1.302320e-014
Cn11an19a4 TDn11a7 TDn19a7 1.302320e-014
Cn11an19a5 TDn11a9 TDn19a9 1.302320e-014
Cn11an19a6 TDn11a11 TDn19a11 1.302320e-014
Cn11an19a7 TDn11a13 TDn19a13 1.302320e-014
Cn11an19a8 TDn11a15 TDn19a15 1.302320e-014
Cn11an19a9 TDn11a17 TDn19a17 1.302320e-014
Cn11an19a10 TDn11a19 TDn19a19 1.302320e-014
Cn11an19a11 TDn11a21 TDn19a21 1.302320e-014
Cn11an19a12 TDn11a23 TDn19a23 1.302320e-014
Cn11an19a13 TDn11a25 TDn19a25 1.302320e-014
Cn11an19a14 TDn11a27 TDn19a27 1.302320e-014
Cn11an19a15 TDn11a29 TDn19a29 1.302320e-014
Cn11an19a16 TDn11a31 TDn19a31 1.302320e-014
Cn11an19a17 TDn11a33 TDn19a33 1.690880e-014
Cn11an20a1 TDn11a1 TDn20a1 1.690880e-014
Cn11an20a2 TDn11a3 TDn20a3 1.302320e-014
Cn11an20a3 TDn11a5 TDn20a5 1.302320e-014
Cn11an20a4 TDn11a7 TDn20a7 1.302320e-014
Cn11an20a5 TDn11a9 TDn20a9 1.302320e-014
Cn11an20a6 TDn11a11 TDn20a11 1.302320e-014
Cn11an20a7 TDn11a13 TDn20a13 1.302320e-014
Cn11an20a8 TDn11a15 TDn20a15 1.302320e-014
Cn11an20a9 TDn11a17 TDn20a17 1.302320e-014
Cn11an20a10 TDn11a19 TDn20a19 1.302320e-014
Cn11an20a11 TDn11a21 TDn20a21 1.302320e-014
Cn11an20a12 TDn11a23 TDn20a23 1.302320e-014
Cn11an20a13 TDn11a25 TDn20a25 1.302320e-014
Cn11an20a14 TDn11a27 TDn20a27 1.302320e-014
Cn11an20a15 TDn11a29 TDn20a29 1.302320e-014
Cn11an20a16 TDn11a31 TDn20a31 1.302320e-014
Cn11an20a17 TDn11a33 TDn20a33 1.690880e-014
Cn11an21a1 TDn11a1 TDn21a1 1.690880e-014
Cn11an21a2 TDn11a3 TDn21a3 1.302320e-014
Cn11an21a3 TDn11a5 TDn21a5 1.302320e-014
Cn11an21a4 TDn11a7 TDn21a7 1.302320e-014
Cn11an21a5 TDn11a9 TDn21a9 1.302320e-014
Cn11an21a6 TDn11a11 TDn21a11 1.302320e-014
Cn11an21a7 TDn11a13 TDn21a13 1.302320e-014
Cn11an21a8 TDn11a15 TDn21a15 1.302320e-014
Cn11an21a9 TDn11a17 TDn21a17 1.302320e-014
Cn11an21a10 TDn11a19 TDn21a19 1.302320e-014
Cn11an21a11 TDn11a21 TDn21a21 1.302320e-014
Cn11an21a12 TDn11a23 TDn21a23 1.302320e-014
Cn11an21a13 TDn11a25 TDn21a25 1.302320e-014
Cn11an21a14 TDn11a27 TDn21a27 1.302320e-014
Cn11an21a15 TDn11a29 TDn21a29 1.302320e-014
Cn11an21a16 TDn11a31 TDn21a31 1.302320e-014
Cn11an21a17 TDn11a33 TDn21a33 1.690880e-014
Cn11an22a1 TDn11a1 TDn22a1 1.690880e-014
Cn11an22a2 TDn11a3 TDn22a3 1.302320e-014
Cn11an22a3 TDn11a5 TDn22a5 1.302320e-014
Cn11an22a4 TDn11a7 TDn22a7 1.302320e-014
Cn11an22a5 TDn11a9 TDn22a9 1.302320e-014
Cn11an22a6 TDn11a11 TDn22a11 1.302320e-014
Cn11an22a7 TDn11a13 TDn22a13 1.302320e-014
Cn11an22a8 TDn11a15 TDn22a15 1.302320e-014
Cn11an22a9 TDn11a17 TDn22a17 1.302320e-014
Cn11an22a10 TDn11a19 TDn22a19 1.302320e-014
Cn11an22a11 TDn11a21 TDn22a21 1.302320e-014
Cn11an22a12 TDn11a23 TDn22a23 1.302320e-014
Cn11an22a13 TDn11a25 TDn22a25 1.302320e-014
Cn11an22a14 TDn11a27 TDn22a27 1.302320e-014
Cn11an22a15 TDn11a29 TDn22a29 1.302320e-014
Cn11an22a16 TDn11a31 TDn22a31 1.302320e-014
Cn11an22a17 TDn11a33 TDn22a33 1.690880e-014
Cn11an23a1 TDn11a1 TDn23a1 1.690880e-014
Cn11an23a2 TDn11a3 TDn23a3 1.302320e-014
Cn11an23a3 TDn11a5 TDn23a5 1.302320e-014
Cn11an23a4 TDn11a7 TDn23a7 1.302320e-014
Cn11an23a5 TDn11a9 TDn23a9 1.302320e-014
Cn11an23a6 TDn11a11 TDn23a11 1.302320e-014
Cn11an23a7 TDn11a13 TDn23a13 1.302320e-014
Cn11an23a8 TDn11a15 TDn23a15 1.302320e-014
Cn11an23a9 TDn11a17 TDn23a17 1.302320e-014
Cn11an23a10 TDn11a19 TDn23a19 1.302320e-014
Cn11an23a11 TDn11a21 TDn23a21 1.302320e-014
Cn11an23a12 TDn11a23 TDn23a23 1.302320e-014
Cn11an23a13 TDn11a25 TDn23a25 1.302320e-014
Cn11an23a14 TDn11a27 TDn23a27 1.302320e-014
Cn11an23a15 TDn11a29 TDn23a29 1.302320e-014
Cn11an23a16 TDn11a31 TDn23a31 1.302320e-014
Cn11an23a17 TDn11a33 TDn23a33 1.690880e-014
Cn11an24a1 TDn11a1 TDn24a1 1.690880e-014
Cn11an24a2 TDn11a3 TDn24a3 1.302320e-014
Cn11an24a3 TDn11a5 TDn24a5 1.302320e-014
Cn11an24a4 TDn11a7 TDn24a7 1.302320e-014
Cn11an24a5 TDn11a9 TDn24a9 1.302320e-014
Cn11an24a6 TDn11a11 TDn24a11 1.302320e-014
Cn11an24a7 TDn11a13 TDn24a13 1.302320e-014
Cn11an24a8 TDn11a15 TDn24a15 1.302320e-014
Cn11an24a9 TDn11a17 TDn24a17 1.302320e-014
Cn11an24a10 TDn11a19 TDn24a19 1.302320e-014
Cn11an24a11 TDn11a21 TDn24a21 1.302320e-014
Cn11an24a12 TDn11a23 TDn24a23 1.302320e-014
Cn11an24a13 TDn11a25 TDn24a25 1.302320e-014
Cn11an24a14 TDn11a27 TDn24a27 1.302320e-014
Cn11an24a15 TDn11a29 TDn24a29 1.302320e-014
Cn11an24a16 TDn11a31 TDn24a31 1.302320e-014
Cn11an24a17 TDn11a33 TDn24a33 1.690880e-014
Cn11an25a1 TDn11a1 TDn25a1 1.690880e-014
Cn11an25a2 TDn11a3 TDn25a3 1.302320e-014
Cn11an25a3 TDn11a5 TDn25a5 1.302320e-014
Cn11an25a4 TDn11a7 TDn25a7 1.302320e-014
Cn11an25a5 TDn11a9 TDn25a9 1.302320e-014
Cn11an25a6 TDn11a11 TDn25a11 1.302320e-014
Cn11an25a7 TDn11a13 TDn25a13 1.302320e-014
Cn11an25a8 TDn11a15 TDn25a15 1.302320e-014
Cn11an25a9 TDn11a17 TDn25a17 1.302320e-014
Cn11an25a10 TDn11a19 TDn25a19 1.302320e-014
Cn11an25a11 TDn11a21 TDn25a21 1.302320e-014
Cn11an25a12 TDn11a23 TDn25a23 1.302320e-014
Cn11an25a13 TDn11a25 TDn25a25 1.302320e-014
Cn11an25a14 TDn11a27 TDn25a27 1.302320e-014
Cn11an25a15 TDn11a29 TDn25a29 1.302320e-014
Cn11an25a16 TDn11a31 TDn25a31 1.302320e-014
Cn11an25a17 TDn11a33 TDn25a33 1.690880e-014
Cn11an26a1 TDn11a1 TDn26a1 1.690880e-014
Cn11an26a2 TDn11a3 TDn26a3 1.302320e-014
Cn11an26a3 TDn11a5 TDn26a5 1.302320e-014
Cn11an26a4 TDn11a7 TDn26a7 1.302320e-014
Cn11an26a5 TDn11a9 TDn26a9 1.302320e-014
Cn11an26a6 TDn11a11 TDn26a11 1.302320e-014
Cn11an26a7 TDn11a13 TDn26a13 1.302320e-014
Cn11an26a8 TDn11a15 TDn26a15 1.302320e-014
Cn11an26a9 TDn11a17 TDn26a17 1.302320e-014
Cn11an26a10 TDn11a19 TDn26a19 1.302320e-014
Cn11an26a11 TDn11a21 TDn26a21 1.302320e-014
Cn11an26a12 TDn11a23 TDn26a23 1.302320e-014
Cn11an26a13 TDn11a25 TDn26a25 1.302320e-014
Cn11an26a14 TDn11a27 TDn26a27 1.302320e-014
Cn11an26a15 TDn11a29 TDn26a29 1.302320e-014
Cn11an26a16 TDn11a31 TDn26a31 1.302320e-014
Cn11an26a17 TDn11a33 TDn26a33 1.690880e-014
Cn11an27a1 TDn11a1 TDn27a1 1.690880e-014
Cn11an27a2 TDn11a3 TDn27a3 1.302320e-014
Cn11an27a3 TDn11a5 TDn27a5 1.302320e-014
Cn11an27a4 TDn11a7 TDn27a7 1.302320e-014
Cn11an27a5 TDn11a9 TDn27a9 1.302320e-014
Cn11an27a6 TDn11a11 TDn27a11 1.302320e-014
Cn11an27a7 TDn11a13 TDn27a13 1.302320e-014
Cn11an27a8 TDn11a15 TDn27a15 1.302320e-014
Cn11an27a9 TDn11a17 TDn27a17 1.302320e-014
Cn11an27a10 TDn11a19 TDn27a19 1.302320e-014
Cn11an27a11 TDn11a21 TDn27a21 1.302320e-014
Cn11an27a12 TDn11a23 TDn27a23 1.302320e-014
Cn11an27a13 TDn11a25 TDn27a25 1.302320e-014
Cn11an27a14 TDn11a27 TDn27a27 1.302320e-014
Cn11an27a15 TDn11a29 TDn27a29 1.302320e-014
Cn11an27a16 TDn11a31 TDn27a31 1.302320e-014
Cn11an27a17 TDn11a33 TDn27a33 1.690880e-014
Cn11an28a1 TDn11a1 TDn28a1 1.690880e-014
Cn11an28a2 TDn11a3 TDn28a3 1.302320e-014
Cn11an28a3 TDn11a5 TDn28a5 1.302320e-014
Cn11an28a4 TDn11a7 TDn28a7 1.302320e-014
Cn11an28a5 TDn11a9 TDn28a9 1.302320e-014
Cn11an28a6 TDn11a11 TDn28a11 1.302320e-014
Cn11an28a7 TDn11a13 TDn28a13 1.302320e-014
Cn11an28a8 TDn11a15 TDn28a15 1.302320e-014
Cn11an28a9 TDn11a17 TDn28a17 1.302320e-014
Cn11an28a10 TDn11a19 TDn28a19 1.302320e-014
Cn11an28a11 TDn11a21 TDn28a21 1.302320e-014
Cn11an28a12 TDn11a23 TDn28a23 1.302320e-014
Cn11an28a13 TDn11a25 TDn28a25 1.302320e-014
Cn11an28a14 TDn11a27 TDn28a27 1.302320e-014
Cn11an28a15 TDn11a29 TDn28a29 1.302320e-014
Cn11an28a16 TDn11a31 TDn28a31 1.302320e-014
Cn11an28a17 TDn11a33 TDn28a33 1.690880e-014
Cn11an29a1 TDn11a1 TDn29a1 1.690880e-014
Cn11an29a2 TDn11a3 TDn29a3 1.302320e-014
Cn11an29a3 TDn11a5 TDn29a5 1.302320e-014
Cn11an29a4 TDn11a7 TDn29a7 1.302320e-014
Cn11an29a5 TDn11a9 TDn29a9 1.302320e-014
Cn11an29a6 TDn11a11 TDn29a11 1.302320e-014
Cn11an29a7 TDn11a13 TDn29a13 1.302320e-014
Cn11an29a8 TDn11a15 TDn29a15 1.302320e-014
Cn11an29a9 TDn11a17 TDn29a17 1.302320e-014
Cn11an29a10 TDn11a19 TDn29a19 1.302320e-014
Cn11an29a11 TDn11a21 TDn29a21 1.302320e-014
Cn11an29a12 TDn11a23 TDn29a23 1.302320e-014
Cn11an29a13 TDn11a25 TDn29a25 1.302320e-014
Cn11an29a14 TDn11a27 TDn29a27 1.302320e-014
Cn11an29a15 TDn11a29 TDn29a29 1.302320e-014
Cn11an29a16 TDn11a31 TDn29a31 1.302320e-014
Cn11an29a17 TDn11a33 TDn29a33 1.690880e-014
Cn11an30a1 TDn11a1 TDn30a1 1.690880e-014
Cn11an30a2 TDn11a3 TDn30a3 1.302320e-014
Cn11an30a3 TDn11a5 TDn30a5 1.302320e-014
Cn11an30a4 TDn11a7 TDn30a7 1.302320e-014
Cn11an30a5 TDn11a9 TDn30a9 1.302320e-014
Cn11an30a6 TDn11a11 TDn30a11 1.302320e-014
Cn11an30a7 TDn11a13 TDn30a13 1.302320e-014
Cn11an30a8 TDn11a15 TDn30a15 1.302320e-014
Cn11an30a9 TDn11a17 TDn30a17 1.302320e-014
Cn11an30a10 TDn11a19 TDn30a19 1.302320e-014
Cn11an30a11 TDn11a21 TDn30a21 1.302320e-014
Cn11an30a12 TDn11a23 TDn30a23 1.302320e-014
Cn11an30a13 TDn11a25 TDn30a25 1.302320e-014
Cn11an30a14 TDn11a27 TDn30a27 1.302320e-014
Cn11an30a15 TDn11a29 TDn30a29 1.302320e-014
Cn11an30a16 TDn11a31 TDn30a31 1.302320e-014
Cn11an30a17 TDn11a33 TDn30a33 1.690880e-014
Cn11an31a1 TDn11a1 TDn31a1 1.690880e-014
Cn11an31a2 TDn11a3 TDn31a3 1.302320e-014
Cn11an31a3 TDn11a5 TDn31a5 1.302320e-014
Cn11an31a4 TDn11a7 TDn31a7 1.302320e-014
Cn11an31a5 TDn11a9 TDn31a9 1.302320e-014
Cn11an31a6 TDn11a11 TDn31a11 1.302320e-014
Cn11an31a7 TDn11a13 TDn31a13 1.302320e-014
Cn11an31a8 TDn11a15 TDn31a15 1.302320e-014
Cn11an31a9 TDn11a17 TDn31a17 1.302320e-014
Cn11an31a10 TDn11a19 TDn31a19 1.302320e-014
Cn11an31a11 TDn11a21 TDn31a21 1.302320e-014
Cn11an31a12 TDn11a23 TDn31a23 1.302320e-014
Cn11an31a13 TDn11a25 TDn31a25 1.302320e-014
Cn11an31a14 TDn11a27 TDn31a27 1.302320e-014
Cn11an31a15 TDn11a29 TDn31a29 1.302320e-014
Cn11an31a16 TDn11a31 TDn31a31 1.302320e-014
Cn11an31a17 TDn11a33 TDn31a33 1.690880e-014
Cn11an32a1 TDn11a1 TDn32a1 1.690880e-014
Cn11an32a2 TDn11a3 TDn32a3 1.302320e-014
Cn11an32a3 TDn11a5 TDn32a5 1.302320e-014
Cn11an32a4 TDn11a7 TDn32a7 1.302320e-014
Cn11an32a5 TDn11a9 TDn32a9 1.302320e-014
Cn11an32a6 TDn11a11 TDn32a11 1.302320e-014
Cn11an32a7 TDn11a13 TDn32a13 1.302320e-014
Cn11an32a8 TDn11a15 TDn32a15 1.302320e-014
Cn11an32a9 TDn11a17 TDn32a17 1.302320e-014
Cn11an32a10 TDn11a19 TDn32a19 1.302320e-014
Cn11an32a11 TDn11a21 TDn32a21 1.302320e-014
Cn11an32a12 TDn11a23 TDn32a23 1.302320e-014
Cn11an32a13 TDn11a25 TDn32a25 1.302320e-014
Cn11an32a14 TDn11a27 TDn32a27 1.302320e-014
Cn11an32a15 TDn11a29 TDn32a29 1.302320e-014
Cn11an32a16 TDn11a31 TDn32a31 1.302320e-014
Cn11an32a17 TDn11a33 TDn32a33 1.690880e-014
Cn11anva1 TDn11a1 TDnva1 1.690880e-014
Cn11anva2 TDn11a3 TDnva3 1.690880e-014
Cn11anva3 TDn11a5 TDnva5 1.690880e-014
Cn11anva4 TDn11a7 TDnva7 1.690880e-014
Cn11anva5 TDn11a9 TDnva9 1.690880e-014
Cn11anva6 TDn11a11 TDnva11 1.690880e-014
Cn11anva7 TDn11a13 TDnva13 1.690880e-014
Cn11anva8 TDn11a15 TDnva15 1.690880e-014
Cn11anva9 TDn11a17 TDnva17 1.690880e-014
Cn11anva10 TDn11a19 TDnva19 1.690880e-014
Cn11anva11 TDn11a21 TDnva21 1.690880e-014
Cn11anva12 TDn11a23 TDnva23 1.690880e-014
Cn11anva13 TDn11a25 TDnva25 1.690880e-014
Cn11anva14 TDn11a27 TDnva27 1.690880e-014
Cn11anva15 TDn11a29 TDnva29 1.690880e-014
Cn11anva16 TDn11a31 TDnva31 1.690880e-014
Cn11anva17 TDn11a33 TDnva33 1.690880e-014
Cn12an13a1 TDn12a1 TDn13a1 1.690880e-014
Cn12an13a2 TDn12a3 TDn13a3 1.302320e-014
Cn12an13a3 TDn12a5 TDn13a5 1.302320e-014
Cn12an13a4 TDn12a7 TDn13a7 1.302320e-014
Cn12an13a5 TDn12a9 TDn13a9 1.302320e-014
Cn12an13a6 TDn12a11 TDn13a11 1.302320e-014
Cn12an13a7 TDn12a13 TDn13a13 1.302320e-014
Cn12an13a8 TDn12a15 TDn13a15 1.302320e-014
Cn12an13a9 TDn12a17 TDn13a17 1.302320e-014
Cn12an13a10 TDn12a19 TDn13a19 1.302320e-014
Cn12an13a11 TDn12a21 TDn13a21 1.302320e-014
Cn12an13a12 TDn12a23 TDn13a23 1.302320e-014
Cn12an13a13 TDn12a25 TDn13a25 1.302320e-014
Cn12an13a14 TDn12a27 TDn13a27 1.302320e-014
Cn12an13a15 TDn12a29 TDn13a29 1.302320e-014
Cn12an13a16 TDn12a31 TDn13a31 1.302320e-014
Cn12an13a17 TDn12a33 TDn13a33 1.690880e-014
Cn12an14a1 TDn12a1 TDn14a1 1.690880e-014
Cn12an14a2 TDn12a3 TDn14a3 1.302320e-014
Cn12an14a3 TDn12a5 TDn14a5 1.302320e-014
Cn12an14a4 TDn12a7 TDn14a7 1.302320e-014
Cn12an14a5 TDn12a9 TDn14a9 1.302320e-014
Cn12an14a6 TDn12a11 TDn14a11 1.302320e-014
Cn12an14a7 TDn12a13 TDn14a13 1.302320e-014
Cn12an14a8 TDn12a15 TDn14a15 1.302320e-014
Cn12an14a9 TDn12a17 TDn14a17 1.302320e-014
Cn12an14a10 TDn12a19 TDn14a19 1.302320e-014
Cn12an14a11 TDn12a21 TDn14a21 1.302320e-014
Cn12an14a12 TDn12a23 TDn14a23 1.302320e-014
Cn12an14a13 TDn12a25 TDn14a25 1.302320e-014
Cn12an14a14 TDn12a27 TDn14a27 1.302320e-014
Cn12an14a15 TDn12a29 TDn14a29 1.302320e-014
Cn12an14a16 TDn12a31 TDn14a31 1.302320e-014
Cn12an14a17 TDn12a33 TDn14a33 1.690880e-014
Cn12an15a1 TDn12a1 TDn15a1 1.690880e-014
Cn12an15a2 TDn12a3 TDn15a3 1.302320e-014
Cn12an15a3 TDn12a5 TDn15a5 1.302320e-014
Cn12an15a4 TDn12a7 TDn15a7 1.302320e-014
Cn12an15a5 TDn12a9 TDn15a9 1.302320e-014
Cn12an15a6 TDn12a11 TDn15a11 1.302320e-014
Cn12an15a7 TDn12a13 TDn15a13 1.302320e-014
Cn12an15a8 TDn12a15 TDn15a15 1.302320e-014
Cn12an15a9 TDn12a17 TDn15a17 1.302320e-014
Cn12an15a10 TDn12a19 TDn15a19 1.302320e-014
Cn12an15a11 TDn12a21 TDn15a21 1.302320e-014
Cn12an15a12 TDn12a23 TDn15a23 1.302320e-014
Cn12an15a13 TDn12a25 TDn15a25 1.302320e-014
Cn12an15a14 TDn12a27 TDn15a27 1.302320e-014
Cn12an15a15 TDn12a29 TDn15a29 1.302320e-014
Cn12an15a16 TDn12a31 TDn15a31 1.302320e-014
Cn12an15a17 TDn12a33 TDn15a33 1.690880e-014
Cn12an16a1 TDn12a1 TDn16a1 1.690880e-014
Cn12an16a2 TDn12a3 TDn16a3 1.302320e-014
Cn12an16a3 TDn12a5 TDn16a5 1.302320e-014
Cn12an16a4 TDn12a7 TDn16a7 1.302320e-014
Cn12an16a5 TDn12a9 TDn16a9 1.302320e-014
Cn12an16a6 TDn12a11 TDn16a11 1.302320e-014
Cn12an16a7 TDn12a13 TDn16a13 1.302320e-014
Cn12an16a8 TDn12a15 TDn16a15 1.302320e-014
Cn12an16a9 TDn12a17 TDn16a17 1.302320e-014
Cn12an16a10 TDn12a19 TDn16a19 1.302320e-014
Cn12an16a11 TDn12a21 TDn16a21 1.302320e-014
Cn12an16a12 TDn12a23 TDn16a23 1.302320e-014
Cn12an16a13 TDn12a25 TDn16a25 1.302320e-014
Cn12an16a14 TDn12a27 TDn16a27 1.302320e-014
Cn12an16a15 TDn12a29 TDn16a29 1.302320e-014
Cn12an16a16 TDn12a31 TDn16a31 1.302320e-014
Cn12an16a17 TDn12a33 TDn16a33 1.690880e-014
Cn12an17a1 TDn12a1 TDn17a1 1.690880e-014
Cn12an17a2 TDn12a3 TDn17a3 1.302320e-014
Cn12an17a3 TDn12a5 TDn17a5 1.302320e-014
Cn12an17a4 TDn12a7 TDn17a7 1.302320e-014
Cn12an17a5 TDn12a9 TDn17a9 1.302320e-014
Cn12an17a6 TDn12a11 TDn17a11 1.302320e-014
Cn12an17a7 TDn12a13 TDn17a13 1.302320e-014
Cn12an17a8 TDn12a15 TDn17a15 1.302320e-014
Cn12an17a9 TDn12a17 TDn17a17 1.302320e-014
Cn12an17a10 TDn12a19 TDn17a19 1.302320e-014
Cn12an17a11 TDn12a21 TDn17a21 1.302320e-014
Cn12an17a12 TDn12a23 TDn17a23 1.302320e-014
Cn12an17a13 TDn12a25 TDn17a25 1.302320e-014
Cn12an17a14 TDn12a27 TDn17a27 1.302320e-014
Cn12an17a15 TDn12a29 TDn17a29 1.302320e-014
Cn12an17a16 TDn12a31 TDn17a31 1.302320e-014
Cn12an17a17 TDn12a33 TDn17a33 1.690880e-014
Cn12an18a1 TDn12a1 TDn18a1 1.690880e-014
Cn12an18a2 TDn12a3 TDn18a3 1.302320e-014
Cn12an18a3 TDn12a5 TDn18a5 1.302320e-014
Cn12an18a4 TDn12a7 TDn18a7 1.302320e-014
Cn12an18a5 TDn12a9 TDn18a9 1.302320e-014
Cn12an18a6 TDn12a11 TDn18a11 1.302320e-014
Cn12an18a7 TDn12a13 TDn18a13 1.302320e-014
Cn12an18a8 TDn12a15 TDn18a15 1.302320e-014
Cn12an18a9 TDn12a17 TDn18a17 1.302320e-014
Cn12an18a10 TDn12a19 TDn18a19 1.302320e-014
Cn12an18a11 TDn12a21 TDn18a21 1.302320e-014
Cn12an18a12 TDn12a23 TDn18a23 1.302320e-014
Cn12an18a13 TDn12a25 TDn18a25 1.302320e-014
Cn12an18a14 TDn12a27 TDn18a27 1.302320e-014
Cn12an18a15 TDn12a29 TDn18a29 1.302320e-014
Cn12an18a16 TDn12a31 TDn18a31 1.302320e-014
Cn12an18a17 TDn12a33 TDn18a33 1.690880e-014
Cn12an19a1 TDn12a1 TDn19a1 1.690880e-014
Cn12an19a2 TDn12a3 TDn19a3 1.302320e-014
Cn12an19a3 TDn12a5 TDn19a5 1.302320e-014
Cn12an19a4 TDn12a7 TDn19a7 1.302320e-014
Cn12an19a5 TDn12a9 TDn19a9 1.302320e-014
Cn12an19a6 TDn12a11 TDn19a11 1.302320e-014
Cn12an19a7 TDn12a13 TDn19a13 1.302320e-014
Cn12an19a8 TDn12a15 TDn19a15 1.302320e-014
Cn12an19a9 TDn12a17 TDn19a17 1.302320e-014
Cn12an19a10 TDn12a19 TDn19a19 1.302320e-014
Cn12an19a11 TDn12a21 TDn19a21 1.302320e-014
Cn12an19a12 TDn12a23 TDn19a23 1.302320e-014
Cn12an19a13 TDn12a25 TDn19a25 1.302320e-014
Cn12an19a14 TDn12a27 TDn19a27 1.302320e-014
Cn12an19a15 TDn12a29 TDn19a29 1.302320e-014
Cn12an19a16 TDn12a31 TDn19a31 1.302320e-014
Cn12an19a17 TDn12a33 TDn19a33 1.690880e-014
Cn12an20a1 TDn12a1 TDn20a1 1.690880e-014
Cn12an20a2 TDn12a3 TDn20a3 1.302320e-014
Cn12an20a3 TDn12a5 TDn20a5 1.302320e-014
Cn12an20a4 TDn12a7 TDn20a7 1.302320e-014
Cn12an20a5 TDn12a9 TDn20a9 1.302320e-014
Cn12an20a6 TDn12a11 TDn20a11 1.302320e-014
Cn12an20a7 TDn12a13 TDn20a13 1.302320e-014
Cn12an20a8 TDn12a15 TDn20a15 1.302320e-014
Cn12an20a9 TDn12a17 TDn20a17 1.302320e-014
Cn12an20a10 TDn12a19 TDn20a19 1.302320e-014
Cn12an20a11 TDn12a21 TDn20a21 1.302320e-014
Cn12an20a12 TDn12a23 TDn20a23 1.302320e-014
Cn12an20a13 TDn12a25 TDn20a25 1.302320e-014
Cn12an20a14 TDn12a27 TDn20a27 1.302320e-014
Cn12an20a15 TDn12a29 TDn20a29 1.302320e-014
Cn12an20a16 TDn12a31 TDn20a31 1.302320e-014
Cn12an20a17 TDn12a33 TDn20a33 1.690880e-014
Cn12an21a1 TDn12a1 TDn21a1 1.690880e-014
Cn12an21a2 TDn12a3 TDn21a3 1.302320e-014
Cn12an21a3 TDn12a5 TDn21a5 1.302320e-014
Cn12an21a4 TDn12a7 TDn21a7 1.302320e-014
Cn12an21a5 TDn12a9 TDn21a9 1.302320e-014
Cn12an21a6 TDn12a11 TDn21a11 1.302320e-014
Cn12an21a7 TDn12a13 TDn21a13 1.302320e-014
Cn12an21a8 TDn12a15 TDn21a15 1.302320e-014
Cn12an21a9 TDn12a17 TDn21a17 1.302320e-014
Cn12an21a10 TDn12a19 TDn21a19 1.302320e-014
Cn12an21a11 TDn12a21 TDn21a21 1.302320e-014
Cn12an21a12 TDn12a23 TDn21a23 1.302320e-014
Cn12an21a13 TDn12a25 TDn21a25 1.302320e-014
Cn12an21a14 TDn12a27 TDn21a27 1.302320e-014
Cn12an21a15 TDn12a29 TDn21a29 1.302320e-014
Cn12an21a16 TDn12a31 TDn21a31 1.302320e-014
Cn12an21a17 TDn12a33 TDn21a33 1.690880e-014
Cn12an22a1 TDn12a1 TDn22a1 1.690880e-014
Cn12an22a2 TDn12a3 TDn22a3 1.302320e-014
Cn12an22a3 TDn12a5 TDn22a5 1.302320e-014
Cn12an22a4 TDn12a7 TDn22a7 1.302320e-014
Cn12an22a5 TDn12a9 TDn22a9 1.302320e-014
Cn12an22a6 TDn12a11 TDn22a11 1.302320e-014
Cn12an22a7 TDn12a13 TDn22a13 1.302320e-014
Cn12an22a8 TDn12a15 TDn22a15 1.302320e-014
Cn12an22a9 TDn12a17 TDn22a17 1.302320e-014
Cn12an22a10 TDn12a19 TDn22a19 1.302320e-014
Cn12an22a11 TDn12a21 TDn22a21 1.302320e-014
Cn12an22a12 TDn12a23 TDn22a23 1.302320e-014
Cn12an22a13 TDn12a25 TDn22a25 1.302320e-014
Cn12an22a14 TDn12a27 TDn22a27 1.302320e-014
Cn12an22a15 TDn12a29 TDn22a29 1.302320e-014
Cn12an22a16 TDn12a31 TDn22a31 1.302320e-014
Cn12an22a17 TDn12a33 TDn22a33 1.690880e-014
Cn12an23a1 TDn12a1 TDn23a1 1.690880e-014
Cn12an23a2 TDn12a3 TDn23a3 1.302320e-014
Cn12an23a3 TDn12a5 TDn23a5 1.302320e-014
Cn12an23a4 TDn12a7 TDn23a7 1.302320e-014
Cn12an23a5 TDn12a9 TDn23a9 1.302320e-014
Cn12an23a6 TDn12a11 TDn23a11 1.302320e-014
Cn12an23a7 TDn12a13 TDn23a13 1.302320e-014
Cn12an23a8 TDn12a15 TDn23a15 1.302320e-014
Cn12an23a9 TDn12a17 TDn23a17 1.302320e-014
Cn12an23a10 TDn12a19 TDn23a19 1.302320e-014
Cn12an23a11 TDn12a21 TDn23a21 1.302320e-014
Cn12an23a12 TDn12a23 TDn23a23 1.302320e-014
Cn12an23a13 TDn12a25 TDn23a25 1.302320e-014
Cn12an23a14 TDn12a27 TDn23a27 1.302320e-014
Cn12an23a15 TDn12a29 TDn23a29 1.302320e-014
Cn12an23a16 TDn12a31 TDn23a31 1.302320e-014
Cn12an23a17 TDn12a33 TDn23a33 1.690880e-014
Cn12an24a1 TDn12a1 TDn24a1 1.690880e-014
Cn12an24a2 TDn12a3 TDn24a3 1.302320e-014
Cn12an24a3 TDn12a5 TDn24a5 1.302320e-014
Cn12an24a4 TDn12a7 TDn24a7 1.302320e-014
Cn12an24a5 TDn12a9 TDn24a9 1.302320e-014
Cn12an24a6 TDn12a11 TDn24a11 1.302320e-014
Cn12an24a7 TDn12a13 TDn24a13 1.302320e-014
Cn12an24a8 TDn12a15 TDn24a15 1.302320e-014
Cn12an24a9 TDn12a17 TDn24a17 1.302320e-014
Cn12an24a10 TDn12a19 TDn24a19 1.302320e-014
Cn12an24a11 TDn12a21 TDn24a21 1.302320e-014
Cn12an24a12 TDn12a23 TDn24a23 1.302320e-014
Cn12an24a13 TDn12a25 TDn24a25 1.302320e-014
Cn12an24a14 TDn12a27 TDn24a27 1.302320e-014
Cn12an24a15 TDn12a29 TDn24a29 1.302320e-014
Cn12an24a16 TDn12a31 TDn24a31 1.302320e-014
Cn12an24a17 TDn12a33 TDn24a33 1.690880e-014
Cn12an25a1 TDn12a1 TDn25a1 1.690880e-014
Cn12an25a2 TDn12a3 TDn25a3 1.302320e-014
Cn12an25a3 TDn12a5 TDn25a5 1.302320e-014
Cn12an25a4 TDn12a7 TDn25a7 1.302320e-014
Cn12an25a5 TDn12a9 TDn25a9 1.302320e-014
Cn12an25a6 TDn12a11 TDn25a11 1.302320e-014
Cn12an25a7 TDn12a13 TDn25a13 1.302320e-014
Cn12an25a8 TDn12a15 TDn25a15 1.302320e-014
Cn12an25a9 TDn12a17 TDn25a17 1.302320e-014
Cn12an25a10 TDn12a19 TDn25a19 1.302320e-014
Cn12an25a11 TDn12a21 TDn25a21 1.302320e-014
Cn12an25a12 TDn12a23 TDn25a23 1.302320e-014
Cn12an25a13 TDn12a25 TDn25a25 1.302320e-014
Cn12an25a14 TDn12a27 TDn25a27 1.302320e-014
Cn12an25a15 TDn12a29 TDn25a29 1.302320e-014
Cn12an25a16 TDn12a31 TDn25a31 1.302320e-014
Cn12an25a17 TDn12a33 TDn25a33 1.690880e-014
Cn12an26a1 TDn12a1 TDn26a1 1.690880e-014
Cn12an26a2 TDn12a3 TDn26a3 1.302320e-014
Cn12an26a3 TDn12a5 TDn26a5 1.302320e-014
Cn12an26a4 TDn12a7 TDn26a7 1.302320e-014
Cn12an26a5 TDn12a9 TDn26a9 1.302320e-014
Cn12an26a6 TDn12a11 TDn26a11 1.302320e-014
Cn12an26a7 TDn12a13 TDn26a13 1.302320e-014
Cn12an26a8 TDn12a15 TDn26a15 1.302320e-014
Cn12an26a9 TDn12a17 TDn26a17 1.302320e-014
Cn12an26a10 TDn12a19 TDn26a19 1.302320e-014
Cn12an26a11 TDn12a21 TDn26a21 1.302320e-014
Cn12an26a12 TDn12a23 TDn26a23 1.302320e-014
Cn12an26a13 TDn12a25 TDn26a25 1.302320e-014
Cn12an26a14 TDn12a27 TDn26a27 1.302320e-014
Cn12an26a15 TDn12a29 TDn26a29 1.302320e-014
Cn12an26a16 TDn12a31 TDn26a31 1.302320e-014
Cn12an26a17 TDn12a33 TDn26a33 1.690880e-014
Cn12an27a1 TDn12a1 TDn27a1 1.690880e-014
Cn12an27a2 TDn12a3 TDn27a3 1.302320e-014
Cn12an27a3 TDn12a5 TDn27a5 1.302320e-014
Cn12an27a4 TDn12a7 TDn27a7 1.302320e-014
Cn12an27a5 TDn12a9 TDn27a9 1.302320e-014
Cn12an27a6 TDn12a11 TDn27a11 1.302320e-014
Cn12an27a7 TDn12a13 TDn27a13 1.302320e-014
Cn12an27a8 TDn12a15 TDn27a15 1.302320e-014
Cn12an27a9 TDn12a17 TDn27a17 1.302320e-014
Cn12an27a10 TDn12a19 TDn27a19 1.302320e-014
Cn12an27a11 TDn12a21 TDn27a21 1.302320e-014
Cn12an27a12 TDn12a23 TDn27a23 1.302320e-014
Cn12an27a13 TDn12a25 TDn27a25 1.302320e-014
Cn12an27a14 TDn12a27 TDn27a27 1.302320e-014
Cn12an27a15 TDn12a29 TDn27a29 1.302320e-014
Cn12an27a16 TDn12a31 TDn27a31 1.302320e-014
Cn12an27a17 TDn12a33 TDn27a33 1.690880e-014
Cn12an28a1 TDn12a1 TDn28a1 1.690880e-014
Cn12an28a2 TDn12a3 TDn28a3 1.302320e-014
Cn12an28a3 TDn12a5 TDn28a5 1.302320e-014
Cn12an28a4 TDn12a7 TDn28a7 1.302320e-014
Cn12an28a5 TDn12a9 TDn28a9 1.302320e-014
Cn12an28a6 TDn12a11 TDn28a11 1.302320e-014
Cn12an28a7 TDn12a13 TDn28a13 1.302320e-014
Cn12an28a8 TDn12a15 TDn28a15 1.302320e-014
Cn12an28a9 TDn12a17 TDn28a17 1.302320e-014
Cn12an28a10 TDn12a19 TDn28a19 1.302320e-014
Cn12an28a11 TDn12a21 TDn28a21 1.302320e-014
Cn12an28a12 TDn12a23 TDn28a23 1.302320e-014
Cn12an28a13 TDn12a25 TDn28a25 1.302320e-014
Cn12an28a14 TDn12a27 TDn28a27 1.302320e-014
Cn12an28a15 TDn12a29 TDn28a29 1.302320e-014
Cn12an28a16 TDn12a31 TDn28a31 1.302320e-014
Cn12an28a17 TDn12a33 TDn28a33 1.690880e-014
Cn12an29a1 TDn12a1 TDn29a1 1.690880e-014
Cn12an29a2 TDn12a3 TDn29a3 1.302320e-014
Cn12an29a3 TDn12a5 TDn29a5 1.302320e-014
Cn12an29a4 TDn12a7 TDn29a7 1.302320e-014
Cn12an29a5 TDn12a9 TDn29a9 1.302320e-014
Cn12an29a6 TDn12a11 TDn29a11 1.302320e-014
Cn12an29a7 TDn12a13 TDn29a13 1.302320e-014
Cn12an29a8 TDn12a15 TDn29a15 1.302320e-014
Cn12an29a9 TDn12a17 TDn29a17 1.302320e-014
Cn12an29a10 TDn12a19 TDn29a19 1.302320e-014
Cn12an29a11 TDn12a21 TDn29a21 1.302320e-014
Cn12an29a12 TDn12a23 TDn29a23 1.302320e-014
Cn12an29a13 TDn12a25 TDn29a25 1.302320e-014
Cn12an29a14 TDn12a27 TDn29a27 1.302320e-014
Cn12an29a15 TDn12a29 TDn29a29 1.302320e-014
Cn12an29a16 TDn12a31 TDn29a31 1.302320e-014
Cn12an29a17 TDn12a33 TDn29a33 1.690880e-014
Cn12an30a1 TDn12a1 TDn30a1 1.690880e-014
Cn12an30a2 TDn12a3 TDn30a3 1.302320e-014
Cn12an30a3 TDn12a5 TDn30a5 1.302320e-014
Cn12an30a4 TDn12a7 TDn30a7 1.302320e-014
Cn12an30a5 TDn12a9 TDn30a9 1.302320e-014
Cn12an30a6 TDn12a11 TDn30a11 1.302320e-014
Cn12an30a7 TDn12a13 TDn30a13 1.302320e-014
Cn12an30a8 TDn12a15 TDn30a15 1.302320e-014
Cn12an30a9 TDn12a17 TDn30a17 1.302320e-014
Cn12an30a10 TDn12a19 TDn30a19 1.302320e-014
Cn12an30a11 TDn12a21 TDn30a21 1.302320e-014
Cn12an30a12 TDn12a23 TDn30a23 1.302320e-014
Cn12an30a13 TDn12a25 TDn30a25 1.302320e-014
Cn12an30a14 TDn12a27 TDn30a27 1.302320e-014
Cn12an30a15 TDn12a29 TDn30a29 1.302320e-014
Cn12an30a16 TDn12a31 TDn30a31 1.302320e-014
Cn12an30a17 TDn12a33 TDn30a33 1.690880e-014
Cn12an31a1 TDn12a1 TDn31a1 1.690880e-014
Cn12an31a2 TDn12a3 TDn31a3 1.302320e-014
Cn12an31a3 TDn12a5 TDn31a5 1.302320e-014
Cn12an31a4 TDn12a7 TDn31a7 1.302320e-014
Cn12an31a5 TDn12a9 TDn31a9 1.302320e-014
Cn12an31a6 TDn12a11 TDn31a11 1.302320e-014
Cn12an31a7 TDn12a13 TDn31a13 1.302320e-014
Cn12an31a8 TDn12a15 TDn31a15 1.302320e-014
Cn12an31a9 TDn12a17 TDn31a17 1.302320e-014
Cn12an31a10 TDn12a19 TDn31a19 1.302320e-014
Cn12an31a11 TDn12a21 TDn31a21 1.302320e-014
Cn12an31a12 TDn12a23 TDn31a23 1.302320e-014
Cn12an31a13 TDn12a25 TDn31a25 1.302320e-014
Cn12an31a14 TDn12a27 TDn31a27 1.302320e-014
Cn12an31a15 TDn12a29 TDn31a29 1.302320e-014
Cn12an31a16 TDn12a31 TDn31a31 1.302320e-014
Cn12an31a17 TDn12a33 TDn31a33 1.690880e-014
Cn12an32a1 TDn12a1 TDn32a1 1.690880e-014
Cn12an32a2 TDn12a3 TDn32a3 1.302320e-014
Cn12an32a3 TDn12a5 TDn32a5 1.302320e-014
Cn12an32a4 TDn12a7 TDn32a7 1.302320e-014
Cn12an32a5 TDn12a9 TDn32a9 1.302320e-014
Cn12an32a6 TDn12a11 TDn32a11 1.302320e-014
Cn12an32a7 TDn12a13 TDn32a13 1.302320e-014
Cn12an32a8 TDn12a15 TDn32a15 1.302320e-014
Cn12an32a9 TDn12a17 TDn32a17 1.302320e-014
Cn12an32a10 TDn12a19 TDn32a19 1.302320e-014
Cn12an32a11 TDn12a21 TDn32a21 1.302320e-014
Cn12an32a12 TDn12a23 TDn32a23 1.302320e-014
Cn12an32a13 TDn12a25 TDn32a25 1.302320e-014
Cn12an32a14 TDn12a27 TDn32a27 1.302320e-014
Cn12an32a15 TDn12a29 TDn32a29 1.302320e-014
Cn12an32a16 TDn12a31 TDn32a31 1.302320e-014
Cn12an32a17 TDn12a33 TDn32a33 1.690880e-014
Cn12anva1 TDn12a1 TDnva1 1.690880e-014
Cn12anva2 TDn12a3 TDnva3 1.690880e-014
Cn12anva3 TDn12a5 TDnva5 1.690880e-014
Cn12anva4 TDn12a7 TDnva7 1.690880e-014
Cn12anva5 TDn12a9 TDnva9 1.690880e-014
Cn12anva6 TDn12a11 TDnva11 1.690880e-014
Cn12anva7 TDn12a13 TDnva13 1.690880e-014
Cn12anva8 TDn12a15 TDnva15 1.690880e-014
Cn12anva9 TDn12a17 TDnva17 1.690880e-014
Cn12anva10 TDn12a19 TDnva19 1.690880e-014
Cn12anva11 TDn12a21 TDnva21 1.690880e-014
Cn12anva12 TDn12a23 TDnva23 1.690880e-014
Cn12anva13 TDn12a25 TDnva25 1.690880e-014
Cn12anva14 TDn12a27 TDnva27 1.690880e-014
Cn12anva15 TDn12a29 TDnva29 1.690880e-014
Cn12anva16 TDn12a31 TDnva31 1.690880e-014
Cn12anva17 TDn12a33 TDnva33 1.690880e-014
Cn13an14a1 TDn13a1 TDn14a1 1.690880e-014
Cn13an14a2 TDn13a3 TDn14a3 1.302320e-014
Cn13an14a3 TDn13a5 TDn14a5 1.302320e-014
Cn13an14a4 TDn13a7 TDn14a7 1.302320e-014
Cn13an14a5 TDn13a9 TDn14a9 1.302320e-014
Cn13an14a6 TDn13a11 TDn14a11 1.302320e-014
Cn13an14a7 TDn13a13 TDn14a13 1.302320e-014
Cn13an14a8 TDn13a15 TDn14a15 1.302320e-014
Cn13an14a9 TDn13a17 TDn14a17 1.302320e-014
Cn13an14a10 TDn13a19 TDn14a19 1.302320e-014
Cn13an14a11 TDn13a21 TDn14a21 1.302320e-014
Cn13an14a12 TDn13a23 TDn14a23 1.302320e-014
Cn13an14a13 TDn13a25 TDn14a25 1.302320e-014
Cn13an14a14 TDn13a27 TDn14a27 1.302320e-014
Cn13an14a15 TDn13a29 TDn14a29 1.302320e-014
Cn13an14a16 TDn13a31 TDn14a31 1.302320e-014
Cn13an14a17 TDn13a33 TDn14a33 1.690880e-014
Cn13an15a1 TDn13a1 TDn15a1 1.690880e-014
Cn13an15a2 TDn13a3 TDn15a3 1.302320e-014
Cn13an15a3 TDn13a5 TDn15a5 1.302320e-014
Cn13an15a4 TDn13a7 TDn15a7 1.302320e-014
Cn13an15a5 TDn13a9 TDn15a9 1.302320e-014
Cn13an15a6 TDn13a11 TDn15a11 1.302320e-014
Cn13an15a7 TDn13a13 TDn15a13 1.302320e-014
Cn13an15a8 TDn13a15 TDn15a15 1.302320e-014
Cn13an15a9 TDn13a17 TDn15a17 1.302320e-014
Cn13an15a10 TDn13a19 TDn15a19 1.302320e-014
Cn13an15a11 TDn13a21 TDn15a21 1.302320e-014
Cn13an15a12 TDn13a23 TDn15a23 1.302320e-014
Cn13an15a13 TDn13a25 TDn15a25 1.302320e-014
Cn13an15a14 TDn13a27 TDn15a27 1.302320e-014
Cn13an15a15 TDn13a29 TDn15a29 1.302320e-014
Cn13an15a16 TDn13a31 TDn15a31 1.302320e-014
Cn13an15a17 TDn13a33 TDn15a33 1.690880e-014
Cn13an16a1 TDn13a1 TDn16a1 1.690880e-014
Cn13an16a2 TDn13a3 TDn16a3 1.302320e-014
Cn13an16a3 TDn13a5 TDn16a5 1.302320e-014
Cn13an16a4 TDn13a7 TDn16a7 1.302320e-014
Cn13an16a5 TDn13a9 TDn16a9 1.302320e-014
Cn13an16a6 TDn13a11 TDn16a11 1.302320e-014
Cn13an16a7 TDn13a13 TDn16a13 1.302320e-014
Cn13an16a8 TDn13a15 TDn16a15 1.302320e-014
Cn13an16a9 TDn13a17 TDn16a17 1.302320e-014
Cn13an16a10 TDn13a19 TDn16a19 1.302320e-014
Cn13an16a11 TDn13a21 TDn16a21 1.302320e-014
Cn13an16a12 TDn13a23 TDn16a23 1.302320e-014
Cn13an16a13 TDn13a25 TDn16a25 1.302320e-014
Cn13an16a14 TDn13a27 TDn16a27 1.302320e-014
Cn13an16a15 TDn13a29 TDn16a29 1.302320e-014
Cn13an16a16 TDn13a31 TDn16a31 1.302320e-014
Cn13an16a17 TDn13a33 TDn16a33 1.690880e-014
Cn13an17a1 TDn13a1 TDn17a1 1.690880e-014
Cn13an17a2 TDn13a3 TDn17a3 1.302320e-014
Cn13an17a3 TDn13a5 TDn17a5 1.302320e-014
Cn13an17a4 TDn13a7 TDn17a7 1.302320e-014
Cn13an17a5 TDn13a9 TDn17a9 1.302320e-014
Cn13an17a6 TDn13a11 TDn17a11 1.302320e-014
Cn13an17a7 TDn13a13 TDn17a13 1.302320e-014
Cn13an17a8 TDn13a15 TDn17a15 1.302320e-014
Cn13an17a9 TDn13a17 TDn17a17 1.302320e-014
Cn13an17a10 TDn13a19 TDn17a19 1.302320e-014
Cn13an17a11 TDn13a21 TDn17a21 1.302320e-014
Cn13an17a12 TDn13a23 TDn17a23 1.302320e-014
Cn13an17a13 TDn13a25 TDn17a25 1.302320e-014
Cn13an17a14 TDn13a27 TDn17a27 1.302320e-014
Cn13an17a15 TDn13a29 TDn17a29 1.302320e-014
Cn13an17a16 TDn13a31 TDn17a31 1.302320e-014
Cn13an17a17 TDn13a33 TDn17a33 1.690880e-014
Cn13an18a1 TDn13a1 TDn18a1 1.690880e-014
Cn13an18a2 TDn13a3 TDn18a3 1.302320e-014
Cn13an18a3 TDn13a5 TDn18a5 1.302320e-014
Cn13an18a4 TDn13a7 TDn18a7 1.302320e-014
Cn13an18a5 TDn13a9 TDn18a9 1.302320e-014
Cn13an18a6 TDn13a11 TDn18a11 1.302320e-014
Cn13an18a7 TDn13a13 TDn18a13 1.302320e-014
Cn13an18a8 TDn13a15 TDn18a15 1.302320e-014
Cn13an18a9 TDn13a17 TDn18a17 1.302320e-014
Cn13an18a10 TDn13a19 TDn18a19 1.302320e-014
Cn13an18a11 TDn13a21 TDn18a21 1.302320e-014
Cn13an18a12 TDn13a23 TDn18a23 1.302320e-014
Cn13an18a13 TDn13a25 TDn18a25 1.302320e-014
Cn13an18a14 TDn13a27 TDn18a27 1.302320e-014
Cn13an18a15 TDn13a29 TDn18a29 1.302320e-014
Cn13an18a16 TDn13a31 TDn18a31 1.302320e-014
Cn13an18a17 TDn13a33 TDn18a33 1.690880e-014
Cn13an19a1 TDn13a1 TDn19a1 1.690880e-014
Cn13an19a2 TDn13a3 TDn19a3 1.302320e-014
Cn13an19a3 TDn13a5 TDn19a5 1.302320e-014
Cn13an19a4 TDn13a7 TDn19a7 1.302320e-014
Cn13an19a5 TDn13a9 TDn19a9 1.302320e-014
Cn13an19a6 TDn13a11 TDn19a11 1.302320e-014
Cn13an19a7 TDn13a13 TDn19a13 1.302320e-014
Cn13an19a8 TDn13a15 TDn19a15 1.302320e-014
Cn13an19a9 TDn13a17 TDn19a17 1.302320e-014
Cn13an19a10 TDn13a19 TDn19a19 1.302320e-014
Cn13an19a11 TDn13a21 TDn19a21 1.302320e-014
Cn13an19a12 TDn13a23 TDn19a23 1.302320e-014
Cn13an19a13 TDn13a25 TDn19a25 1.302320e-014
Cn13an19a14 TDn13a27 TDn19a27 1.302320e-014
Cn13an19a15 TDn13a29 TDn19a29 1.302320e-014
Cn13an19a16 TDn13a31 TDn19a31 1.302320e-014
Cn13an19a17 TDn13a33 TDn19a33 1.690880e-014
Cn13an20a1 TDn13a1 TDn20a1 1.690880e-014
Cn13an20a2 TDn13a3 TDn20a3 1.302320e-014
Cn13an20a3 TDn13a5 TDn20a5 1.302320e-014
Cn13an20a4 TDn13a7 TDn20a7 1.302320e-014
Cn13an20a5 TDn13a9 TDn20a9 1.302320e-014
Cn13an20a6 TDn13a11 TDn20a11 1.302320e-014
Cn13an20a7 TDn13a13 TDn20a13 1.302320e-014
Cn13an20a8 TDn13a15 TDn20a15 1.302320e-014
Cn13an20a9 TDn13a17 TDn20a17 1.302320e-014
Cn13an20a10 TDn13a19 TDn20a19 1.302320e-014
Cn13an20a11 TDn13a21 TDn20a21 1.302320e-014
Cn13an20a12 TDn13a23 TDn20a23 1.302320e-014
Cn13an20a13 TDn13a25 TDn20a25 1.302320e-014
Cn13an20a14 TDn13a27 TDn20a27 1.302320e-014
Cn13an20a15 TDn13a29 TDn20a29 1.302320e-014
Cn13an20a16 TDn13a31 TDn20a31 1.302320e-014
Cn13an20a17 TDn13a33 TDn20a33 1.690880e-014
Cn13an21a1 TDn13a1 TDn21a1 1.690880e-014
Cn13an21a2 TDn13a3 TDn21a3 1.302320e-014
Cn13an21a3 TDn13a5 TDn21a5 1.302320e-014
Cn13an21a4 TDn13a7 TDn21a7 1.302320e-014
Cn13an21a5 TDn13a9 TDn21a9 1.302320e-014
Cn13an21a6 TDn13a11 TDn21a11 1.302320e-014
Cn13an21a7 TDn13a13 TDn21a13 1.302320e-014
Cn13an21a8 TDn13a15 TDn21a15 1.302320e-014
Cn13an21a9 TDn13a17 TDn21a17 1.302320e-014
Cn13an21a10 TDn13a19 TDn21a19 1.302320e-014
Cn13an21a11 TDn13a21 TDn21a21 1.302320e-014
Cn13an21a12 TDn13a23 TDn21a23 1.302320e-014
Cn13an21a13 TDn13a25 TDn21a25 1.302320e-014
Cn13an21a14 TDn13a27 TDn21a27 1.302320e-014
Cn13an21a15 TDn13a29 TDn21a29 1.302320e-014
Cn13an21a16 TDn13a31 TDn21a31 1.302320e-014
Cn13an21a17 TDn13a33 TDn21a33 1.690880e-014
Cn13an22a1 TDn13a1 TDn22a1 1.690880e-014
Cn13an22a2 TDn13a3 TDn22a3 1.302320e-014
Cn13an22a3 TDn13a5 TDn22a5 1.302320e-014
Cn13an22a4 TDn13a7 TDn22a7 1.302320e-014
Cn13an22a5 TDn13a9 TDn22a9 1.302320e-014
Cn13an22a6 TDn13a11 TDn22a11 1.302320e-014
Cn13an22a7 TDn13a13 TDn22a13 1.302320e-014
Cn13an22a8 TDn13a15 TDn22a15 1.302320e-014
Cn13an22a9 TDn13a17 TDn22a17 1.302320e-014
Cn13an22a10 TDn13a19 TDn22a19 1.302320e-014
Cn13an22a11 TDn13a21 TDn22a21 1.302320e-014
Cn13an22a12 TDn13a23 TDn22a23 1.302320e-014
Cn13an22a13 TDn13a25 TDn22a25 1.302320e-014
Cn13an22a14 TDn13a27 TDn22a27 1.302320e-014
Cn13an22a15 TDn13a29 TDn22a29 1.302320e-014
Cn13an22a16 TDn13a31 TDn22a31 1.302320e-014
Cn13an22a17 TDn13a33 TDn22a33 1.690880e-014
Cn13an23a1 TDn13a1 TDn23a1 1.690880e-014
Cn13an23a2 TDn13a3 TDn23a3 1.302320e-014
Cn13an23a3 TDn13a5 TDn23a5 1.302320e-014
Cn13an23a4 TDn13a7 TDn23a7 1.302320e-014
Cn13an23a5 TDn13a9 TDn23a9 1.302320e-014
Cn13an23a6 TDn13a11 TDn23a11 1.302320e-014
Cn13an23a7 TDn13a13 TDn23a13 1.302320e-014
Cn13an23a8 TDn13a15 TDn23a15 1.302320e-014
Cn13an23a9 TDn13a17 TDn23a17 1.302320e-014
Cn13an23a10 TDn13a19 TDn23a19 1.302320e-014
Cn13an23a11 TDn13a21 TDn23a21 1.302320e-014
Cn13an23a12 TDn13a23 TDn23a23 1.302320e-014
Cn13an23a13 TDn13a25 TDn23a25 1.302320e-014
Cn13an23a14 TDn13a27 TDn23a27 1.302320e-014
Cn13an23a15 TDn13a29 TDn23a29 1.302320e-014
Cn13an23a16 TDn13a31 TDn23a31 1.302320e-014
Cn13an23a17 TDn13a33 TDn23a33 1.690880e-014
Cn13an24a1 TDn13a1 TDn24a1 1.690880e-014
Cn13an24a2 TDn13a3 TDn24a3 1.302320e-014
Cn13an24a3 TDn13a5 TDn24a5 1.302320e-014
Cn13an24a4 TDn13a7 TDn24a7 1.302320e-014
Cn13an24a5 TDn13a9 TDn24a9 1.302320e-014
Cn13an24a6 TDn13a11 TDn24a11 1.302320e-014
Cn13an24a7 TDn13a13 TDn24a13 1.302320e-014
Cn13an24a8 TDn13a15 TDn24a15 1.302320e-014
Cn13an24a9 TDn13a17 TDn24a17 1.302320e-014
Cn13an24a10 TDn13a19 TDn24a19 1.302320e-014
Cn13an24a11 TDn13a21 TDn24a21 1.302320e-014
Cn13an24a12 TDn13a23 TDn24a23 1.302320e-014
Cn13an24a13 TDn13a25 TDn24a25 1.302320e-014
Cn13an24a14 TDn13a27 TDn24a27 1.302320e-014
Cn13an24a15 TDn13a29 TDn24a29 1.302320e-014
Cn13an24a16 TDn13a31 TDn24a31 1.302320e-014
Cn13an24a17 TDn13a33 TDn24a33 1.690880e-014
Cn13an25a1 TDn13a1 TDn25a1 1.690880e-014
Cn13an25a2 TDn13a3 TDn25a3 1.302320e-014
Cn13an25a3 TDn13a5 TDn25a5 1.302320e-014
Cn13an25a4 TDn13a7 TDn25a7 1.302320e-014
Cn13an25a5 TDn13a9 TDn25a9 1.302320e-014
Cn13an25a6 TDn13a11 TDn25a11 1.302320e-014
Cn13an25a7 TDn13a13 TDn25a13 1.302320e-014
Cn13an25a8 TDn13a15 TDn25a15 1.302320e-014
Cn13an25a9 TDn13a17 TDn25a17 1.302320e-014
Cn13an25a10 TDn13a19 TDn25a19 1.302320e-014
Cn13an25a11 TDn13a21 TDn25a21 1.302320e-014
Cn13an25a12 TDn13a23 TDn25a23 1.302320e-014
Cn13an25a13 TDn13a25 TDn25a25 1.302320e-014
Cn13an25a14 TDn13a27 TDn25a27 1.302320e-014
Cn13an25a15 TDn13a29 TDn25a29 1.302320e-014
Cn13an25a16 TDn13a31 TDn25a31 1.302320e-014
Cn13an25a17 TDn13a33 TDn25a33 1.690880e-014
Cn13an26a1 TDn13a1 TDn26a1 1.690880e-014
Cn13an26a2 TDn13a3 TDn26a3 1.302320e-014
Cn13an26a3 TDn13a5 TDn26a5 1.302320e-014
Cn13an26a4 TDn13a7 TDn26a7 1.302320e-014
Cn13an26a5 TDn13a9 TDn26a9 1.302320e-014
Cn13an26a6 TDn13a11 TDn26a11 1.302320e-014
Cn13an26a7 TDn13a13 TDn26a13 1.302320e-014
Cn13an26a8 TDn13a15 TDn26a15 1.302320e-014
Cn13an26a9 TDn13a17 TDn26a17 1.302320e-014
Cn13an26a10 TDn13a19 TDn26a19 1.302320e-014
Cn13an26a11 TDn13a21 TDn26a21 1.302320e-014
Cn13an26a12 TDn13a23 TDn26a23 1.302320e-014
Cn13an26a13 TDn13a25 TDn26a25 1.302320e-014
Cn13an26a14 TDn13a27 TDn26a27 1.302320e-014
Cn13an26a15 TDn13a29 TDn26a29 1.302320e-014
Cn13an26a16 TDn13a31 TDn26a31 1.302320e-014
Cn13an26a17 TDn13a33 TDn26a33 1.690880e-014
Cn13an27a1 TDn13a1 TDn27a1 1.690880e-014
Cn13an27a2 TDn13a3 TDn27a3 1.302320e-014
Cn13an27a3 TDn13a5 TDn27a5 1.302320e-014
Cn13an27a4 TDn13a7 TDn27a7 1.302320e-014
Cn13an27a5 TDn13a9 TDn27a9 1.302320e-014
Cn13an27a6 TDn13a11 TDn27a11 1.302320e-014
Cn13an27a7 TDn13a13 TDn27a13 1.302320e-014
Cn13an27a8 TDn13a15 TDn27a15 1.302320e-014
Cn13an27a9 TDn13a17 TDn27a17 1.302320e-014
Cn13an27a10 TDn13a19 TDn27a19 1.302320e-014
Cn13an27a11 TDn13a21 TDn27a21 1.302320e-014
Cn13an27a12 TDn13a23 TDn27a23 1.302320e-014
Cn13an27a13 TDn13a25 TDn27a25 1.302320e-014
Cn13an27a14 TDn13a27 TDn27a27 1.302320e-014
Cn13an27a15 TDn13a29 TDn27a29 1.302320e-014
Cn13an27a16 TDn13a31 TDn27a31 1.302320e-014
Cn13an27a17 TDn13a33 TDn27a33 1.690880e-014
Cn13an28a1 TDn13a1 TDn28a1 1.690880e-014
Cn13an28a2 TDn13a3 TDn28a3 1.302320e-014
Cn13an28a3 TDn13a5 TDn28a5 1.302320e-014
Cn13an28a4 TDn13a7 TDn28a7 1.302320e-014
Cn13an28a5 TDn13a9 TDn28a9 1.302320e-014
Cn13an28a6 TDn13a11 TDn28a11 1.302320e-014
Cn13an28a7 TDn13a13 TDn28a13 1.302320e-014
Cn13an28a8 TDn13a15 TDn28a15 1.302320e-014
Cn13an28a9 TDn13a17 TDn28a17 1.302320e-014
Cn13an28a10 TDn13a19 TDn28a19 1.302320e-014
Cn13an28a11 TDn13a21 TDn28a21 1.302320e-014
Cn13an28a12 TDn13a23 TDn28a23 1.302320e-014
Cn13an28a13 TDn13a25 TDn28a25 1.302320e-014
Cn13an28a14 TDn13a27 TDn28a27 1.302320e-014
Cn13an28a15 TDn13a29 TDn28a29 1.302320e-014
Cn13an28a16 TDn13a31 TDn28a31 1.302320e-014
Cn13an28a17 TDn13a33 TDn28a33 1.690880e-014
Cn13an29a1 TDn13a1 TDn29a1 1.690880e-014
Cn13an29a2 TDn13a3 TDn29a3 1.302320e-014
Cn13an29a3 TDn13a5 TDn29a5 1.302320e-014
Cn13an29a4 TDn13a7 TDn29a7 1.302320e-014
Cn13an29a5 TDn13a9 TDn29a9 1.302320e-014
Cn13an29a6 TDn13a11 TDn29a11 1.302320e-014
Cn13an29a7 TDn13a13 TDn29a13 1.302320e-014
Cn13an29a8 TDn13a15 TDn29a15 1.302320e-014
Cn13an29a9 TDn13a17 TDn29a17 1.302320e-014
Cn13an29a10 TDn13a19 TDn29a19 1.302320e-014
Cn13an29a11 TDn13a21 TDn29a21 1.302320e-014
Cn13an29a12 TDn13a23 TDn29a23 1.302320e-014
Cn13an29a13 TDn13a25 TDn29a25 1.302320e-014
Cn13an29a14 TDn13a27 TDn29a27 1.302320e-014
Cn13an29a15 TDn13a29 TDn29a29 1.302320e-014
Cn13an29a16 TDn13a31 TDn29a31 1.302320e-014
Cn13an29a17 TDn13a33 TDn29a33 1.690880e-014
Cn13an30a1 TDn13a1 TDn30a1 1.690880e-014
Cn13an30a2 TDn13a3 TDn30a3 1.302320e-014
Cn13an30a3 TDn13a5 TDn30a5 1.302320e-014
Cn13an30a4 TDn13a7 TDn30a7 1.302320e-014
Cn13an30a5 TDn13a9 TDn30a9 1.302320e-014
Cn13an30a6 TDn13a11 TDn30a11 1.302320e-014
Cn13an30a7 TDn13a13 TDn30a13 1.302320e-014
Cn13an30a8 TDn13a15 TDn30a15 1.302320e-014
Cn13an30a9 TDn13a17 TDn30a17 1.302320e-014
Cn13an30a10 TDn13a19 TDn30a19 1.302320e-014
Cn13an30a11 TDn13a21 TDn30a21 1.302320e-014
Cn13an30a12 TDn13a23 TDn30a23 1.302320e-014
Cn13an30a13 TDn13a25 TDn30a25 1.302320e-014
Cn13an30a14 TDn13a27 TDn30a27 1.302320e-014
Cn13an30a15 TDn13a29 TDn30a29 1.302320e-014
Cn13an30a16 TDn13a31 TDn30a31 1.302320e-014
Cn13an30a17 TDn13a33 TDn30a33 1.690880e-014
Cn13an31a1 TDn13a1 TDn31a1 1.690880e-014
Cn13an31a2 TDn13a3 TDn31a3 1.302320e-014
Cn13an31a3 TDn13a5 TDn31a5 1.302320e-014
Cn13an31a4 TDn13a7 TDn31a7 1.302320e-014
Cn13an31a5 TDn13a9 TDn31a9 1.302320e-014
Cn13an31a6 TDn13a11 TDn31a11 1.302320e-014
Cn13an31a7 TDn13a13 TDn31a13 1.302320e-014
Cn13an31a8 TDn13a15 TDn31a15 1.302320e-014
Cn13an31a9 TDn13a17 TDn31a17 1.302320e-014
Cn13an31a10 TDn13a19 TDn31a19 1.302320e-014
Cn13an31a11 TDn13a21 TDn31a21 1.302320e-014
Cn13an31a12 TDn13a23 TDn31a23 1.302320e-014
Cn13an31a13 TDn13a25 TDn31a25 1.302320e-014
Cn13an31a14 TDn13a27 TDn31a27 1.302320e-014
Cn13an31a15 TDn13a29 TDn31a29 1.302320e-014
Cn13an31a16 TDn13a31 TDn31a31 1.302320e-014
Cn13an31a17 TDn13a33 TDn31a33 1.690880e-014
Cn13an32a1 TDn13a1 TDn32a1 1.690880e-014
Cn13an32a2 TDn13a3 TDn32a3 1.302320e-014
Cn13an32a3 TDn13a5 TDn32a5 1.302320e-014
Cn13an32a4 TDn13a7 TDn32a7 1.302320e-014
Cn13an32a5 TDn13a9 TDn32a9 1.302320e-014
Cn13an32a6 TDn13a11 TDn32a11 1.302320e-014
Cn13an32a7 TDn13a13 TDn32a13 1.302320e-014
Cn13an32a8 TDn13a15 TDn32a15 1.302320e-014
Cn13an32a9 TDn13a17 TDn32a17 1.302320e-014
Cn13an32a10 TDn13a19 TDn32a19 1.302320e-014
Cn13an32a11 TDn13a21 TDn32a21 1.302320e-014
Cn13an32a12 TDn13a23 TDn32a23 1.302320e-014
Cn13an32a13 TDn13a25 TDn32a25 1.302320e-014
Cn13an32a14 TDn13a27 TDn32a27 1.302320e-014
Cn13an32a15 TDn13a29 TDn32a29 1.302320e-014
Cn13an32a16 TDn13a31 TDn32a31 1.302320e-014
Cn13an32a17 TDn13a33 TDn32a33 1.690880e-014
Cn13anva1 TDn13a1 TDnva1 1.690880e-014
Cn13anva2 TDn13a3 TDnva3 1.690880e-014
Cn13anva3 TDn13a5 TDnva5 1.690880e-014
Cn13anva4 TDn13a7 TDnva7 1.690880e-014
Cn13anva5 TDn13a9 TDnva9 1.690880e-014
Cn13anva6 TDn13a11 TDnva11 1.690880e-014
Cn13anva7 TDn13a13 TDnva13 1.690880e-014
Cn13anva8 TDn13a15 TDnva15 1.690880e-014
Cn13anva9 TDn13a17 TDnva17 1.690880e-014
Cn13anva10 TDn13a19 TDnva19 1.690880e-014
Cn13anva11 TDn13a21 TDnva21 1.690880e-014
Cn13anva12 TDn13a23 TDnva23 1.690880e-014
Cn13anva13 TDn13a25 TDnva25 1.690880e-014
Cn13anva14 TDn13a27 TDnva27 1.690880e-014
Cn13anva15 TDn13a29 TDnva29 1.690880e-014
Cn13anva16 TDn13a31 TDnva31 1.690880e-014
Cn13anva17 TDn13a33 TDnva33 1.690880e-014
Cn14an15a1 TDn14a1 TDn15a1 1.690880e-014
Cn14an15a2 TDn14a3 TDn15a3 1.302320e-014
Cn14an15a3 TDn14a5 TDn15a5 1.302320e-014
Cn14an15a4 TDn14a7 TDn15a7 1.302320e-014
Cn14an15a5 TDn14a9 TDn15a9 1.302320e-014
Cn14an15a6 TDn14a11 TDn15a11 1.302320e-014
Cn14an15a7 TDn14a13 TDn15a13 1.302320e-014
Cn14an15a8 TDn14a15 TDn15a15 1.302320e-014
Cn14an15a9 TDn14a17 TDn15a17 1.302320e-014
Cn14an15a10 TDn14a19 TDn15a19 1.302320e-014
Cn14an15a11 TDn14a21 TDn15a21 1.302320e-014
Cn14an15a12 TDn14a23 TDn15a23 1.302320e-014
Cn14an15a13 TDn14a25 TDn15a25 1.302320e-014
Cn14an15a14 TDn14a27 TDn15a27 1.302320e-014
Cn14an15a15 TDn14a29 TDn15a29 1.302320e-014
Cn14an15a16 TDn14a31 TDn15a31 1.302320e-014
Cn14an15a17 TDn14a33 TDn15a33 1.690880e-014
Cn14an16a1 TDn14a1 TDn16a1 1.690880e-014
Cn14an16a2 TDn14a3 TDn16a3 1.302320e-014
Cn14an16a3 TDn14a5 TDn16a5 1.302320e-014
Cn14an16a4 TDn14a7 TDn16a7 1.302320e-014
Cn14an16a5 TDn14a9 TDn16a9 1.302320e-014
Cn14an16a6 TDn14a11 TDn16a11 1.302320e-014
Cn14an16a7 TDn14a13 TDn16a13 1.302320e-014
Cn14an16a8 TDn14a15 TDn16a15 1.302320e-014
Cn14an16a9 TDn14a17 TDn16a17 1.302320e-014
Cn14an16a10 TDn14a19 TDn16a19 1.302320e-014
Cn14an16a11 TDn14a21 TDn16a21 1.302320e-014
Cn14an16a12 TDn14a23 TDn16a23 1.302320e-014
Cn14an16a13 TDn14a25 TDn16a25 1.302320e-014
Cn14an16a14 TDn14a27 TDn16a27 1.302320e-014
Cn14an16a15 TDn14a29 TDn16a29 1.302320e-014
Cn14an16a16 TDn14a31 TDn16a31 1.302320e-014
Cn14an16a17 TDn14a33 TDn16a33 1.690880e-014
Cn14an17a1 TDn14a1 TDn17a1 1.690880e-014
Cn14an17a2 TDn14a3 TDn17a3 1.302320e-014
Cn14an17a3 TDn14a5 TDn17a5 1.302320e-014
Cn14an17a4 TDn14a7 TDn17a7 1.302320e-014
Cn14an17a5 TDn14a9 TDn17a9 1.302320e-014
Cn14an17a6 TDn14a11 TDn17a11 1.302320e-014
Cn14an17a7 TDn14a13 TDn17a13 1.302320e-014
Cn14an17a8 TDn14a15 TDn17a15 1.302320e-014
Cn14an17a9 TDn14a17 TDn17a17 1.302320e-014
Cn14an17a10 TDn14a19 TDn17a19 1.302320e-014
Cn14an17a11 TDn14a21 TDn17a21 1.302320e-014
Cn14an17a12 TDn14a23 TDn17a23 1.302320e-014
Cn14an17a13 TDn14a25 TDn17a25 1.302320e-014
Cn14an17a14 TDn14a27 TDn17a27 1.302320e-014
Cn14an17a15 TDn14a29 TDn17a29 1.302320e-014
Cn14an17a16 TDn14a31 TDn17a31 1.302320e-014
Cn14an17a17 TDn14a33 TDn17a33 1.690880e-014
Cn14an18a1 TDn14a1 TDn18a1 1.690880e-014
Cn14an18a2 TDn14a3 TDn18a3 1.302320e-014
Cn14an18a3 TDn14a5 TDn18a5 1.302320e-014
Cn14an18a4 TDn14a7 TDn18a7 1.302320e-014
Cn14an18a5 TDn14a9 TDn18a9 1.302320e-014
Cn14an18a6 TDn14a11 TDn18a11 1.302320e-014
Cn14an18a7 TDn14a13 TDn18a13 1.302320e-014
Cn14an18a8 TDn14a15 TDn18a15 1.302320e-014
Cn14an18a9 TDn14a17 TDn18a17 1.302320e-014
Cn14an18a10 TDn14a19 TDn18a19 1.302320e-014
Cn14an18a11 TDn14a21 TDn18a21 1.302320e-014
Cn14an18a12 TDn14a23 TDn18a23 1.302320e-014
Cn14an18a13 TDn14a25 TDn18a25 1.302320e-014
Cn14an18a14 TDn14a27 TDn18a27 1.302320e-014
Cn14an18a15 TDn14a29 TDn18a29 1.302320e-014
Cn14an18a16 TDn14a31 TDn18a31 1.302320e-014
Cn14an18a17 TDn14a33 TDn18a33 1.690880e-014
Cn14an19a1 TDn14a1 TDn19a1 1.690880e-014
Cn14an19a2 TDn14a3 TDn19a3 1.302320e-014
Cn14an19a3 TDn14a5 TDn19a5 1.302320e-014
Cn14an19a4 TDn14a7 TDn19a7 1.302320e-014
Cn14an19a5 TDn14a9 TDn19a9 1.302320e-014
Cn14an19a6 TDn14a11 TDn19a11 1.302320e-014
Cn14an19a7 TDn14a13 TDn19a13 1.302320e-014
Cn14an19a8 TDn14a15 TDn19a15 1.302320e-014
Cn14an19a9 TDn14a17 TDn19a17 1.302320e-014
Cn14an19a10 TDn14a19 TDn19a19 1.302320e-014
Cn14an19a11 TDn14a21 TDn19a21 1.302320e-014
Cn14an19a12 TDn14a23 TDn19a23 1.302320e-014
Cn14an19a13 TDn14a25 TDn19a25 1.302320e-014
Cn14an19a14 TDn14a27 TDn19a27 1.302320e-014
Cn14an19a15 TDn14a29 TDn19a29 1.302320e-014
Cn14an19a16 TDn14a31 TDn19a31 1.302320e-014
Cn14an19a17 TDn14a33 TDn19a33 1.690880e-014
Cn14an20a1 TDn14a1 TDn20a1 1.690880e-014
Cn14an20a2 TDn14a3 TDn20a3 1.302320e-014
Cn14an20a3 TDn14a5 TDn20a5 1.302320e-014
Cn14an20a4 TDn14a7 TDn20a7 1.302320e-014
Cn14an20a5 TDn14a9 TDn20a9 1.302320e-014
Cn14an20a6 TDn14a11 TDn20a11 1.302320e-014
Cn14an20a7 TDn14a13 TDn20a13 1.302320e-014
Cn14an20a8 TDn14a15 TDn20a15 1.302320e-014
Cn14an20a9 TDn14a17 TDn20a17 1.302320e-014
Cn14an20a10 TDn14a19 TDn20a19 1.302320e-014
Cn14an20a11 TDn14a21 TDn20a21 1.302320e-014
Cn14an20a12 TDn14a23 TDn20a23 1.302320e-014
Cn14an20a13 TDn14a25 TDn20a25 1.302320e-014
Cn14an20a14 TDn14a27 TDn20a27 1.302320e-014
Cn14an20a15 TDn14a29 TDn20a29 1.302320e-014
Cn14an20a16 TDn14a31 TDn20a31 1.302320e-014
Cn14an20a17 TDn14a33 TDn20a33 1.690880e-014
Cn14an21a1 TDn14a1 TDn21a1 1.690880e-014
Cn14an21a2 TDn14a3 TDn21a3 1.302320e-014
Cn14an21a3 TDn14a5 TDn21a5 1.302320e-014
Cn14an21a4 TDn14a7 TDn21a7 1.302320e-014
Cn14an21a5 TDn14a9 TDn21a9 1.302320e-014
Cn14an21a6 TDn14a11 TDn21a11 1.302320e-014
Cn14an21a7 TDn14a13 TDn21a13 1.302320e-014
Cn14an21a8 TDn14a15 TDn21a15 1.302320e-014
Cn14an21a9 TDn14a17 TDn21a17 1.302320e-014
Cn14an21a10 TDn14a19 TDn21a19 1.302320e-014
Cn14an21a11 TDn14a21 TDn21a21 1.302320e-014
Cn14an21a12 TDn14a23 TDn21a23 1.302320e-014
Cn14an21a13 TDn14a25 TDn21a25 1.302320e-014
Cn14an21a14 TDn14a27 TDn21a27 1.302320e-014
Cn14an21a15 TDn14a29 TDn21a29 1.302320e-014
Cn14an21a16 TDn14a31 TDn21a31 1.302320e-014
Cn14an21a17 TDn14a33 TDn21a33 1.690880e-014
Cn14an22a1 TDn14a1 TDn22a1 1.690880e-014
Cn14an22a2 TDn14a3 TDn22a3 1.302320e-014
Cn14an22a3 TDn14a5 TDn22a5 1.302320e-014
Cn14an22a4 TDn14a7 TDn22a7 1.302320e-014
Cn14an22a5 TDn14a9 TDn22a9 1.302320e-014
Cn14an22a6 TDn14a11 TDn22a11 1.302320e-014
Cn14an22a7 TDn14a13 TDn22a13 1.302320e-014
Cn14an22a8 TDn14a15 TDn22a15 1.302320e-014
Cn14an22a9 TDn14a17 TDn22a17 1.302320e-014
Cn14an22a10 TDn14a19 TDn22a19 1.302320e-014
Cn14an22a11 TDn14a21 TDn22a21 1.302320e-014
Cn14an22a12 TDn14a23 TDn22a23 1.302320e-014
Cn14an22a13 TDn14a25 TDn22a25 1.302320e-014
Cn14an22a14 TDn14a27 TDn22a27 1.302320e-014
Cn14an22a15 TDn14a29 TDn22a29 1.302320e-014
Cn14an22a16 TDn14a31 TDn22a31 1.302320e-014
Cn14an22a17 TDn14a33 TDn22a33 1.690880e-014
Cn14an23a1 TDn14a1 TDn23a1 1.690880e-014
Cn14an23a2 TDn14a3 TDn23a3 1.302320e-014
Cn14an23a3 TDn14a5 TDn23a5 1.302320e-014
Cn14an23a4 TDn14a7 TDn23a7 1.302320e-014
Cn14an23a5 TDn14a9 TDn23a9 1.302320e-014
Cn14an23a6 TDn14a11 TDn23a11 1.302320e-014
Cn14an23a7 TDn14a13 TDn23a13 1.302320e-014
Cn14an23a8 TDn14a15 TDn23a15 1.302320e-014
Cn14an23a9 TDn14a17 TDn23a17 1.302320e-014
Cn14an23a10 TDn14a19 TDn23a19 1.302320e-014
Cn14an23a11 TDn14a21 TDn23a21 1.302320e-014
Cn14an23a12 TDn14a23 TDn23a23 1.302320e-014
Cn14an23a13 TDn14a25 TDn23a25 1.302320e-014
Cn14an23a14 TDn14a27 TDn23a27 1.302320e-014
Cn14an23a15 TDn14a29 TDn23a29 1.302320e-014
Cn14an23a16 TDn14a31 TDn23a31 1.302320e-014
Cn14an23a17 TDn14a33 TDn23a33 1.690880e-014
Cn14an24a1 TDn14a1 TDn24a1 1.690880e-014
Cn14an24a2 TDn14a3 TDn24a3 1.302320e-014
Cn14an24a3 TDn14a5 TDn24a5 1.302320e-014
Cn14an24a4 TDn14a7 TDn24a7 1.302320e-014
Cn14an24a5 TDn14a9 TDn24a9 1.302320e-014
Cn14an24a6 TDn14a11 TDn24a11 1.302320e-014
Cn14an24a7 TDn14a13 TDn24a13 1.302320e-014
Cn14an24a8 TDn14a15 TDn24a15 1.302320e-014
Cn14an24a9 TDn14a17 TDn24a17 1.302320e-014
Cn14an24a10 TDn14a19 TDn24a19 1.302320e-014
Cn14an24a11 TDn14a21 TDn24a21 1.302320e-014
Cn14an24a12 TDn14a23 TDn24a23 1.302320e-014
Cn14an24a13 TDn14a25 TDn24a25 1.302320e-014
Cn14an24a14 TDn14a27 TDn24a27 1.302320e-014
Cn14an24a15 TDn14a29 TDn24a29 1.302320e-014
Cn14an24a16 TDn14a31 TDn24a31 1.302320e-014
Cn14an24a17 TDn14a33 TDn24a33 1.690880e-014
Cn14an25a1 TDn14a1 TDn25a1 1.690880e-014
Cn14an25a2 TDn14a3 TDn25a3 1.302320e-014
Cn14an25a3 TDn14a5 TDn25a5 1.302320e-014
Cn14an25a4 TDn14a7 TDn25a7 1.302320e-014
Cn14an25a5 TDn14a9 TDn25a9 1.302320e-014
Cn14an25a6 TDn14a11 TDn25a11 1.302320e-014
Cn14an25a7 TDn14a13 TDn25a13 1.302320e-014
Cn14an25a8 TDn14a15 TDn25a15 1.302320e-014
Cn14an25a9 TDn14a17 TDn25a17 1.302320e-014
Cn14an25a10 TDn14a19 TDn25a19 1.302320e-014
Cn14an25a11 TDn14a21 TDn25a21 1.302320e-014
Cn14an25a12 TDn14a23 TDn25a23 1.302320e-014
Cn14an25a13 TDn14a25 TDn25a25 1.302320e-014
Cn14an25a14 TDn14a27 TDn25a27 1.302320e-014
Cn14an25a15 TDn14a29 TDn25a29 1.302320e-014
Cn14an25a16 TDn14a31 TDn25a31 1.302320e-014
Cn14an25a17 TDn14a33 TDn25a33 1.690880e-014
Cn14an26a1 TDn14a1 TDn26a1 1.690880e-014
Cn14an26a2 TDn14a3 TDn26a3 1.302320e-014
Cn14an26a3 TDn14a5 TDn26a5 1.302320e-014
Cn14an26a4 TDn14a7 TDn26a7 1.302320e-014
Cn14an26a5 TDn14a9 TDn26a9 1.302320e-014
Cn14an26a6 TDn14a11 TDn26a11 1.302320e-014
Cn14an26a7 TDn14a13 TDn26a13 1.302320e-014
Cn14an26a8 TDn14a15 TDn26a15 1.302320e-014
Cn14an26a9 TDn14a17 TDn26a17 1.302320e-014
Cn14an26a10 TDn14a19 TDn26a19 1.302320e-014
Cn14an26a11 TDn14a21 TDn26a21 1.302320e-014
Cn14an26a12 TDn14a23 TDn26a23 1.302320e-014
Cn14an26a13 TDn14a25 TDn26a25 1.302320e-014
Cn14an26a14 TDn14a27 TDn26a27 1.302320e-014
Cn14an26a15 TDn14a29 TDn26a29 1.302320e-014
Cn14an26a16 TDn14a31 TDn26a31 1.302320e-014
Cn14an26a17 TDn14a33 TDn26a33 1.690880e-014
Cn14an27a1 TDn14a1 TDn27a1 1.690880e-014
Cn14an27a2 TDn14a3 TDn27a3 1.302320e-014
Cn14an27a3 TDn14a5 TDn27a5 1.302320e-014
Cn14an27a4 TDn14a7 TDn27a7 1.302320e-014
Cn14an27a5 TDn14a9 TDn27a9 1.302320e-014
Cn14an27a6 TDn14a11 TDn27a11 1.302320e-014
Cn14an27a7 TDn14a13 TDn27a13 1.302320e-014
Cn14an27a8 TDn14a15 TDn27a15 1.302320e-014
Cn14an27a9 TDn14a17 TDn27a17 1.302320e-014
Cn14an27a10 TDn14a19 TDn27a19 1.302320e-014
Cn14an27a11 TDn14a21 TDn27a21 1.302320e-014
Cn14an27a12 TDn14a23 TDn27a23 1.302320e-014
Cn14an27a13 TDn14a25 TDn27a25 1.302320e-014
Cn14an27a14 TDn14a27 TDn27a27 1.302320e-014
Cn14an27a15 TDn14a29 TDn27a29 1.302320e-014
Cn14an27a16 TDn14a31 TDn27a31 1.302320e-014
Cn14an27a17 TDn14a33 TDn27a33 1.690880e-014
Cn14an28a1 TDn14a1 TDn28a1 1.690880e-014
Cn14an28a2 TDn14a3 TDn28a3 1.302320e-014
Cn14an28a3 TDn14a5 TDn28a5 1.302320e-014
Cn14an28a4 TDn14a7 TDn28a7 1.302320e-014
Cn14an28a5 TDn14a9 TDn28a9 1.302320e-014
Cn14an28a6 TDn14a11 TDn28a11 1.302320e-014
Cn14an28a7 TDn14a13 TDn28a13 1.302320e-014
Cn14an28a8 TDn14a15 TDn28a15 1.302320e-014
Cn14an28a9 TDn14a17 TDn28a17 1.302320e-014
Cn14an28a10 TDn14a19 TDn28a19 1.302320e-014
Cn14an28a11 TDn14a21 TDn28a21 1.302320e-014
Cn14an28a12 TDn14a23 TDn28a23 1.302320e-014
Cn14an28a13 TDn14a25 TDn28a25 1.302320e-014
Cn14an28a14 TDn14a27 TDn28a27 1.302320e-014
Cn14an28a15 TDn14a29 TDn28a29 1.302320e-014
Cn14an28a16 TDn14a31 TDn28a31 1.302320e-014
Cn14an28a17 TDn14a33 TDn28a33 1.690880e-014
Cn14an29a1 TDn14a1 TDn29a1 1.690880e-014
Cn14an29a2 TDn14a3 TDn29a3 1.302320e-014
Cn14an29a3 TDn14a5 TDn29a5 1.302320e-014
Cn14an29a4 TDn14a7 TDn29a7 1.302320e-014
Cn14an29a5 TDn14a9 TDn29a9 1.302320e-014
Cn14an29a6 TDn14a11 TDn29a11 1.302320e-014
Cn14an29a7 TDn14a13 TDn29a13 1.302320e-014
Cn14an29a8 TDn14a15 TDn29a15 1.302320e-014
Cn14an29a9 TDn14a17 TDn29a17 1.302320e-014
Cn14an29a10 TDn14a19 TDn29a19 1.302320e-014
Cn14an29a11 TDn14a21 TDn29a21 1.302320e-014
Cn14an29a12 TDn14a23 TDn29a23 1.302320e-014
Cn14an29a13 TDn14a25 TDn29a25 1.302320e-014
Cn14an29a14 TDn14a27 TDn29a27 1.302320e-014
Cn14an29a15 TDn14a29 TDn29a29 1.302320e-014
Cn14an29a16 TDn14a31 TDn29a31 1.302320e-014
Cn14an29a17 TDn14a33 TDn29a33 1.690880e-014
Cn14an30a1 TDn14a1 TDn30a1 1.690880e-014
Cn14an30a2 TDn14a3 TDn30a3 1.302320e-014
Cn14an30a3 TDn14a5 TDn30a5 1.302320e-014
Cn14an30a4 TDn14a7 TDn30a7 1.302320e-014
Cn14an30a5 TDn14a9 TDn30a9 1.302320e-014
Cn14an30a6 TDn14a11 TDn30a11 1.302320e-014
Cn14an30a7 TDn14a13 TDn30a13 1.302320e-014
Cn14an30a8 TDn14a15 TDn30a15 1.302320e-014
Cn14an30a9 TDn14a17 TDn30a17 1.302320e-014
Cn14an30a10 TDn14a19 TDn30a19 1.302320e-014
Cn14an30a11 TDn14a21 TDn30a21 1.302320e-014
Cn14an30a12 TDn14a23 TDn30a23 1.302320e-014
Cn14an30a13 TDn14a25 TDn30a25 1.302320e-014
Cn14an30a14 TDn14a27 TDn30a27 1.302320e-014
Cn14an30a15 TDn14a29 TDn30a29 1.302320e-014
Cn14an30a16 TDn14a31 TDn30a31 1.302320e-014
Cn14an30a17 TDn14a33 TDn30a33 1.690880e-014
Cn14an31a1 TDn14a1 TDn31a1 1.690880e-014
Cn14an31a2 TDn14a3 TDn31a3 1.302320e-014
Cn14an31a3 TDn14a5 TDn31a5 1.302320e-014
Cn14an31a4 TDn14a7 TDn31a7 1.302320e-014
Cn14an31a5 TDn14a9 TDn31a9 1.302320e-014
Cn14an31a6 TDn14a11 TDn31a11 1.302320e-014
Cn14an31a7 TDn14a13 TDn31a13 1.302320e-014
Cn14an31a8 TDn14a15 TDn31a15 1.302320e-014
Cn14an31a9 TDn14a17 TDn31a17 1.302320e-014
Cn14an31a10 TDn14a19 TDn31a19 1.302320e-014
Cn14an31a11 TDn14a21 TDn31a21 1.302320e-014
Cn14an31a12 TDn14a23 TDn31a23 1.302320e-014
Cn14an31a13 TDn14a25 TDn31a25 1.302320e-014
Cn14an31a14 TDn14a27 TDn31a27 1.302320e-014
Cn14an31a15 TDn14a29 TDn31a29 1.302320e-014
Cn14an31a16 TDn14a31 TDn31a31 1.302320e-014
Cn14an31a17 TDn14a33 TDn31a33 1.690880e-014
Cn14an32a1 TDn14a1 TDn32a1 1.690880e-014
Cn14an32a2 TDn14a3 TDn32a3 1.302320e-014
Cn14an32a3 TDn14a5 TDn32a5 1.302320e-014
Cn14an32a4 TDn14a7 TDn32a7 1.302320e-014
Cn14an32a5 TDn14a9 TDn32a9 1.302320e-014
Cn14an32a6 TDn14a11 TDn32a11 1.302320e-014
Cn14an32a7 TDn14a13 TDn32a13 1.302320e-014
Cn14an32a8 TDn14a15 TDn32a15 1.302320e-014
Cn14an32a9 TDn14a17 TDn32a17 1.302320e-014
Cn14an32a10 TDn14a19 TDn32a19 1.302320e-014
Cn14an32a11 TDn14a21 TDn32a21 1.302320e-014
Cn14an32a12 TDn14a23 TDn32a23 1.302320e-014
Cn14an32a13 TDn14a25 TDn32a25 1.302320e-014
Cn14an32a14 TDn14a27 TDn32a27 1.302320e-014
Cn14an32a15 TDn14a29 TDn32a29 1.302320e-014
Cn14an32a16 TDn14a31 TDn32a31 1.302320e-014
Cn14an32a17 TDn14a33 TDn32a33 1.690880e-014
Cn14anva1 TDn14a1 TDnva1 1.690880e-014
Cn14anva2 TDn14a3 TDnva3 1.690880e-014
Cn14anva3 TDn14a5 TDnva5 1.690880e-014
Cn14anva4 TDn14a7 TDnva7 1.690880e-014
Cn14anva5 TDn14a9 TDnva9 1.690880e-014
Cn14anva6 TDn14a11 TDnva11 1.690880e-014
Cn14anva7 TDn14a13 TDnva13 1.690880e-014
Cn14anva8 TDn14a15 TDnva15 1.690880e-014
Cn14anva9 TDn14a17 TDnva17 1.690880e-014
Cn14anva10 TDn14a19 TDnva19 1.690880e-014
Cn14anva11 TDn14a21 TDnva21 1.690880e-014
Cn14anva12 TDn14a23 TDnva23 1.690880e-014
Cn14anva13 TDn14a25 TDnva25 1.690880e-014
Cn14anva14 TDn14a27 TDnva27 1.690880e-014
Cn14anva15 TDn14a29 TDnva29 1.690880e-014
Cn14anva16 TDn14a31 TDnva31 1.690880e-014
Cn14anva17 TDn14a33 TDnva33 1.690880e-014
Cn15an16a1 TDn15a1 TDn16a1 1.690880e-014
Cn15an16a2 TDn15a3 TDn16a3 1.302320e-014
Cn15an16a3 TDn15a5 TDn16a5 1.302320e-014
Cn15an16a4 TDn15a7 TDn16a7 1.302320e-014
Cn15an16a5 TDn15a9 TDn16a9 1.302320e-014
Cn15an16a6 TDn15a11 TDn16a11 1.302320e-014
Cn15an16a7 TDn15a13 TDn16a13 1.302320e-014
Cn15an16a8 TDn15a15 TDn16a15 1.302320e-014
Cn15an16a9 TDn15a17 TDn16a17 1.302320e-014
Cn15an16a10 TDn15a19 TDn16a19 1.302320e-014
Cn15an16a11 TDn15a21 TDn16a21 1.302320e-014
Cn15an16a12 TDn15a23 TDn16a23 1.302320e-014
Cn15an16a13 TDn15a25 TDn16a25 1.302320e-014
Cn15an16a14 TDn15a27 TDn16a27 1.302320e-014
Cn15an16a15 TDn15a29 TDn16a29 1.302320e-014
Cn15an16a16 TDn15a31 TDn16a31 1.302320e-014
Cn15an16a17 TDn15a33 TDn16a33 1.690880e-014
Cn15an17a1 TDn15a1 TDn17a1 1.690880e-014
Cn15an17a2 TDn15a3 TDn17a3 1.302320e-014
Cn15an17a3 TDn15a5 TDn17a5 1.302320e-014
Cn15an17a4 TDn15a7 TDn17a7 1.302320e-014
Cn15an17a5 TDn15a9 TDn17a9 1.302320e-014
Cn15an17a6 TDn15a11 TDn17a11 1.302320e-014
Cn15an17a7 TDn15a13 TDn17a13 1.302320e-014
Cn15an17a8 TDn15a15 TDn17a15 1.302320e-014
Cn15an17a9 TDn15a17 TDn17a17 1.302320e-014
Cn15an17a10 TDn15a19 TDn17a19 1.302320e-014
Cn15an17a11 TDn15a21 TDn17a21 1.302320e-014
Cn15an17a12 TDn15a23 TDn17a23 1.302320e-014
Cn15an17a13 TDn15a25 TDn17a25 1.302320e-014
Cn15an17a14 TDn15a27 TDn17a27 1.302320e-014
Cn15an17a15 TDn15a29 TDn17a29 1.302320e-014
Cn15an17a16 TDn15a31 TDn17a31 1.302320e-014
Cn15an17a17 TDn15a33 TDn17a33 1.690880e-014
Cn15an18a1 TDn15a1 TDn18a1 1.690880e-014
Cn15an18a2 TDn15a3 TDn18a3 1.302320e-014
Cn15an18a3 TDn15a5 TDn18a5 1.302320e-014
Cn15an18a4 TDn15a7 TDn18a7 1.302320e-014
Cn15an18a5 TDn15a9 TDn18a9 1.302320e-014
Cn15an18a6 TDn15a11 TDn18a11 1.302320e-014
Cn15an18a7 TDn15a13 TDn18a13 1.302320e-014
Cn15an18a8 TDn15a15 TDn18a15 1.302320e-014
Cn15an18a9 TDn15a17 TDn18a17 1.302320e-014
Cn15an18a10 TDn15a19 TDn18a19 1.302320e-014
Cn15an18a11 TDn15a21 TDn18a21 1.302320e-014
Cn15an18a12 TDn15a23 TDn18a23 1.302320e-014
Cn15an18a13 TDn15a25 TDn18a25 1.302320e-014
Cn15an18a14 TDn15a27 TDn18a27 1.302320e-014
Cn15an18a15 TDn15a29 TDn18a29 1.302320e-014
Cn15an18a16 TDn15a31 TDn18a31 1.302320e-014
Cn15an18a17 TDn15a33 TDn18a33 1.690880e-014
Cn15an19a1 TDn15a1 TDn19a1 1.690880e-014
Cn15an19a2 TDn15a3 TDn19a3 1.302320e-014
Cn15an19a3 TDn15a5 TDn19a5 1.302320e-014
Cn15an19a4 TDn15a7 TDn19a7 1.302320e-014
Cn15an19a5 TDn15a9 TDn19a9 1.302320e-014
Cn15an19a6 TDn15a11 TDn19a11 1.302320e-014
Cn15an19a7 TDn15a13 TDn19a13 1.302320e-014
Cn15an19a8 TDn15a15 TDn19a15 1.302320e-014
Cn15an19a9 TDn15a17 TDn19a17 1.302320e-014
Cn15an19a10 TDn15a19 TDn19a19 1.302320e-014
Cn15an19a11 TDn15a21 TDn19a21 1.302320e-014
Cn15an19a12 TDn15a23 TDn19a23 1.302320e-014
Cn15an19a13 TDn15a25 TDn19a25 1.302320e-014
Cn15an19a14 TDn15a27 TDn19a27 1.302320e-014
Cn15an19a15 TDn15a29 TDn19a29 1.302320e-014
Cn15an19a16 TDn15a31 TDn19a31 1.302320e-014
Cn15an19a17 TDn15a33 TDn19a33 1.690880e-014
Cn15an20a1 TDn15a1 TDn20a1 1.690880e-014
Cn15an20a2 TDn15a3 TDn20a3 1.302320e-014
Cn15an20a3 TDn15a5 TDn20a5 1.302320e-014
Cn15an20a4 TDn15a7 TDn20a7 1.302320e-014
Cn15an20a5 TDn15a9 TDn20a9 1.302320e-014
Cn15an20a6 TDn15a11 TDn20a11 1.302320e-014
Cn15an20a7 TDn15a13 TDn20a13 1.302320e-014
Cn15an20a8 TDn15a15 TDn20a15 1.302320e-014
Cn15an20a9 TDn15a17 TDn20a17 1.302320e-014
Cn15an20a10 TDn15a19 TDn20a19 1.302320e-014
Cn15an20a11 TDn15a21 TDn20a21 1.302320e-014
Cn15an20a12 TDn15a23 TDn20a23 1.302320e-014
Cn15an20a13 TDn15a25 TDn20a25 1.302320e-014
Cn15an20a14 TDn15a27 TDn20a27 1.302320e-014
Cn15an20a15 TDn15a29 TDn20a29 1.302320e-014
Cn15an20a16 TDn15a31 TDn20a31 1.302320e-014
Cn15an20a17 TDn15a33 TDn20a33 1.690880e-014
Cn15an21a1 TDn15a1 TDn21a1 1.690880e-014
Cn15an21a2 TDn15a3 TDn21a3 1.302320e-014
Cn15an21a3 TDn15a5 TDn21a5 1.302320e-014
Cn15an21a4 TDn15a7 TDn21a7 1.302320e-014
Cn15an21a5 TDn15a9 TDn21a9 1.302320e-014
Cn15an21a6 TDn15a11 TDn21a11 1.302320e-014
Cn15an21a7 TDn15a13 TDn21a13 1.302320e-014
Cn15an21a8 TDn15a15 TDn21a15 1.302320e-014
Cn15an21a9 TDn15a17 TDn21a17 1.302320e-014
Cn15an21a10 TDn15a19 TDn21a19 1.302320e-014
Cn15an21a11 TDn15a21 TDn21a21 1.302320e-014
Cn15an21a12 TDn15a23 TDn21a23 1.302320e-014
Cn15an21a13 TDn15a25 TDn21a25 1.302320e-014
Cn15an21a14 TDn15a27 TDn21a27 1.302320e-014
Cn15an21a15 TDn15a29 TDn21a29 1.302320e-014
Cn15an21a16 TDn15a31 TDn21a31 1.302320e-014
Cn15an21a17 TDn15a33 TDn21a33 1.690880e-014
Cn15an22a1 TDn15a1 TDn22a1 1.690880e-014
Cn15an22a2 TDn15a3 TDn22a3 1.302320e-014
Cn15an22a3 TDn15a5 TDn22a5 1.302320e-014
Cn15an22a4 TDn15a7 TDn22a7 1.302320e-014
Cn15an22a5 TDn15a9 TDn22a9 1.302320e-014
Cn15an22a6 TDn15a11 TDn22a11 1.302320e-014
Cn15an22a7 TDn15a13 TDn22a13 1.302320e-014
Cn15an22a8 TDn15a15 TDn22a15 1.302320e-014
Cn15an22a9 TDn15a17 TDn22a17 1.302320e-014
Cn15an22a10 TDn15a19 TDn22a19 1.302320e-014
Cn15an22a11 TDn15a21 TDn22a21 1.302320e-014
Cn15an22a12 TDn15a23 TDn22a23 1.302320e-014
Cn15an22a13 TDn15a25 TDn22a25 1.302320e-014
Cn15an22a14 TDn15a27 TDn22a27 1.302320e-014
Cn15an22a15 TDn15a29 TDn22a29 1.302320e-014
Cn15an22a16 TDn15a31 TDn22a31 1.302320e-014
Cn15an22a17 TDn15a33 TDn22a33 1.690880e-014
Cn15an23a1 TDn15a1 TDn23a1 1.690880e-014
Cn15an23a2 TDn15a3 TDn23a3 1.302320e-014
Cn15an23a3 TDn15a5 TDn23a5 1.302320e-014
Cn15an23a4 TDn15a7 TDn23a7 1.302320e-014
Cn15an23a5 TDn15a9 TDn23a9 1.302320e-014
Cn15an23a6 TDn15a11 TDn23a11 1.302320e-014
Cn15an23a7 TDn15a13 TDn23a13 1.302320e-014
Cn15an23a8 TDn15a15 TDn23a15 1.302320e-014
Cn15an23a9 TDn15a17 TDn23a17 1.302320e-014
Cn15an23a10 TDn15a19 TDn23a19 1.302320e-014
Cn15an23a11 TDn15a21 TDn23a21 1.302320e-014
Cn15an23a12 TDn15a23 TDn23a23 1.302320e-014
Cn15an23a13 TDn15a25 TDn23a25 1.302320e-014
Cn15an23a14 TDn15a27 TDn23a27 1.302320e-014
Cn15an23a15 TDn15a29 TDn23a29 1.302320e-014
Cn15an23a16 TDn15a31 TDn23a31 1.302320e-014
Cn15an23a17 TDn15a33 TDn23a33 1.690880e-014
Cn15an24a1 TDn15a1 TDn24a1 1.690880e-014
Cn15an24a2 TDn15a3 TDn24a3 1.302320e-014
Cn15an24a3 TDn15a5 TDn24a5 1.302320e-014
Cn15an24a4 TDn15a7 TDn24a7 1.302320e-014
Cn15an24a5 TDn15a9 TDn24a9 1.302320e-014
Cn15an24a6 TDn15a11 TDn24a11 1.302320e-014
Cn15an24a7 TDn15a13 TDn24a13 1.302320e-014
Cn15an24a8 TDn15a15 TDn24a15 1.302320e-014
Cn15an24a9 TDn15a17 TDn24a17 1.302320e-014
Cn15an24a10 TDn15a19 TDn24a19 1.302320e-014
Cn15an24a11 TDn15a21 TDn24a21 1.302320e-014
Cn15an24a12 TDn15a23 TDn24a23 1.302320e-014
Cn15an24a13 TDn15a25 TDn24a25 1.302320e-014
Cn15an24a14 TDn15a27 TDn24a27 1.302320e-014
Cn15an24a15 TDn15a29 TDn24a29 1.302320e-014
Cn15an24a16 TDn15a31 TDn24a31 1.302320e-014
Cn15an24a17 TDn15a33 TDn24a33 1.690880e-014
Cn15an25a1 TDn15a1 TDn25a1 1.690880e-014
Cn15an25a2 TDn15a3 TDn25a3 1.302320e-014
Cn15an25a3 TDn15a5 TDn25a5 1.302320e-014
Cn15an25a4 TDn15a7 TDn25a7 1.302320e-014
Cn15an25a5 TDn15a9 TDn25a9 1.302320e-014
Cn15an25a6 TDn15a11 TDn25a11 1.302320e-014
Cn15an25a7 TDn15a13 TDn25a13 1.302320e-014
Cn15an25a8 TDn15a15 TDn25a15 1.302320e-014
Cn15an25a9 TDn15a17 TDn25a17 1.302320e-014
Cn15an25a10 TDn15a19 TDn25a19 1.302320e-014
Cn15an25a11 TDn15a21 TDn25a21 1.302320e-014
Cn15an25a12 TDn15a23 TDn25a23 1.302320e-014
Cn15an25a13 TDn15a25 TDn25a25 1.302320e-014
Cn15an25a14 TDn15a27 TDn25a27 1.302320e-014
Cn15an25a15 TDn15a29 TDn25a29 1.302320e-014
Cn15an25a16 TDn15a31 TDn25a31 1.302320e-014
Cn15an25a17 TDn15a33 TDn25a33 1.690880e-014
Cn15an26a1 TDn15a1 TDn26a1 1.690880e-014
Cn15an26a2 TDn15a3 TDn26a3 1.302320e-014
Cn15an26a3 TDn15a5 TDn26a5 1.302320e-014
Cn15an26a4 TDn15a7 TDn26a7 1.302320e-014
Cn15an26a5 TDn15a9 TDn26a9 1.302320e-014
Cn15an26a6 TDn15a11 TDn26a11 1.302320e-014
Cn15an26a7 TDn15a13 TDn26a13 1.302320e-014
Cn15an26a8 TDn15a15 TDn26a15 1.302320e-014
Cn15an26a9 TDn15a17 TDn26a17 1.302320e-014
Cn15an26a10 TDn15a19 TDn26a19 1.302320e-014
Cn15an26a11 TDn15a21 TDn26a21 1.302320e-014
Cn15an26a12 TDn15a23 TDn26a23 1.302320e-014
Cn15an26a13 TDn15a25 TDn26a25 1.302320e-014
Cn15an26a14 TDn15a27 TDn26a27 1.302320e-014
Cn15an26a15 TDn15a29 TDn26a29 1.302320e-014
Cn15an26a16 TDn15a31 TDn26a31 1.302320e-014
Cn15an26a17 TDn15a33 TDn26a33 1.690880e-014
Cn15an27a1 TDn15a1 TDn27a1 1.690880e-014
Cn15an27a2 TDn15a3 TDn27a3 1.302320e-014
Cn15an27a3 TDn15a5 TDn27a5 1.302320e-014
Cn15an27a4 TDn15a7 TDn27a7 1.302320e-014
Cn15an27a5 TDn15a9 TDn27a9 1.302320e-014
Cn15an27a6 TDn15a11 TDn27a11 1.302320e-014
Cn15an27a7 TDn15a13 TDn27a13 1.302320e-014
Cn15an27a8 TDn15a15 TDn27a15 1.302320e-014
Cn15an27a9 TDn15a17 TDn27a17 1.302320e-014
Cn15an27a10 TDn15a19 TDn27a19 1.302320e-014
Cn15an27a11 TDn15a21 TDn27a21 1.302320e-014
Cn15an27a12 TDn15a23 TDn27a23 1.302320e-014
Cn15an27a13 TDn15a25 TDn27a25 1.302320e-014
Cn15an27a14 TDn15a27 TDn27a27 1.302320e-014
Cn15an27a15 TDn15a29 TDn27a29 1.302320e-014
Cn15an27a16 TDn15a31 TDn27a31 1.302320e-014
Cn15an27a17 TDn15a33 TDn27a33 1.690880e-014
Cn15an28a1 TDn15a1 TDn28a1 1.690880e-014
Cn15an28a2 TDn15a3 TDn28a3 1.302320e-014
Cn15an28a3 TDn15a5 TDn28a5 1.302320e-014
Cn15an28a4 TDn15a7 TDn28a7 1.302320e-014
Cn15an28a5 TDn15a9 TDn28a9 1.302320e-014
Cn15an28a6 TDn15a11 TDn28a11 1.302320e-014
Cn15an28a7 TDn15a13 TDn28a13 1.302320e-014
Cn15an28a8 TDn15a15 TDn28a15 1.302320e-014
Cn15an28a9 TDn15a17 TDn28a17 1.302320e-014
Cn15an28a10 TDn15a19 TDn28a19 1.302320e-014
Cn15an28a11 TDn15a21 TDn28a21 1.302320e-014
Cn15an28a12 TDn15a23 TDn28a23 1.302320e-014
Cn15an28a13 TDn15a25 TDn28a25 1.302320e-014
Cn15an28a14 TDn15a27 TDn28a27 1.302320e-014
Cn15an28a15 TDn15a29 TDn28a29 1.302320e-014
Cn15an28a16 TDn15a31 TDn28a31 1.302320e-014
Cn15an28a17 TDn15a33 TDn28a33 1.690880e-014
Cn15an29a1 TDn15a1 TDn29a1 1.690880e-014
Cn15an29a2 TDn15a3 TDn29a3 1.302320e-014
Cn15an29a3 TDn15a5 TDn29a5 1.302320e-014
Cn15an29a4 TDn15a7 TDn29a7 1.302320e-014
Cn15an29a5 TDn15a9 TDn29a9 1.302320e-014
Cn15an29a6 TDn15a11 TDn29a11 1.302320e-014
Cn15an29a7 TDn15a13 TDn29a13 1.302320e-014
Cn15an29a8 TDn15a15 TDn29a15 1.302320e-014
Cn15an29a9 TDn15a17 TDn29a17 1.302320e-014
Cn15an29a10 TDn15a19 TDn29a19 1.302320e-014
Cn15an29a11 TDn15a21 TDn29a21 1.302320e-014
Cn15an29a12 TDn15a23 TDn29a23 1.302320e-014
Cn15an29a13 TDn15a25 TDn29a25 1.302320e-014
Cn15an29a14 TDn15a27 TDn29a27 1.302320e-014
Cn15an29a15 TDn15a29 TDn29a29 1.302320e-014
Cn15an29a16 TDn15a31 TDn29a31 1.302320e-014
Cn15an29a17 TDn15a33 TDn29a33 1.690880e-014
Cn15an30a1 TDn15a1 TDn30a1 1.690880e-014
Cn15an30a2 TDn15a3 TDn30a3 1.302320e-014
Cn15an30a3 TDn15a5 TDn30a5 1.302320e-014
Cn15an30a4 TDn15a7 TDn30a7 1.302320e-014
Cn15an30a5 TDn15a9 TDn30a9 1.302320e-014
Cn15an30a6 TDn15a11 TDn30a11 1.302320e-014
Cn15an30a7 TDn15a13 TDn30a13 1.302320e-014
Cn15an30a8 TDn15a15 TDn30a15 1.302320e-014
Cn15an30a9 TDn15a17 TDn30a17 1.302320e-014
Cn15an30a10 TDn15a19 TDn30a19 1.302320e-014
Cn15an30a11 TDn15a21 TDn30a21 1.302320e-014
Cn15an30a12 TDn15a23 TDn30a23 1.302320e-014
Cn15an30a13 TDn15a25 TDn30a25 1.302320e-014
Cn15an30a14 TDn15a27 TDn30a27 1.302320e-014
Cn15an30a15 TDn15a29 TDn30a29 1.302320e-014
Cn15an30a16 TDn15a31 TDn30a31 1.302320e-014
Cn15an30a17 TDn15a33 TDn30a33 1.690880e-014
Cn15an31a1 TDn15a1 TDn31a1 1.690880e-014
Cn15an31a2 TDn15a3 TDn31a3 1.302320e-014
Cn15an31a3 TDn15a5 TDn31a5 1.302320e-014
Cn15an31a4 TDn15a7 TDn31a7 1.302320e-014
Cn15an31a5 TDn15a9 TDn31a9 1.302320e-014
Cn15an31a6 TDn15a11 TDn31a11 1.302320e-014
Cn15an31a7 TDn15a13 TDn31a13 1.302320e-014
Cn15an31a8 TDn15a15 TDn31a15 1.302320e-014
Cn15an31a9 TDn15a17 TDn31a17 1.302320e-014
Cn15an31a10 TDn15a19 TDn31a19 1.302320e-014
Cn15an31a11 TDn15a21 TDn31a21 1.302320e-014
Cn15an31a12 TDn15a23 TDn31a23 1.302320e-014
Cn15an31a13 TDn15a25 TDn31a25 1.302320e-014
Cn15an31a14 TDn15a27 TDn31a27 1.302320e-014
Cn15an31a15 TDn15a29 TDn31a29 1.302320e-014
Cn15an31a16 TDn15a31 TDn31a31 1.302320e-014
Cn15an31a17 TDn15a33 TDn31a33 1.690880e-014
Cn15an32a1 TDn15a1 TDn32a1 1.690880e-014
Cn15an32a2 TDn15a3 TDn32a3 1.302320e-014
Cn15an32a3 TDn15a5 TDn32a5 1.302320e-014
Cn15an32a4 TDn15a7 TDn32a7 1.302320e-014
Cn15an32a5 TDn15a9 TDn32a9 1.302320e-014
Cn15an32a6 TDn15a11 TDn32a11 1.302320e-014
Cn15an32a7 TDn15a13 TDn32a13 1.302320e-014
Cn15an32a8 TDn15a15 TDn32a15 1.302320e-014
Cn15an32a9 TDn15a17 TDn32a17 1.302320e-014
Cn15an32a10 TDn15a19 TDn32a19 1.302320e-014
Cn15an32a11 TDn15a21 TDn32a21 1.302320e-014
Cn15an32a12 TDn15a23 TDn32a23 1.302320e-014
Cn15an32a13 TDn15a25 TDn32a25 1.302320e-014
Cn15an32a14 TDn15a27 TDn32a27 1.302320e-014
Cn15an32a15 TDn15a29 TDn32a29 1.302320e-014
Cn15an32a16 TDn15a31 TDn32a31 1.302320e-014
Cn15an32a17 TDn15a33 TDn32a33 1.690880e-014
Cn15anva1 TDn15a1 TDnva1 1.690880e-014
Cn15anva2 TDn15a3 TDnva3 1.690880e-014
Cn15anva3 TDn15a5 TDnva5 1.690880e-014
Cn15anva4 TDn15a7 TDnva7 1.690880e-014
Cn15anva5 TDn15a9 TDnva9 1.690880e-014
Cn15anva6 TDn15a11 TDnva11 1.690880e-014
Cn15anva7 TDn15a13 TDnva13 1.690880e-014
Cn15anva8 TDn15a15 TDnva15 1.690880e-014
Cn15anva9 TDn15a17 TDnva17 1.690880e-014
Cn15anva10 TDn15a19 TDnva19 1.690880e-014
Cn15anva11 TDn15a21 TDnva21 1.690880e-014
Cn15anva12 TDn15a23 TDnva23 1.690880e-014
Cn15anva13 TDn15a25 TDnva25 1.690880e-014
Cn15anva14 TDn15a27 TDnva27 1.690880e-014
Cn15anva15 TDn15a29 TDnva29 1.690880e-014
Cn15anva16 TDn15a31 TDnva31 1.690880e-014
Cn15anva17 TDn15a33 TDnva33 1.690880e-014
Cn16an17a1 TDn16a1 TDn17a1 1.690880e-014
Cn16an17a2 TDn16a3 TDn17a3 1.302320e-014
Cn16an17a3 TDn16a5 TDn17a5 1.302320e-014
Cn16an17a4 TDn16a7 TDn17a7 1.302320e-014
Cn16an17a5 TDn16a9 TDn17a9 1.302320e-014
Cn16an17a6 TDn16a11 TDn17a11 1.302320e-014
Cn16an17a7 TDn16a13 TDn17a13 1.302320e-014
Cn16an17a8 TDn16a15 TDn17a15 1.302320e-014
Cn16an17a9 TDn16a17 TDn17a17 1.302320e-014
Cn16an17a10 TDn16a19 TDn17a19 1.302320e-014
Cn16an17a11 TDn16a21 TDn17a21 1.302320e-014
Cn16an17a12 TDn16a23 TDn17a23 1.302320e-014
Cn16an17a13 TDn16a25 TDn17a25 1.302320e-014
Cn16an17a14 TDn16a27 TDn17a27 1.302320e-014
Cn16an17a15 TDn16a29 TDn17a29 1.302320e-014
Cn16an17a16 TDn16a31 TDn17a31 1.302320e-014
Cn16an17a17 TDn16a33 TDn17a33 1.690880e-014
Cn16an18a1 TDn16a1 TDn18a1 1.690880e-014
Cn16an18a2 TDn16a3 TDn18a3 1.302320e-014
Cn16an18a3 TDn16a5 TDn18a5 1.302320e-014
Cn16an18a4 TDn16a7 TDn18a7 1.302320e-014
Cn16an18a5 TDn16a9 TDn18a9 1.302320e-014
Cn16an18a6 TDn16a11 TDn18a11 1.302320e-014
Cn16an18a7 TDn16a13 TDn18a13 1.302320e-014
Cn16an18a8 TDn16a15 TDn18a15 1.302320e-014
Cn16an18a9 TDn16a17 TDn18a17 1.302320e-014
Cn16an18a10 TDn16a19 TDn18a19 1.302320e-014
Cn16an18a11 TDn16a21 TDn18a21 1.302320e-014
Cn16an18a12 TDn16a23 TDn18a23 1.302320e-014
Cn16an18a13 TDn16a25 TDn18a25 1.302320e-014
Cn16an18a14 TDn16a27 TDn18a27 1.302320e-014
Cn16an18a15 TDn16a29 TDn18a29 1.302320e-014
Cn16an18a16 TDn16a31 TDn18a31 1.302320e-014
Cn16an18a17 TDn16a33 TDn18a33 1.690880e-014
Cn16an19a1 TDn16a1 TDn19a1 1.690880e-014
Cn16an19a2 TDn16a3 TDn19a3 1.302320e-014
Cn16an19a3 TDn16a5 TDn19a5 1.302320e-014
Cn16an19a4 TDn16a7 TDn19a7 1.302320e-014
Cn16an19a5 TDn16a9 TDn19a9 1.302320e-014
Cn16an19a6 TDn16a11 TDn19a11 1.302320e-014
Cn16an19a7 TDn16a13 TDn19a13 1.302320e-014
Cn16an19a8 TDn16a15 TDn19a15 1.302320e-014
Cn16an19a9 TDn16a17 TDn19a17 1.302320e-014
Cn16an19a10 TDn16a19 TDn19a19 1.302320e-014
Cn16an19a11 TDn16a21 TDn19a21 1.302320e-014
Cn16an19a12 TDn16a23 TDn19a23 1.302320e-014
Cn16an19a13 TDn16a25 TDn19a25 1.302320e-014
Cn16an19a14 TDn16a27 TDn19a27 1.302320e-014
Cn16an19a15 TDn16a29 TDn19a29 1.302320e-014
Cn16an19a16 TDn16a31 TDn19a31 1.302320e-014
Cn16an19a17 TDn16a33 TDn19a33 1.690880e-014
Cn16an20a1 TDn16a1 TDn20a1 1.690880e-014
Cn16an20a2 TDn16a3 TDn20a3 1.302320e-014
Cn16an20a3 TDn16a5 TDn20a5 1.302320e-014
Cn16an20a4 TDn16a7 TDn20a7 1.302320e-014
Cn16an20a5 TDn16a9 TDn20a9 1.302320e-014
Cn16an20a6 TDn16a11 TDn20a11 1.302320e-014
Cn16an20a7 TDn16a13 TDn20a13 1.302320e-014
Cn16an20a8 TDn16a15 TDn20a15 1.302320e-014
Cn16an20a9 TDn16a17 TDn20a17 1.302320e-014
Cn16an20a10 TDn16a19 TDn20a19 1.302320e-014
Cn16an20a11 TDn16a21 TDn20a21 1.302320e-014
Cn16an20a12 TDn16a23 TDn20a23 1.302320e-014
Cn16an20a13 TDn16a25 TDn20a25 1.302320e-014
Cn16an20a14 TDn16a27 TDn20a27 1.302320e-014
Cn16an20a15 TDn16a29 TDn20a29 1.302320e-014
Cn16an20a16 TDn16a31 TDn20a31 1.302320e-014
Cn16an20a17 TDn16a33 TDn20a33 1.690880e-014
Cn16an21a1 TDn16a1 TDn21a1 1.690880e-014
Cn16an21a2 TDn16a3 TDn21a3 1.302320e-014
Cn16an21a3 TDn16a5 TDn21a5 1.302320e-014
Cn16an21a4 TDn16a7 TDn21a7 1.302320e-014
Cn16an21a5 TDn16a9 TDn21a9 1.302320e-014
Cn16an21a6 TDn16a11 TDn21a11 1.302320e-014
Cn16an21a7 TDn16a13 TDn21a13 1.302320e-014
Cn16an21a8 TDn16a15 TDn21a15 1.302320e-014
Cn16an21a9 TDn16a17 TDn21a17 1.302320e-014
Cn16an21a10 TDn16a19 TDn21a19 1.302320e-014
Cn16an21a11 TDn16a21 TDn21a21 1.302320e-014
Cn16an21a12 TDn16a23 TDn21a23 1.302320e-014
Cn16an21a13 TDn16a25 TDn21a25 1.302320e-014
Cn16an21a14 TDn16a27 TDn21a27 1.302320e-014
Cn16an21a15 TDn16a29 TDn21a29 1.302320e-014
Cn16an21a16 TDn16a31 TDn21a31 1.302320e-014
Cn16an21a17 TDn16a33 TDn21a33 1.690880e-014
Cn16an22a1 TDn16a1 TDn22a1 1.690880e-014
Cn16an22a2 TDn16a3 TDn22a3 1.302320e-014
Cn16an22a3 TDn16a5 TDn22a5 1.302320e-014
Cn16an22a4 TDn16a7 TDn22a7 1.302320e-014
Cn16an22a5 TDn16a9 TDn22a9 1.302320e-014
Cn16an22a6 TDn16a11 TDn22a11 1.302320e-014
Cn16an22a7 TDn16a13 TDn22a13 1.302320e-014
Cn16an22a8 TDn16a15 TDn22a15 1.302320e-014
Cn16an22a9 TDn16a17 TDn22a17 1.302320e-014
Cn16an22a10 TDn16a19 TDn22a19 1.302320e-014
Cn16an22a11 TDn16a21 TDn22a21 1.302320e-014
Cn16an22a12 TDn16a23 TDn22a23 1.302320e-014
Cn16an22a13 TDn16a25 TDn22a25 1.302320e-014
Cn16an22a14 TDn16a27 TDn22a27 1.302320e-014
Cn16an22a15 TDn16a29 TDn22a29 1.302320e-014
Cn16an22a16 TDn16a31 TDn22a31 1.302320e-014
Cn16an22a17 TDn16a33 TDn22a33 1.690880e-014
Cn16an23a1 TDn16a1 TDn23a1 1.690880e-014
Cn16an23a2 TDn16a3 TDn23a3 1.302320e-014
Cn16an23a3 TDn16a5 TDn23a5 1.302320e-014
Cn16an23a4 TDn16a7 TDn23a7 1.302320e-014
Cn16an23a5 TDn16a9 TDn23a9 1.302320e-014
Cn16an23a6 TDn16a11 TDn23a11 1.302320e-014
Cn16an23a7 TDn16a13 TDn23a13 1.302320e-014
Cn16an23a8 TDn16a15 TDn23a15 1.302320e-014
Cn16an23a9 TDn16a17 TDn23a17 1.302320e-014
Cn16an23a10 TDn16a19 TDn23a19 1.302320e-014
Cn16an23a11 TDn16a21 TDn23a21 1.302320e-014
Cn16an23a12 TDn16a23 TDn23a23 1.302320e-014
Cn16an23a13 TDn16a25 TDn23a25 1.302320e-014
Cn16an23a14 TDn16a27 TDn23a27 1.302320e-014
Cn16an23a15 TDn16a29 TDn23a29 1.302320e-014
Cn16an23a16 TDn16a31 TDn23a31 1.302320e-014
Cn16an23a17 TDn16a33 TDn23a33 1.690880e-014
Cn16an24a1 TDn16a1 TDn24a1 1.690880e-014
Cn16an24a2 TDn16a3 TDn24a3 1.302320e-014
Cn16an24a3 TDn16a5 TDn24a5 1.302320e-014
Cn16an24a4 TDn16a7 TDn24a7 1.302320e-014
Cn16an24a5 TDn16a9 TDn24a9 1.302320e-014
Cn16an24a6 TDn16a11 TDn24a11 1.302320e-014
Cn16an24a7 TDn16a13 TDn24a13 1.302320e-014
Cn16an24a8 TDn16a15 TDn24a15 1.302320e-014
Cn16an24a9 TDn16a17 TDn24a17 1.302320e-014
Cn16an24a10 TDn16a19 TDn24a19 1.302320e-014
Cn16an24a11 TDn16a21 TDn24a21 1.302320e-014
Cn16an24a12 TDn16a23 TDn24a23 1.302320e-014
Cn16an24a13 TDn16a25 TDn24a25 1.302320e-014
Cn16an24a14 TDn16a27 TDn24a27 1.302320e-014
Cn16an24a15 TDn16a29 TDn24a29 1.302320e-014
Cn16an24a16 TDn16a31 TDn24a31 1.302320e-014
Cn16an24a17 TDn16a33 TDn24a33 1.690880e-014
Cn16an25a1 TDn16a1 TDn25a1 1.690880e-014
Cn16an25a2 TDn16a3 TDn25a3 1.302320e-014
Cn16an25a3 TDn16a5 TDn25a5 1.302320e-014
Cn16an25a4 TDn16a7 TDn25a7 1.302320e-014
Cn16an25a5 TDn16a9 TDn25a9 1.302320e-014
Cn16an25a6 TDn16a11 TDn25a11 1.302320e-014
Cn16an25a7 TDn16a13 TDn25a13 1.302320e-014
Cn16an25a8 TDn16a15 TDn25a15 1.302320e-014
Cn16an25a9 TDn16a17 TDn25a17 1.302320e-014
Cn16an25a10 TDn16a19 TDn25a19 1.302320e-014
Cn16an25a11 TDn16a21 TDn25a21 1.302320e-014
Cn16an25a12 TDn16a23 TDn25a23 1.302320e-014
Cn16an25a13 TDn16a25 TDn25a25 1.302320e-014
Cn16an25a14 TDn16a27 TDn25a27 1.302320e-014
Cn16an25a15 TDn16a29 TDn25a29 1.302320e-014
Cn16an25a16 TDn16a31 TDn25a31 1.302320e-014
Cn16an25a17 TDn16a33 TDn25a33 1.690880e-014
Cn16an26a1 TDn16a1 TDn26a1 1.690880e-014
Cn16an26a2 TDn16a3 TDn26a3 1.302320e-014
Cn16an26a3 TDn16a5 TDn26a5 1.302320e-014
Cn16an26a4 TDn16a7 TDn26a7 1.302320e-014
Cn16an26a5 TDn16a9 TDn26a9 1.302320e-014
Cn16an26a6 TDn16a11 TDn26a11 1.302320e-014
Cn16an26a7 TDn16a13 TDn26a13 1.302320e-014
Cn16an26a8 TDn16a15 TDn26a15 1.302320e-014
Cn16an26a9 TDn16a17 TDn26a17 1.302320e-014
Cn16an26a10 TDn16a19 TDn26a19 1.302320e-014
Cn16an26a11 TDn16a21 TDn26a21 1.302320e-014
Cn16an26a12 TDn16a23 TDn26a23 1.302320e-014
Cn16an26a13 TDn16a25 TDn26a25 1.302320e-014
Cn16an26a14 TDn16a27 TDn26a27 1.302320e-014
Cn16an26a15 TDn16a29 TDn26a29 1.302320e-014
Cn16an26a16 TDn16a31 TDn26a31 1.302320e-014
Cn16an26a17 TDn16a33 TDn26a33 1.690880e-014
Cn16an27a1 TDn16a1 TDn27a1 1.690880e-014
Cn16an27a2 TDn16a3 TDn27a3 1.302320e-014
Cn16an27a3 TDn16a5 TDn27a5 1.302320e-014
Cn16an27a4 TDn16a7 TDn27a7 1.302320e-014
Cn16an27a5 TDn16a9 TDn27a9 1.302320e-014
Cn16an27a6 TDn16a11 TDn27a11 1.302320e-014
Cn16an27a7 TDn16a13 TDn27a13 1.302320e-014
Cn16an27a8 TDn16a15 TDn27a15 1.302320e-014
Cn16an27a9 TDn16a17 TDn27a17 1.302320e-014
Cn16an27a10 TDn16a19 TDn27a19 1.302320e-014
Cn16an27a11 TDn16a21 TDn27a21 1.302320e-014
Cn16an27a12 TDn16a23 TDn27a23 1.302320e-014
Cn16an27a13 TDn16a25 TDn27a25 1.302320e-014
Cn16an27a14 TDn16a27 TDn27a27 1.302320e-014
Cn16an27a15 TDn16a29 TDn27a29 1.302320e-014
Cn16an27a16 TDn16a31 TDn27a31 1.302320e-014
Cn16an27a17 TDn16a33 TDn27a33 1.690880e-014
Cn16an28a1 TDn16a1 TDn28a1 1.690880e-014
Cn16an28a2 TDn16a3 TDn28a3 1.302320e-014
Cn16an28a3 TDn16a5 TDn28a5 1.302320e-014
Cn16an28a4 TDn16a7 TDn28a7 1.302320e-014
Cn16an28a5 TDn16a9 TDn28a9 1.302320e-014
Cn16an28a6 TDn16a11 TDn28a11 1.302320e-014
Cn16an28a7 TDn16a13 TDn28a13 1.302320e-014
Cn16an28a8 TDn16a15 TDn28a15 1.302320e-014
Cn16an28a9 TDn16a17 TDn28a17 1.302320e-014
Cn16an28a10 TDn16a19 TDn28a19 1.302320e-014
Cn16an28a11 TDn16a21 TDn28a21 1.302320e-014
Cn16an28a12 TDn16a23 TDn28a23 1.302320e-014
Cn16an28a13 TDn16a25 TDn28a25 1.302320e-014
Cn16an28a14 TDn16a27 TDn28a27 1.302320e-014
Cn16an28a15 TDn16a29 TDn28a29 1.302320e-014
Cn16an28a16 TDn16a31 TDn28a31 1.302320e-014
Cn16an28a17 TDn16a33 TDn28a33 1.690880e-014
Cn16an29a1 TDn16a1 TDn29a1 1.690880e-014
Cn16an29a2 TDn16a3 TDn29a3 1.302320e-014
Cn16an29a3 TDn16a5 TDn29a5 1.302320e-014
Cn16an29a4 TDn16a7 TDn29a7 1.302320e-014
Cn16an29a5 TDn16a9 TDn29a9 1.302320e-014
Cn16an29a6 TDn16a11 TDn29a11 1.302320e-014
Cn16an29a7 TDn16a13 TDn29a13 1.302320e-014
Cn16an29a8 TDn16a15 TDn29a15 1.302320e-014
Cn16an29a9 TDn16a17 TDn29a17 1.302320e-014
Cn16an29a10 TDn16a19 TDn29a19 1.302320e-014
Cn16an29a11 TDn16a21 TDn29a21 1.302320e-014
Cn16an29a12 TDn16a23 TDn29a23 1.302320e-014
Cn16an29a13 TDn16a25 TDn29a25 1.302320e-014
Cn16an29a14 TDn16a27 TDn29a27 1.302320e-014
Cn16an29a15 TDn16a29 TDn29a29 1.302320e-014
Cn16an29a16 TDn16a31 TDn29a31 1.302320e-014
Cn16an29a17 TDn16a33 TDn29a33 1.690880e-014
Cn16an30a1 TDn16a1 TDn30a1 1.690880e-014
Cn16an30a2 TDn16a3 TDn30a3 1.302320e-014
Cn16an30a3 TDn16a5 TDn30a5 1.302320e-014
Cn16an30a4 TDn16a7 TDn30a7 1.302320e-014
Cn16an30a5 TDn16a9 TDn30a9 1.302320e-014
Cn16an30a6 TDn16a11 TDn30a11 1.302320e-014
Cn16an30a7 TDn16a13 TDn30a13 1.302320e-014
Cn16an30a8 TDn16a15 TDn30a15 1.302320e-014
Cn16an30a9 TDn16a17 TDn30a17 1.302320e-014
Cn16an30a10 TDn16a19 TDn30a19 1.302320e-014
Cn16an30a11 TDn16a21 TDn30a21 1.302320e-014
Cn16an30a12 TDn16a23 TDn30a23 1.302320e-014
Cn16an30a13 TDn16a25 TDn30a25 1.302320e-014
Cn16an30a14 TDn16a27 TDn30a27 1.302320e-014
Cn16an30a15 TDn16a29 TDn30a29 1.302320e-014
Cn16an30a16 TDn16a31 TDn30a31 1.302320e-014
Cn16an30a17 TDn16a33 TDn30a33 1.690880e-014
Cn16an31a1 TDn16a1 TDn31a1 1.690880e-014
Cn16an31a2 TDn16a3 TDn31a3 1.302320e-014
Cn16an31a3 TDn16a5 TDn31a5 1.302320e-014
Cn16an31a4 TDn16a7 TDn31a7 1.302320e-014
Cn16an31a5 TDn16a9 TDn31a9 1.302320e-014
Cn16an31a6 TDn16a11 TDn31a11 1.302320e-014
Cn16an31a7 TDn16a13 TDn31a13 1.302320e-014
Cn16an31a8 TDn16a15 TDn31a15 1.302320e-014
Cn16an31a9 TDn16a17 TDn31a17 1.302320e-014
Cn16an31a10 TDn16a19 TDn31a19 1.302320e-014
Cn16an31a11 TDn16a21 TDn31a21 1.302320e-014
Cn16an31a12 TDn16a23 TDn31a23 1.302320e-014
Cn16an31a13 TDn16a25 TDn31a25 1.302320e-014
Cn16an31a14 TDn16a27 TDn31a27 1.302320e-014
Cn16an31a15 TDn16a29 TDn31a29 1.302320e-014
Cn16an31a16 TDn16a31 TDn31a31 1.302320e-014
Cn16an31a17 TDn16a33 TDn31a33 1.690880e-014
Cn16an32a1 TDn16a1 TDn32a1 1.690880e-014
Cn16an32a2 TDn16a3 TDn32a3 1.302320e-014
Cn16an32a3 TDn16a5 TDn32a5 1.302320e-014
Cn16an32a4 TDn16a7 TDn32a7 1.302320e-014
Cn16an32a5 TDn16a9 TDn32a9 1.302320e-014
Cn16an32a6 TDn16a11 TDn32a11 1.302320e-014
Cn16an32a7 TDn16a13 TDn32a13 1.302320e-014
Cn16an32a8 TDn16a15 TDn32a15 1.302320e-014
Cn16an32a9 TDn16a17 TDn32a17 1.302320e-014
Cn16an32a10 TDn16a19 TDn32a19 1.302320e-014
Cn16an32a11 TDn16a21 TDn32a21 1.302320e-014
Cn16an32a12 TDn16a23 TDn32a23 1.302320e-014
Cn16an32a13 TDn16a25 TDn32a25 1.302320e-014
Cn16an32a14 TDn16a27 TDn32a27 1.302320e-014
Cn16an32a15 TDn16a29 TDn32a29 1.302320e-014
Cn16an32a16 TDn16a31 TDn32a31 1.302320e-014
Cn16an32a17 TDn16a33 TDn32a33 1.690880e-014
Cn16anva1 TDn16a1 TDnva1 1.690880e-014
Cn16anva2 TDn16a3 TDnva3 1.690880e-014
Cn16anva3 TDn16a5 TDnva5 1.690880e-014
Cn16anva4 TDn16a7 TDnva7 1.690880e-014
Cn16anva5 TDn16a9 TDnva9 1.690880e-014
Cn16anva6 TDn16a11 TDnva11 1.690880e-014
Cn16anva7 TDn16a13 TDnva13 1.690880e-014
Cn16anva8 TDn16a15 TDnva15 1.690880e-014
Cn16anva9 TDn16a17 TDnva17 1.690880e-014
Cn16anva10 TDn16a19 TDnva19 1.690880e-014
Cn16anva11 TDn16a21 TDnva21 1.690880e-014
Cn16anva12 TDn16a23 TDnva23 1.690880e-014
Cn16anva13 TDn16a25 TDnva25 1.690880e-014
Cn16anva14 TDn16a27 TDnva27 1.690880e-014
Cn16anva15 TDn16a29 TDnva29 1.690880e-014
Cn16anva16 TDn16a31 TDnva31 1.690880e-014
Cn16anva17 TDn16a33 TDnva33 1.690880e-014
Cn17an18a1 TDn17a1 TDn18a1 1.690880e-014
Cn17an18a2 TDn17a3 TDn18a3 1.302320e-014
Cn17an18a3 TDn17a5 TDn18a5 1.302320e-014
Cn17an18a4 TDn17a7 TDn18a7 1.302320e-014
Cn17an18a5 TDn17a9 TDn18a9 1.302320e-014
Cn17an18a6 TDn17a11 TDn18a11 1.302320e-014
Cn17an18a7 TDn17a13 TDn18a13 1.302320e-014
Cn17an18a8 TDn17a15 TDn18a15 1.302320e-014
Cn17an18a9 TDn17a17 TDn18a17 1.302320e-014
Cn17an18a10 TDn17a19 TDn18a19 1.302320e-014
Cn17an18a11 TDn17a21 TDn18a21 1.302320e-014
Cn17an18a12 TDn17a23 TDn18a23 1.302320e-014
Cn17an18a13 TDn17a25 TDn18a25 1.302320e-014
Cn17an18a14 TDn17a27 TDn18a27 1.302320e-014
Cn17an18a15 TDn17a29 TDn18a29 1.302320e-014
Cn17an18a16 TDn17a31 TDn18a31 1.302320e-014
Cn17an18a17 TDn17a33 TDn18a33 1.690880e-014
Cn17an19a1 TDn17a1 TDn19a1 1.690880e-014
Cn17an19a2 TDn17a3 TDn19a3 1.302320e-014
Cn17an19a3 TDn17a5 TDn19a5 1.302320e-014
Cn17an19a4 TDn17a7 TDn19a7 1.302320e-014
Cn17an19a5 TDn17a9 TDn19a9 1.302320e-014
Cn17an19a6 TDn17a11 TDn19a11 1.302320e-014
Cn17an19a7 TDn17a13 TDn19a13 1.302320e-014
Cn17an19a8 TDn17a15 TDn19a15 1.302320e-014
Cn17an19a9 TDn17a17 TDn19a17 1.302320e-014
Cn17an19a10 TDn17a19 TDn19a19 1.302320e-014
Cn17an19a11 TDn17a21 TDn19a21 1.302320e-014
Cn17an19a12 TDn17a23 TDn19a23 1.302320e-014
Cn17an19a13 TDn17a25 TDn19a25 1.302320e-014
Cn17an19a14 TDn17a27 TDn19a27 1.302320e-014
Cn17an19a15 TDn17a29 TDn19a29 1.302320e-014
Cn17an19a16 TDn17a31 TDn19a31 1.302320e-014
Cn17an19a17 TDn17a33 TDn19a33 1.690880e-014
Cn17an20a1 TDn17a1 TDn20a1 1.690880e-014
Cn17an20a2 TDn17a3 TDn20a3 1.302320e-014
Cn17an20a3 TDn17a5 TDn20a5 1.302320e-014
Cn17an20a4 TDn17a7 TDn20a7 1.302320e-014
Cn17an20a5 TDn17a9 TDn20a9 1.302320e-014
Cn17an20a6 TDn17a11 TDn20a11 1.302320e-014
Cn17an20a7 TDn17a13 TDn20a13 1.302320e-014
Cn17an20a8 TDn17a15 TDn20a15 1.302320e-014
Cn17an20a9 TDn17a17 TDn20a17 1.302320e-014
Cn17an20a10 TDn17a19 TDn20a19 1.302320e-014
Cn17an20a11 TDn17a21 TDn20a21 1.302320e-014
Cn17an20a12 TDn17a23 TDn20a23 1.302320e-014
Cn17an20a13 TDn17a25 TDn20a25 1.302320e-014
Cn17an20a14 TDn17a27 TDn20a27 1.302320e-014
Cn17an20a15 TDn17a29 TDn20a29 1.302320e-014
Cn17an20a16 TDn17a31 TDn20a31 1.302320e-014
Cn17an20a17 TDn17a33 TDn20a33 1.690880e-014
Cn17an21a1 TDn17a1 TDn21a1 1.690880e-014
Cn17an21a2 TDn17a3 TDn21a3 1.302320e-014
Cn17an21a3 TDn17a5 TDn21a5 1.302320e-014
Cn17an21a4 TDn17a7 TDn21a7 1.302320e-014
Cn17an21a5 TDn17a9 TDn21a9 1.302320e-014
Cn17an21a6 TDn17a11 TDn21a11 1.302320e-014
Cn17an21a7 TDn17a13 TDn21a13 1.302320e-014
Cn17an21a8 TDn17a15 TDn21a15 1.302320e-014
Cn17an21a9 TDn17a17 TDn21a17 1.302320e-014
Cn17an21a10 TDn17a19 TDn21a19 1.302320e-014
Cn17an21a11 TDn17a21 TDn21a21 1.302320e-014
Cn17an21a12 TDn17a23 TDn21a23 1.302320e-014
Cn17an21a13 TDn17a25 TDn21a25 1.302320e-014
Cn17an21a14 TDn17a27 TDn21a27 1.302320e-014
Cn17an21a15 TDn17a29 TDn21a29 1.302320e-014
Cn17an21a16 TDn17a31 TDn21a31 1.302320e-014
Cn17an21a17 TDn17a33 TDn21a33 1.690880e-014
Cn17an22a1 TDn17a1 TDn22a1 1.690880e-014
Cn17an22a2 TDn17a3 TDn22a3 1.302320e-014
Cn17an22a3 TDn17a5 TDn22a5 1.302320e-014
Cn17an22a4 TDn17a7 TDn22a7 1.302320e-014
Cn17an22a5 TDn17a9 TDn22a9 1.302320e-014
Cn17an22a6 TDn17a11 TDn22a11 1.302320e-014
Cn17an22a7 TDn17a13 TDn22a13 1.302320e-014
Cn17an22a8 TDn17a15 TDn22a15 1.302320e-014
Cn17an22a9 TDn17a17 TDn22a17 1.302320e-014
Cn17an22a10 TDn17a19 TDn22a19 1.302320e-014
Cn17an22a11 TDn17a21 TDn22a21 1.302320e-014
Cn17an22a12 TDn17a23 TDn22a23 1.302320e-014
Cn17an22a13 TDn17a25 TDn22a25 1.302320e-014
Cn17an22a14 TDn17a27 TDn22a27 1.302320e-014
Cn17an22a15 TDn17a29 TDn22a29 1.302320e-014
Cn17an22a16 TDn17a31 TDn22a31 1.302320e-014
Cn17an22a17 TDn17a33 TDn22a33 1.690880e-014
Cn17an23a1 TDn17a1 TDn23a1 1.690880e-014
Cn17an23a2 TDn17a3 TDn23a3 1.302320e-014
Cn17an23a3 TDn17a5 TDn23a5 1.302320e-014
Cn17an23a4 TDn17a7 TDn23a7 1.302320e-014
Cn17an23a5 TDn17a9 TDn23a9 1.302320e-014
Cn17an23a6 TDn17a11 TDn23a11 1.302320e-014
Cn17an23a7 TDn17a13 TDn23a13 1.302320e-014
Cn17an23a8 TDn17a15 TDn23a15 1.302320e-014
Cn17an23a9 TDn17a17 TDn23a17 1.302320e-014
Cn17an23a10 TDn17a19 TDn23a19 1.302320e-014
Cn17an23a11 TDn17a21 TDn23a21 1.302320e-014
Cn17an23a12 TDn17a23 TDn23a23 1.302320e-014
Cn17an23a13 TDn17a25 TDn23a25 1.302320e-014
Cn17an23a14 TDn17a27 TDn23a27 1.302320e-014
Cn17an23a15 TDn17a29 TDn23a29 1.302320e-014
Cn17an23a16 TDn17a31 TDn23a31 1.302320e-014
Cn17an23a17 TDn17a33 TDn23a33 1.690880e-014
Cn17an24a1 TDn17a1 TDn24a1 1.690880e-014
Cn17an24a2 TDn17a3 TDn24a3 1.302320e-014
Cn17an24a3 TDn17a5 TDn24a5 1.302320e-014
Cn17an24a4 TDn17a7 TDn24a7 1.302320e-014
Cn17an24a5 TDn17a9 TDn24a9 1.302320e-014
Cn17an24a6 TDn17a11 TDn24a11 1.302320e-014
Cn17an24a7 TDn17a13 TDn24a13 1.302320e-014
Cn17an24a8 TDn17a15 TDn24a15 1.302320e-014
Cn17an24a9 TDn17a17 TDn24a17 1.302320e-014
Cn17an24a10 TDn17a19 TDn24a19 1.302320e-014
Cn17an24a11 TDn17a21 TDn24a21 1.302320e-014
Cn17an24a12 TDn17a23 TDn24a23 1.302320e-014
Cn17an24a13 TDn17a25 TDn24a25 1.302320e-014
Cn17an24a14 TDn17a27 TDn24a27 1.302320e-014
Cn17an24a15 TDn17a29 TDn24a29 1.302320e-014
Cn17an24a16 TDn17a31 TDn24a31 1.302320e-014
Cn17an24a17 TDn17a33 TDn24a33 1.690880e-014
Cn17an25a1 TDn17a1 TDn25a1 1.690880e-014
Cn17an25a2 TDn17a3 TDn25a3 1.302320e-014
Cn17an25a3 TDn17a5 TDn25a5 1.302320e-014
Cn17an25a4 TDn17a7 TDn25a7 1.302320e-014
Cn17an25a5 TDn17a9 TDn25a9 1.302320e-014
Cn17an25a6 TDn17a11 TDn25a11 1.302320e-014
Cn17an25a7 TDn17a13 TDn25a13 1.302320e-014
Cn17an25a8 TDn17a15 TDn25a15 1.302320e-014
Cn17an25a9 TDn17a17 TDn25a17 1.302320e-014
Cn17an25a10 TDn17a19 TDn25a19 1.302320e-014
Cn17an25a11 TDn17a21 TDn25a21 1.302320e-014
Cn17an25a12 TDn17a23 TDn25a23 1.302320e-014
Cn17an25a13 TDn17a25 TDn25a25 1.302320e-014
Cn17an25a14 TDn17a27 TDn25a27 1.302320e-014
Cn17an25a15 TDn17a29 TDn25a29 1.302320e-014
Cn17an25a16 TDn17a31 TDn25a31 1.302320e-014
Cn17an25a17 TDn17a33 TDn25a33 1.690880e-014
Cn17an26a1 TDn17a1 TDn26a1 1.690880e-014
Cn17an26a2 TDn17a3 TDn26a3 1.302320e-014
Cn17an26a3 TDn17a5 TDn26a5 1.302320e-014
Cn17an26a4 TDn17a7 TDn26a7 1.302320e-014
Cn17an26a5 TDn17a9 TDn26a9 1.302320e-014
Cn17an26a6 TDn17a11 TDn26a11 1.302320e-014
Cn17an26a7 TDn17a13 TDn26a13 1.302320e-014
Cn17an26a8 TDn17a15 TDn26a15 1.302320e-014
Cn17an26a9 TDn17a17 TDn26a17 1.302320e-014
Cn17an26a10 TDn17a19 TDn26a19 1.302320e-014
Cn17an26a11 TDn17a21 TDn26a21 1.302320e-014
Cn17an26a12 TDn17a23 TDn26a23 1.302320e-014
Cn17an26a13 TDn17a25 TDn26a25 1.302320e-014
Cn17an26a14 TDn17a27 TDn26a27 1.302320e-014
Cn17an26a15 TDn17a29 TDn26a29 1.302320e-014
Cn17an26a16 TDn17a31 TDn26a31 1.302320e-014
Cn17an26a17 TDn17a33 TDn26a33 1.690880e-014
Cn17an27a1 TDn17a1 TDn27a1 1.690880e-014
Cn17an27a2 TDn17a3 TDn27a3 1.302320e-014
Cn17an27a3 TDn17a5 TDn27a5 1.302320e-014
Cn17an27a4 TDn17a7 TDn27a7 1.302320e-014
Cn17an27a5 TDn17a9 TDn27a9 1.302320e-014
Cn17an27a6 TDn17a11 TDn27a11 1.302320e-014
Cn17an27a7 TDn17a13 TDn27a13 1.302320e-014
Cn17an27a8 TDn17a15 TDn27a15 1.302320e-014
Cn17an27a9 TDn17a17 TDn27a17 1.302320e-014
Cn17an27a10 TDn17a19 TDn27a19 1.302320e-014
Cn17an27a11 TDn17a21 TDn27a21 1.302320e-014
Cn17an27a12 TDn17a23 TDn27a23 1.302320e-014
Cn17an27a13 TDn17a25 TDn27a25 1.302320e-014
Cn17an27a14 TDn17a27 TDn27a27 1.302320e-014
Cn17an27a15 TDn17a29 TDn27a29 1.302320e-014
Cn17an27a16 TDn17a31 TDn27a31 1.302320e-014
Cn17an27a17 TDn17a33 TDn27a33 1.690880e-014
Cn17an28a1 TDn17a1 TDn28a1 1.690880e-014
Cn17an28a2 TDn17a3 TDn28a3 1.302320e-014
Cn17an28a3 TDn17a5 TDn28a5 1.302320e-014
Cn17an28a4 TDn17a7 TDn28a7 1.302320e-014
Cn17an28a5 TDn17a9 TDn28a9 1.302320e-014
Cn17an28a6 TDn17a11 TDn28a11 1.302320e-014
Cn17an28a7 TDn17a13 TDn28a13 1.302320e-014
Cn17an28a8 TDn17a15 TDn28a15 1.302320e-014
Cn17an28a9 TDn17a17 TDn28a17 1.302320e-014
Cn17an28a10 TDn17a19 TDn28a19 1.302320e-014
Cn17an28a11 TDn17a21 TDn28a21 1.302320e-014
Cn17an28a12 TDn17a23 TDn28a23 1.302320e-014
Cn17an28a13 TDn17a25 TDn28a25 1.302320e-014
Cn17an28a14 TDn17a27 TDn28a27 1.302320e-014
Cn17an28a15 TDn17a29 TDn28a29 1.302320e-014
Cn17an28a16 TDn17a31 TDn28a31 1.302320e-014
Cn17an28a17 TDn17a33 TDn28a33 1.690880e-014
Cn17an29a1 TDn17a1 TDn29a1 1.690880e-014
Cn17an29a2 TDn17a3 TDn29a3 1.302320e-014
Cn17an29a3 TDn17a5 TDn29a5 1.302320e-014
Cn17an29a4 TDn17a7 TDn29a7 1.302320e-014
Cn17an29a5 TDn17a9 TDn29a9 1.302320e-014
Cn17an29a6 TDn17a11 TDn29a11 1.302320e-014
Cn17an29a7 TDn17a13 TDn29a13 1.302320e-014
Cn17an29a8 TDn17a15 TDn29a15 1.302320e-014
Cn17an29a9 TDn17a17 TDn29a17 1.302320e-014
Cn17an29a10 TDn17a19 TDn29a19 1.302320e-014
Cn17an29a11 TDn17a21 TDn29a21 1.302320e-014
Cn17an29a12 TDn17a23 TDn29a23 1.302320e-014
Cn17an29a13 TDn17a25 TDn29a25 1.302320e-014
Cn17an29a14 TDn17a27 TDn29a27 1.302320e-014
Cn17an29a15 TDn17a29 TDn29a29 1.302320e-014
Cn17an29a16 TDn17a31 TDn29a31 1.302320e-014
Cn17an29a17 TDn17a33 TDn29a33 1.690880e-014
Cn17an30a1 TDn17a1 TDn30a1 1.690880e-014
Cn17an30a2 TDn17a3 TDn30a3 1.302320e-014
Cn17an30a3 TDn17a5 TDn30a5 1.302320e-014
Cn17an30a4 TDn17a7 TDn30a7 1.302320e-014
Cn17an30a5 TDn17a9 TDn30a9 1.302320e-014
Cn17an30a6 TDn17a11 TDn30a11 1.302320e-014
Cn17an30a7 TDn17a13 TDn30a13 1.302320e-014
Cn17an30a8 TDn17a15 TDn30a15 1.302320e-014
Cn17an30a9 TDn17a17 TDn30a17 1.302320e-014
Cn17an30a10 TDn17a19 TDn30a19 1.302320e-014
Cn17an30a11 TDn17a21 TDn30a21 1.302320e-014
Cn17an30a12 TDn17a23 TDn30a23 1.302320e-014
Cn17an30a13 TDn17a25 TDn30a25 1.302320e-014
Cn17an30a14 TDn17a27 TDn30a27 1.302320e-014
Cn17an30a15 TDn17a29 TDn30a29 1.302320e-014
Cn17an30a16 TDn17a31 TDn30a31 1.302320e-014
Cn17an30a17 TDn17a33 TDn30a33 1.690880e-014
Cn17an31a1 TDn17a1 TDn31a1 1.690880e-014
Cn17an31a2 TDn17a3 TDn31a3 1.302320e-014
Cn17an31a3 TDn17a5 TDn31a5 1.302320e-014
Cn17an31a4 TDn17a7 TDn31a7 1.302320e-014
Cn17an31a5 TDn17a9 TDn31a9 1.302320e-014
Cn17an31a6 TDn17a11 TDn31a11 1.302320e-014
Cn17an31a7 TDn17a13 TDn31a13 1.302320e-014
Cn17an31a8 TDn17a15 TDn31a15 1.302320e-014
Cn17an31a9 TDn17a17 TDn31a17 1.302320e-014
Cn17an31a10 TDn17a19 TDn31a19 1.302320e-014
Cn17an31a11 TDn17a21 TDn31a21 1.302320e-014
Cn17an31a12 TDn17a23 TDn31a23 1.302320e-014
Cn17an31a13 TDn17a25 TDn31a25 1.302320e-014
Cn17an31a14 TDn17a27 TDn31a27 1.302320e-014
Cn17an31a15 TDn17a29 TDn31a29 1.302320e-014
Cn17an31a16 TDn17a31 TDn31a31 1.302320e-014
Cn17an31a17 TDn17a33 TDn31a33 1.690880e-014
Cn17an32a1 TDn17a1 TDn32a1 1.690880e-014
Cn17an32a2 TDn17a3 TDn32a3 1.302320e-014
Cn17an32a3 TDn17a5 TDn32a5 1.302320e-014
Cn17an32a4 TDn17a7 TDn32a7 1.302320e-014
Cn17an32a5 TDn17a9 TDn32a9 1.302320e-014
Cn17an32a6 TDn17a11 TDn32a11 1.302320e-014
Cn17an32a7 TDn17a13 TDn32a13 1.302320e-014
Cn17an32a8 TDn17a15 TDn32a15 1.302320e-014
Cn17an32a9 TDn17a17 TDn32a17 1.302320e-014
Cn17an32a10 TDn17a19 TDn32a19 1.302320e-014
Cn17an32a11 TDn17a21 TDn32a21 1.302320e-014
Cn17an32a12 TDn17a23 TDn32a23 1.302320e-014
Cn17an32a13 TDn17a25 TDn32a25 1.302320e-014
Cn17an32a14 TDn17a27 TDn32a27 1.302320e-014
Cn17an32a15 TDn17a29 TDn32a29 1.302320e-014
Cn17an32a16 TDn17a31 TDn32a31 1.302320e-014
Cn17an32a17 TDn17a33 TDn32a33 1.690880e-014
Cn17anva1 TDn17a1 TDnva1 1.690880e-014
Cn17anva2 TDn17a3 TDnva3 1.690880e-014
Cn17anva3 TDn17a5 TDnva5 1.690880e-014
Cn17anva4 TDn17a7 TDnva7 1.690880e-014
Cn17anva5 TDn17a9 TDnva9 1.690880e-014
Cn17anva6 TDn17a11 TDnva11 1.690880e-014
Cn17anva7 TDn17a13 TDnva13 1.690880e-014
Cn17anva8 TDn17a15 TDnva15 1.690880e-014
Cn17anva9 TDn17a17 TDnva17 1.690880e-014
Cn17anva10 TDn17a19 TDnva19 1.690880e-014
Cn17anva11 TDn17a21 TDnva21 1.690880e-014
Cn17anva12 TDn17a23 TDnva23 1.690880e-014
Cn17anva13 TDn17a25 TDnva25 1.690880e-014
Cn17anva14 TDn17a27 TDnva27 1.690880e-014
Cn17anva15 TDn17a29 TDnva29 1.690880e-014
Cn17anva16 TDn17a31 TDnva31 1.690880e-014
Cn17anva17 TDn17a33 TDnva33 1.690880e-014
Cn18an19a1 TDn18a1 TDn19a1 1.690880e-014
Cn18an19a2 TDn18a3 TDn19a3 1.302320e-014
Cn18an19a3 TDn18a5 TDn19a5 1.302320e-014
Cn18an19a4 TDn18a7 TDn19a7 1.302320e-014
Cn18an19a5 TDn18a9 TDn19a9 1.302320e-014
Cn18an19a6 TDn18a11 TDn19a11 1.302320e-014
Cn18an19a7 TDn18a13 TDn19a13 1.302320e-014
Cn18an19a8 TDn18a15 TDn19a15 1.302320e-014
Cn18an19a9 TDn18a17 TDn19a17 1.302320e-014
Cn18an19a10 TDn18a19 TDn19a19 1.302320e-014
Cn18an19a11 TDn18a21 TDn19a21 1.302320e-014
Cn18an19a12 TDn18a23 TDn19a23 1.302320e-014
Cn18an19a13 TDn18a25 TDn19a25 1.302320e-014
Cn18an19a14 TDn18a27 TDn19a27 1.302320e-014
Cn18an19a15 TDn18a29 TDn19a29 1.302320e-014
Cn18an19a16 TDn18a31 TDn19a31 1.302320e-014
Cn18an19a17 TDn18a33 TDn19a33 1.690880e-014
Cn18an20a1 TDn18a1 TDn20a1 1.690880e-014
Cn18an20a2 TDn18a3 TDn20a3 1.302320e-014
Cn18an20a3 TDn18a5 TDn20a5 1.302320e-014
Cn18an20a4 TDn18a7 TDn20a7 1.302320e-014
Cn18an20a5 TDn18a9 TDn20a9 1.302320e-014
Cn18an20a6 TDn18a11 TDn20a11 1.302320e-014
Cn18an20a7 TDn18a13 TDn20a13 1.302320e-014
Cn18an20a8 TDn18a15 TDn20a15 1.302320e-014
Cn18an20a9 TDn18a17 TDn20a17 1.302320e-014
Cn18an20a10 TDn18a19 TDn20a19 1.302320e-014
Cn18an20a11 TDn18a21 TDn20a21 1.302320e-014
Cn18an20a12 TDn18a23 TDn20a23 1.302320e-014
Cn18an20a13 TDn18a25 TDn20a25 1.302320e-014
Cn18an20a14 TDn18a27 TDn20a27 1.302320e-014
Cn18an20a15 TDn18a29 TDn20a29 1.302320e-014
Cn18an20a16 TDn18a31 TDn20a31 1.302320e-014
Cn18an20a17 TDn18a33 TDn20a33 1.690880e-014
Cn18an21a1 TDn18a1 TDn21a1 1.690880e-014
Cn18an21a2 TDn18a3 TDn21a3 1.302320e-014
Cn18an21a3 TDn18a5 TDn21a5 1.302320e-014
Cn18an21a4 TDn18a7 TDn21a7 1.302320e-014
Cn18an21a5 TDn18a9 TDn21a9 1.302320e-014
Cn18an21a6 TDn18a11 TDn21a11 1.302320e-014
Cn18an21a7 TDn18a13 TDn21a13 1.302320e-014
Cn18an21a8 TDn18a15 TDn21a15 1.302320e-014
Cn18an21a9 TDn18a17 TDn21a17 1.302320e-014
Cn18an21a10 TDn18a19 TDn21a19 1.302320e-014
Cn18an21a11 TDn18a21 TDn21a21 1.302320e-014
Cn18an21a12 TDn18a23 TDn21a23 1.302320e-014
Cn18an21a13 TDn18a25 TDn21a25 1.302320e-014
Cn18an21a14 TDn18a27 TDn21a27 1.302320e-014
Cn18an21a15 TDn18a29 TDn21a29 1.302320e-014
Cn18an21a16 TDn18a31 TDn21a31 1.302320e-014
Cn18an21a17 TDn18a33 TDn21a33 1.690880e-014
Cn18an22a1 TDn18a1 TDn22a1 1.690880e-014
Cn18an22a2 TDn18a3 TDn22a3 1.302320e-014
Cn18an22a3 TDn18a5 TDn22a5 1.302320e-014
Cn18an22a4 TDn18a7 TDn22a7 1.302320e-014
Cn18an22a5 TDn18a9 TDn22a9 1.302320e-014
Cn18an22a6 TDn18a11 TDn22a11 1.302320e-014
Cn18an22a7 TDn18a13 TDn22a13 1.302320e-014
Cn18an22a8 TDn18a15 TDn22a15 1.302320e-014
Cn18an22a9 TDn18a17 TDn22a17 1.302320e-014
Cn18an22a10 TDn18a19 TDn22a19 1.302320e-014
Cn18an22a11 TDn18a21 TDn22a21 1.302320e-014
Cn18an22a12 TDn18a23 TDn22a23 1.302320e-014
Cn18an22a13 TDn18a25 TDn22a25 1.302320e-014
Cn18an22a14 TDn18a27 TDn22a27 1.302320e-014
Cn18an22a15 TDn18a29 TDn22a29 1.302320e-014
Cn18an22a16 TDn18a31 TDn22a31 1.302320e-014
Cn18an22a17 TDn18a33 TDn22a33 1.690880e-014
Cn18an23a1 TDn18a1 TDn23a1 1.690880e-014
Cn18an23a2 TDn18a3 TDn23a3 1.302320e-014
Cn18an23a3 TDn18a5 TDn23a5 1.302320e-014
Cn18an23a4 TDn18a7 TDn23a7 1.302320e-014
Cn18an23a5 TDn18a9 TDn23a9 1.302320e-014
Cn18an23a6 TDn18a11 TDn23a11 1.302320e-014
Cn18an23a7 TDn18a13 TDn23a13 1.302320e-014
Cn18an23a8 TDn18a15 TDn23a15 1.302320e-014
Cn18an23a9 TDn18a17 TDn23a17 1.302320e-014
Cn18an23a10 TDn18a19 TDn23a19 1.302320e-014
Cn18an23a11 TDn18a21 TDn23a21 1.302320e-014
Cn18an23a12 TDn18a23 TDn23a23 1.302320e-014
Cn18an23a13 TDn18a25 TDn23a25 1.302320e-014
Cn18an23a14 TDn18a27 TDn23a27 1.302320e-014
Cn18an23a15 TDn18a29 TDn23a29 1.302320e-014
Cn18an23a16 TDn18a31 TDn23a31 1.302320e-014
Cn18an23a17 TDn18a33 TDn23a33 1.690880e-014
Cn18an24a1 TDn18a1 TDn24a1 1.690880e-014
Cn18an24a2 TDn18a3 TDn24a3 1.302320e-014
Cn18an24a3 TDn18a5 TDn24a5 1.302320e-014
Cn18an24a4 TDn18a7 TDn24a7 1.302320e-014
Cn18an24a5 TDn18a9 TDn24a9 1.302320e-014
Cn18an24a6 TDn18a11 TDn24a11 1.302320e-014
Cn18an24a7 TDn18a13 TDn24a13 1.302320e-014
Cn18an24a8 TDn18a15 TDn24a15 1.302320e-014
Cn18an24a9 TDn18a17 TDn24a17 1.302320e-014
Cn18an24a10 TDn18a19 TDn24a19 1.302320e-014
Cn18an24a11 TDn18a21 TDn24a21 1.302320e-014
Cn18an24a12 TDn18a23 TDn24a23 1.302320e-014
Cn18an24a13 TDn18a25 TDn24a25 1.302320e-014
Cn18an24a14 TDn18a27 TDn24a27 1.302320e-014
Cn18an24a15 TDn18a29 TDn24a29 1.302320e-014
Cn18an24a16 TDn18a31 TDn24a31 1.302320e-014
Cn18an24a17 TDn18a33 TDn24a33 1.690880e-014
Cn18an25a1 TDn18a1 TDn25a1 1.690880e-014
Cn18an25a2 TDn18a3 TDn25a3 1.302320e-014
Cn18an25a3 TDn18a5 TDn25a5 1.302320e-014
Cn18an25a4 TDn18a7 TDn25a7 1.302320e-014
Cn18an25a5 TDn18a9 TDn25a9 1.302320e-014
Cn18an25a6 TDn18a11 TDn25a11 1.302320e-014
Cn18an25a7 TDn18a13 TDn25a13 1.302320e-014
Cn18an25a8 TDn18a15 TDn25a15 1.302320e-014
Cn18an25a9 TDn18a17 TDn25a17 1.302320e-014
Cn18an25a10 TDn18a19 TDn25a19 1.302320e-014
Cn18an25a11 TDn18a21 TDn25a21 1.302320e-014
Cn18an25a12 TDn18a23 TDn25a23 1.302320e-014
Cn18an25a13 TDn18a25 TDn25a25 1.302320e-014
Cn18an25a14 TDn18a27 TDn25a27 1.302320e-014
Cn18an25a15 TDn18a29 TDn25a29 1.302320e-014
Cn18an25a16 TDn18a31 TDn25a31 1.302320e-014
Cn18an25a17 TDn18a33 TDn25a33 1.690880e-014
Cn18an26a1 TDn18a1 TDn26a1 1.690880e-014
Cn18an26a2 TDn18a3 TDn26a3 1.302320e-014
Cn18an26a3 TDn18a5 TDn26a5 1.302320e-014
Cn18an26a4 TDn18a7 TDn26a7 1.302320e-014
Cn18an26a5 TDn18a9 TDn26a9 1.302320e-014
Cn18an26a6 TDn18a11 TDn26a11 1.302320e-014
Cn18an26a7 TDn18a13 TDn26a13 1.302320e-014
Cn18an26a8 TDn18a15 TDn26a15 1.302320e-014
Cn18an26a9 TDn18a17 TDn26a17 1.302320e-014
Cn18an26a10 TDn18a19 TDn26a19 1.302320e-014
Cn18an26a11 TDn18a21 TDn26a21 1.302320e-014
Cn18an26a12 TDn18a23 TDn26a23 1.302320e-014
Cn18an26a13 TDn18a25 TDn26a25 1.302320e-014
Cn18an26a14 TDn18a27 TDn26a27 1.302320e-014
Cn18an26a15 TDn18a29 TDn26a29 1.302320e-014
Cn18an26a16 TDn18a31 TDn26a31 1.302320e-014
Cn18an26a17 TDn18a33 TDn26a33 1.690880e-014
Cn18an27a1 TDn18a1 TDn27a1 1.690880e-014
Cn18an27a2 TDn18a3 TDn27a3 1.302320e-014
Cn18an27a3 TDn18a5 TDn27a5 1.302320e-014
Cn18an27a4 TDn18a7 TDn27a7 1.302320e-014
Cn18an27a5 TDn18a9 TDn27a9 1.302320e-014
Cn18an27a6 TDn18a11 TDn27a11 1.302320e-014
Cn18an27a7 TDn18a13 TDn27a13 1.302320e-014
Cn18an27a8 TDn18a15 TDn27a15 1.302320e-014
Cn18an27a9 TDn18a17 TDn27a17 1.302320e-014
Cn18an27a10 TDn18a19 TDn27a19 1.302320e-014
Cn18an27a11 TDn18a21 TDn27a21 1.302320e-014
Cn18an27a12 TDn18a23 TDn27a23 1.302320e-014
Cn18an27a13 TDn18a25 TDn27a25 1.302320e-014
Cn18an27a14 TDn18a27 TDn27a27 1.302320e-014
Cn18an27a15 TDn18a29 TDn27a29 1.302320e-014
Cn18an27a16 TDn18a31 TDn27a31 1.302320e-014
Cn18an27a17 TDn18a33 TDn27a33 1.690880e-014
Cn18an28a1 TDn18a1 TDn28a1 1.690880e-014
Cn18an28a2 TDn18a3 TDn28a3 1.302320e-014
Cn18an28a3 TDn18a5 TDn28a5 1.302320e-014
Cn18an28a4 TDn18a7 TDn28a7 1.302320e-014
Cn18an28a5 TDn18a9 TDn28a9 1.302320e-014
Cn18an28a6 TDn18a11 TDn28a11 1.302320e-014
Cn18an28a7 TDn18a13 TDn28a13 1.302320e-014
Cn18an28a8 TDn18a15 TDn28a15 1.302320e-014
Cn18an28a9 TDn18a17 TDn28a17 1.302320e-014
Cn18an28a10 TDn18a19 TDn28a19 1.302320e-014
Cn18an28a11 TDn18a21 TDn28a21 1.302320e-014
Cn18an28a12 TDn18a23 TDn28a23 1.302320e-014
Cn18an28a13 TDn18a25 TDn28a25 1.302320e-014
Cn18an28a14 TDn18a27 TDn28a27 1.302320e-014
Cn18an28a15 TDn18a29 TDn28a29 1.302320e-014
Cn18an28a16 TDn18a31 TDn28a31 1.302320e-014
Cn18an28a17 TDn18a33 TDn28a33 1.690880e-014
Cn18an29a1 TDn18a1 TDn29a1 1.690880e-014
Cn18an29a2 TDn18a3 TDn29a3 1.302320e-014
Cn18an29a3 TDn18a5 TDn29a5 1.302320e-014
Cn18an29a4 TDn18a7 TDn29a7 1.302320e-014
Cn18an29a5 TDn18a9 TDn29a9 1.302320e-014
Cn18an29a6 TDn18a11 TDn29a11 1.302320e-014
Cn18an29a7 TDn18a13 TDn29a13 1.302320e-014
Cn18an29a8 TDn18a15 TDn29a15 1.302320e-014
Cn18an29a9 TDn18a17 TDn29a17 1.302320e-014
Cn18an29a10 TDn18a19 TDn29a19 1.302320e-014
Cn18an29a11 TDn18a21 TDn29a21 1.302320e-014
Cn18an29a12 TDn18a23 TDn29a23 1.302320e-014
Cn18an29a13 TDn18a25 TDn29a25 1.302320e-014
Cn18an29a14 TDn18a27 TDn29a27 1.302320e-014
Cn18an29a15 TDn18a29 TDn29a29 1.302320e-014
Cn18an29a16 TDn18a31 TDn29a31 1.302320e-014
Cn18an29a17 TDn18a33 TDn29a33 1.690880e-014
Cn18an30a1 TDn18a1 TDn30a1 1.690880e-014
Cn18an30a2 TDn18a3 TDn30a3 1.302320e-014
Cn18an30a3 TDn18a5 TDn30a5 1.302320e-014
Cn18an30a4 TDn18a7 TDn30a7 1.302320e-014
Cn18an30a5 TDn18a9 TDn30a9 1.302320e-014
Cn18an30a6 TDn18a11 TDn30a11 1.302320e-014
Cn18an30a7 TDn18a13 TDn30a13 1.302320e-014
Cn18an30a8 TDn18a15 TDn30a15 1.302320e-014
Cn18an30a9 TDn18a17 TDn30a17 1.302320e-014
Cn18an30a10 TDn18a19 TDn30a19 1.302320e-014
Cn18an30a11 TDn18a21 TDn30a21 1.302320e-014
Cn18an30a12 TDn18a23 TDn30a23 1.302320e-014
Cn18an30a13 TDn18a25 TDn30a25 1.302320e-014
Cn18an30a14 TDn18a27 TDn30a27 1.302320e-014
Cn18an30a15 TDn18a29 TDn30a29 1.302320e-014
Cn18an30a16 TDn18a31 TDn30a31 1.302320e-014
Cn18an30a17 TDn18a33 TDn30a33 1.690880e-014
Cn18an31a1 TDn18a1 TDn31a1 1.690880e-014
Cn18an31a2 TDn18a3 TDn31a3 1.302320e-014
Cn18an31a3 TDn18a5 TDn31a5 1.302320e-014
Cn18an31a4 TDn18a7 TDn31a7 1.302320e-014
Cn18an31a5 TDn18a9 TDn31a9 1.302320e-014
Cn18an31a6 TDn18a11 TDn31a11 1.302320e-014
Cn18an31a7 TDn18a13 TDn31a13 1.302320e-014
Cn18an31a8 TDn18a15 TDn31a15 1.302320e-014
Cn18an31a9 TDn18a17 TDn31a17 1.302320e-014
Cn18an31a10 TDn18a19 TDn31a19 1.302320e-014
Cn18an31a11 TDn18a21 TDn31a21 1.302320e-014
Cn18an31a12 TDn18a23 TDn31a23 1.302320e-014
Cn18an31a13 TDn18a25 TDn31a25 1.302320e-014
Cn18an31a14 TDn18a27 TDn31a27 1.302320e-014
Cn18an31a15 TDn18a29 TDn31a29 1.302320e-014
Cn18an31a16 TDn18a31 TDn31a31 1.302320e-014
Cn18an31a17 TDn18a33 TDn31a33 1.690880e-014
Cn18an32a1 TDn18a1 TDn32a1 1.690880e-014
Cn18an32a2 TDn18a3 TDn32a3 1.302320e-014
Cn18an32a3 TDn18a5 TDn32a5 1.302320e-014
Cn18an32a4 TDn18a7 TDn32a7 1.302320e-014
Cn18an32a5 TDn18a9 TDn32a9 1.302320e-014
Cn18an32a6 TDn18a11 TDn32a11 1.302320e-014
Cn18an32a7 TDn18a13 TDn32a13 1.302320e-014
Cn18an32a8 TDn18a15 TDn32a15 1.302320e-014
Cn18an32a9 TDn18a17 TDn32a17 1.302320e-014
Cn18an32a10 TDn18a19 TDn32a19 1.302320e-014
Cn18an32a11 TDn18a21 TDn32a21 1.302320e-014
Cn18an32a12 TDn18a23 TDn32a23 1.302320e-014
Cn18an32a13 TDn18a25 TDn32a25 1.302320e-014
Cn18an32a14 TDn18a27 TDn32a27 1.302320e-014
Cn18an32a15 TDn18a29 TDn32a29 1.302320e-014
Cn18an32a16 TDn18a31 TDn32a31 1.302320e-014
Cn18an32a17 TDn18a33 TDn32a33 1.690880e-014
Cn18anva1 TDn18a1 TDnva1 1.690880e-014
Cn18anva2 TDn18a3 TDnva3 1.690880e-014
Cn18anva3 TDn18a5 TDnva5 1.690880e-014
Cn18anva4 TDn18a7 TDnva7 1.690880e-014
Cn18anva5 TDn18a9 TDnva9 1.690880e-014
Cn18anva6 TDn18a11 TDnva11 1.690880e-014
Cn18anva7 TDn18a13 TDnva13 1.690880e-014
Cn18anva8 TDn18a15 TDnva15 1.690880e-014
Cn18anva9 TDn18a17 TDnva17 1.690880e-014
Cn18anva10 TDn18a19 TDnva19 1.690880e-014
Cn18anva11 TDn18a21 TDnva21 1.690880e-014
Cn18anva12 TDn18a23 TDnva23 1.690880e-014
Cn18anva13 TDn18a25 TDnva25 1.690880e-014
Cn18anva14 TDn18a27 TDnva27 1.690880e-014
Cn18anva15 TDn18a29 TDnva29 1.690880e-014
Cn18anva16 TDn18a31 TDnva31 1.690880e-014
Cn18anva17 TDn18a33 TDnva33 1.690880e-014
Cn19an20a1 TDn19a1 TDn20a1 1.690880e-014
Cn19an20a2 TDn19a3 TDn20a3 1.302320e-014
Cn19an20a3 TDn19a5 TDn20a5 1.302320e-014
Cn19an20a4 TDn19a7 TDn20a7 1.302320e-014
Cn19an20a5 TDn19a9 TDn20a9 1.302320e-014
Cn19an20a6 TDn19a11 TDn20a11 1.302320e-014
Cn19an20a7 TDn19a13 TDn20a13 1.302320e-014
Cn19an20a8 TDn19a15 TDn20a15 1.302320e-014
Cn19an20a9 TDn19a17 TDn20a17 1.302320e-014
Cn19an20a10 TDn19a19 TDn20a19 1.302320e-014
Cn19an20a11 TDn19a21 TDn20a21 1.302320e-014
Cn19an20a12 TDn19a23 TDn20a23 1.302320e-014
Cn19an20a13 TDn19a25 TDn20a25 1.302320e-014
Cn19an20a14 TDn19a27 TDn20a27 1.302320e-014
Cn19an20a15 TDn19a29 TDn20a29 1.302320e-014
Cn19an20a16 TDn19a31 TDn20a31 1.302320e-014
Cn19an20a17 TDn19a33 TDn20a33 1.690880e-014
Cn19an21a1 TDn19a1 TDn21a1 1.690880e-014
Cn19an21a2 TDn19a3 TDn21a3 1.302320e-014
Cn19an21a3 TDn19a5 TDn21a5 1.302320e-014
Cn19an21a4 TDn19a7 TDn21a7 1.302320e-014
Cn19an21a5 TDn19a9 TDn21a9 1.302320e-014
Cn19an21a6 TDn19a11 TDn21a11 1.302320e-014
Cn19an21a7 TDn19a13 TDn21a13 1.302320e-014
Cn19an21a8 TDn19a15 TDn21a15 1.302320e-014
Cn19an21a9 TDn19a17 TDn21a17 1.302320e-014
Cn19an21a10 TDn19a19 TDn21a19 1.302320e-014
Cn19an21a11 TDn19a21 TDn21a21 1.302320e-014
Cn19an21a12 TDn19a23 TDn21a23 1.302320e-014
Cn19an21a13 TDn19a25 TDn21a25 1.302320e-014
Cn19an21a14 TDn19a27 TDn21a27 1.302320e-014
Cn19an21a15 TDn19a29 TDn21a29 1.302320e-014
Cn19an21a16 TDn19a31 TDn21a31 1.302320e-014
Cn19an21a17 TDn19a33 TDn21a33 1.690880e-014
Cn19an22a1 TDn19a1 TDn22a1 1.690880e-014
Cn19an22a2 TDn19a3 TDn22a3 1.302320e-014
Cn19an22a3 TDn19a5 TDn22a5 1.302320e-014
Cn19an22a4 TDn19a7 TDn22a7 1.302320e-014
Cn19an22a5 TDn19a9 TDn22a9 1.302320e-014
Cn19an22a6 TDn19a11 TDn22a11 1.302320e-014
Cn19an22a7 TDn19a13 TDn22a13 1.302320e-014
Cn19an22a8 TDn19a15 TDn22a15 1.302320e-014
Cn19an22a9 TDn19a17 TDn22a17 1.302320e-014
Cn19an22a10 TDn19a19 TDn22a19 1.302320e-014
Cn19an22a11 TDn19a21 TDn22a21 1.302320e-014
Cn19an22a12 TDn19a23 TDn22a23 1.302320e-014
Cn19an22a13 TDn19a25 TDn22a25 1.302320e-014
Cn19an22a14 TDn19a27 TDn22a27 1.302320e-014
Cn19an22a15 TDn19a29 TDn22a29 1.302320e-014
Cn19an22a16 TDn19a31 TDn22a31 1.302320e-014
Cn19an22a17 TDn19a33 TDn22a33 1.690880e-014
Cn19an23a1 TDn19a1 TDn23a1 1.690880e-014
Cn19an23a2 TDn19a3 TDn23a3 1.302320e-014
Cn19an23a3 TDn19a5 TDn23a5 1.302320e-014
Cn19an23a4 TDn19a7 TDn23a7 1.302320e-014
Cn19an23a5 TDn19a9 TDn23a9 1.302320e-014
Cn19an23a6 TDn19a11 TDn23a11 1.302320e-014
Cn19an23a7 TDn19a13 TDn23a13 1.302320e-014
Cn19an23a8 TDn19a15 TDn23a15 1.302320e-014
Cn19an23a9 TDn19a17 TDn23a17 1.302320e-014
Cn19an23a10 TDn19a19 TDn23a19 1.302320e-014
Cn19an23a11 TDn19a21 TDn23a21 1.302320e-014
Cn19an23a12 TDn19a23 TDn23a23 1.302320e-014
Cn19an23a13 TDn19a25 TDn23a25 1.302320e-014
Cn19an23a14 TDn19a27 TDn23a27 1.302320e-014
Cn19an23a15 TDn19a29 TDn23a29 1.302320e-014
Cn19an23a16 TDn19a31 TDn23a31 1.302320e-014
Cn19an23a17 TDn19a33 TDn23a33 1.690880e-014
Cn19an24a1 TDn19a1 TDn24a1 1.690880e-014
Cn19an24a2 TDn19a3 TDn24a3 1.302320e-014
Cn19an24a3 TDn19a5 TDn24a5 1.302320e-014
Cn19an24a4 TDn19a7 TDn24a7 1.302320e-014
Cn19an24a5 TDn19a9 TDn24a9 1.302320e-014
Cn19an24a6 TDn19a11 TDn24a11 1.302320e-014
Cn19an24a7 TDn19a13 TDn24a13 1.302320e-014
Cn19an24a8 TDn19a15 TDn24a15 1.302320e-014
Cn19an24a9 TDn19a17 TDn24a17 1.302320e-014
Cn19an24a10 TDn19a19 TDn24a19 1.302320e-014
Cn19an24a11 TDn19a21 TDn24a21 1.302320e-014
Cn19an24a12 TDn19a23 TDn24a23 1.302320e-014
Cn19an24a13 TDn19a25 TDn24a25 1.302320e-014
Cn19an24a14 TDn19a27 TDn24a27 1.302320e-014
Cn19an24a15 TDn19a29 TDn24a29 1.302320e-014
Cn19an24a16 TDn19a31 TDn24a31 1.302320e-014
Cn19an24a17 TDn19a33 TDn24a33 1.690880e-014
Cn19an25a1 TDn19a1 TDn25a1 1.690880e-014
Cn19an25a2 TDn19a3 TDn25a3 1.302320e-014
Cn19an25a3 TDn19a5 TDn25a5 1.302320e-014
Cn19an25a4 TDn19a7 TDn25a7 1.302320e-014
Cn19an25a5 TDn19a9 TDn25a9 1.302320e-014
Cn19an25a6 TDn19a11 TDn25a11 1.302320e-014
Cn19an25a7 TDn19a13 TDn25a13 1.302320e-014
Cn19an25a8 TDn19a15 TDn25a15 1.302320e-014
Cn19an25a9 TDn19a17 TDn25a17 1.302320e-014
Cn19an25a10 TDn19a19 TDn25a19 1.302320e-014
Cn19an25a11 TDn19a21 TDn25a21 1.302320e-014
Cn19an25a12 TDn19a23 TDn25a23 1.302320e-014
Cn19an25a13 TDn19a25 TDn25a25 1.302320e-014
Cn19an25a14 TDn19a27 TDn25a27 1.302320e-014
Cn19an25a15 TDn19a29 TDn25a29 1.302320e-014
Cn19an25a16 TDn19a31 TDn25a31 1.302320e-014
Cn19an25a17 TDn19a33 TDn25a33 1.690880e-014
Cn19an26a1 TDn19a1 TDn26a1 1.690880e-014
Cn19an26a2 TDn19a3 TDn26a3 1.302320e-014
Cn19an26a3 TDn19a5 TDn26a5 1.302320e-014
Cn19an26a4 TDn19a7 TDn26a7 1.302320e-014
Cn19an26a5 TDn19a9 TDn26a9 1.302320e-014
Cn19an26a6 TDn19a11 TDn26a11 1.302320e-014
Cn19an26a7 TDn19a13 TDn26a13 1.302320e-014
Cn19an26a8 TDn19a15 TDn26a15 1.302320e-014
Cn19an26a9 TDn19a17 TDn26a17 1.302320e-014
Cn19an26a10 TDn19a19 TDn26a19 1.302320e-014
Cn19an26a11 TDn19a21 TDn26a21 1.302320e-014
Cn19an26a12 TDn19a23 TDn26a23 1.302320e-014
Cn19an26a13 TDn19a25 TDn26a25 1.302320e-014
Cn19an26a14 TDn19a27 TDn26a27 1.302320e-014
Cn19an26a15 TDn19a29 TDn26a29 1.302320e-014
Cn19an26a16 TDn19a31 TDn26a31 1.302320e-014
Cn19an26a17 TDn19a33 TDn26a33 1.690880e-014
Cn19an27a1 TDn19a1 TDn27a1 1.690880e-014
Cn19an27a2 TDn19a3 TDn27a3 1.302320e-014
Cn19an27a3 TDn19a5 TDn27a5 1.302320e-014
Cn19an27a4 TDn19a7 TDn27a7 1.302320e-014
Cn19an27a5 TDn19a9 TDn27a9 1.302320e-014
Cn19an27a6 TDn19a11 TDn27a11 1.302320e-014
Cn19an27a7 TDn19a13 TDn27a13 1.302320e-014
Cn19an27a8 TDn19a15 TDn27a15 1.302320e-014
Cn19an27a9 TDn19a17 TDn27a17 1.302320e-014
Cn19an27a10 TDn19a19 TDn27a19 1.302320e-014
Cn19an27a11 TDn19a21 TDn27a21 1.302320e-014
Cn19an27a12 TDn19a23 TDn27a23 1.302320e-014
Cn19an27a13 TDn19a25 TDn27a25 1.302320e-014
Cn19an27a14 TDn19a27 TDn27a27 1.302320e-014
Cn19an27a15 TDn19a29 TDn27a29 1.302320e-014
Cn19an27a16 TDn19a31 TDn27a31 1.302320e-014
Cn19an27a17 TDn19a33 TDn27a33 1.690880e-014
Cn19an28a1 TDn19a1 TDn28a1 1.690880e-014
Cn19an28a2 TDn19a3 TDn28a3 1.302320e-014
Cn19an28a3 TDn19a5 TDn28a5 1.302320e-014
Cn19an28a4 TDn19a7 TDn28a7 1.302320e-014
Cn19an28a5 TDn19a9 TDn28a9 1.302320e-014
Cn19an28a6 TDn19a11 TDn28a11 1.302320e-014
Cn19an28a7 TDn19a13 TDn28a13 1.302320e-014
Cn19an28a8 TDn19a15 TDn28a15 1.302320e-014
Cn19an28a9 TDn19a17 TDn28a17 1.302320e-014
Cn19an28a10 TDn19a19 TDn28a19 1.302320e-014
Cn19an28a11 TDn19a21 TDn28a21 1.302320e-014
Cn19an28a12 TDn19a23 TDn28a23 1.302320e-014
Cn19an28a13 TDn19a25 TDn28a25 1.302320e-014
Cn19an28a14 TDn19a27 TDn28a27 1.302320e-014
Cn19an28a15 TDn19a29 TDn28a29 1.302320e-014
Cn19an28a16 TDn19a31 TDn28a31 1.302320e-014
Cn19an28a17 TDn19a33 TDn28a33 1.690880e-014
Cn19an29a1 TDn19a1 TDn29a1 1.690880e-014
Cn19an29a2 TDn19a3 TDn29a3 1.302320e-014
Cn19an29a3 TDn19a5 TDn29a5 1.302320e-014
Cn19an29a4 TDn19a7 TDn29a7 1.302320e-014
Cn19an29a5 TDn19a9 TDn29a9 1.302320e-014
Cn19an29a6 TDn19a11 TDn29a11 1.302320e-014
Cn19an29a7 TDn19a13 TDn29a13 1.302320e-014
Cn19an29a8 TDn19a15 TDn29a15 1.302320e-014
Cn19an29a9 TDn19a17 TDn29a17 1.302320e-014
Cn19an29a10 TDn19a19 TDn29a19 1.302320e-014
Cn19an29a11 TDn19a21 TDn29a21 1.302320e-014
Cn19an29a12 TDn19a23 TDn29a23 1.302320e-014
Cn19an29a13 TDn19a25 TDn29a25 1.302320e-014
Cn19an29a14 TDn19a27 TDn29a27 1.302320e-014
Cn19an29a15 TDn19a29 TDn29a29 1.302320e-014
Cn19an29a16 TDn19a31 TDn29a31 1.302320e-014
Cn19an29a17 TDn19a33 TDn29a33 1.690880e-014
Cn19an30a1 TDn19a1 TDn30a1 1.690880e-014
Cn19an30a2 TDn19a3 TDn30a3 1.302320e-014
Cn19an30a3 TDn19a5 TDn30a5 1.302320e-014
Cn19an30a4 TDn19a7 TDn30a7 1.302320e-014
Cn19an30a5 TDn19a9 TDn30a9 1.302320e-014
Cn19an30a6 TDn19a11 TDn30a11 1.302320e-014
Cn19an30a7 TDn19a13 TDn30a13 1.302320e-014
Cn19an30a8 TDn19a15 TDn30a15 1.302320e-014
Cn19an30a9 TDn19a17 TDn30a17 1.302320e-014
Cn19an30a10 TDn19a19 TDn30a19 1.302320e-014
Cn19an30a11 TDn19a21 TDn30a21 1.302320e-014
Cn19an30a12 TDn19a23 TDn30a23 1.302320e-014
Cn19an30a13 TDn19a25 TDn30a25 1.302320e-014
Cn19an30a14 TDn19a27 TDn30a27 1.302320e-014
Cn19an30a15 TDn19a29 TDn30a29 1.302320e-014
Cn19an30a16 TDn19a31 TDn30a31 1.302320e-014
Cn19an30a17 TDn19a33 TDn30a33 1.690880e-014
Cn19an31a1 TDn19a1 TDn31a1 1.690880e-014
Cn19an31a2 TDn19a3 TDn31a3 1.302320e-014
Cn19an31a3 TDn19a5 TDn31a5 1.302320e-014
Cn19an31a4 TDn19a7 TDn31a7 1.302320e-014
Cn19an31a5 TDn19a9 TDn31a9 1.302320e-014
Cn19an31a6 TDn19a11 TDn31a11 1.302320e-014
Cn19an31a7 TDn19a13 TDn31a13 1.302320e-014
Cn19an31a8 TDn19a15 TDn31a15 1.302320e-014
Cn19an31a9 TDn19a17 TDn31a17 1.302320e-014
Cn19an31a10 TDn19a19 TDn31a19 1.302320e-014
Cn19an31a11 TDn19a21 TDn31a21 1.302320e-014
Cn19an31a12 TDn19a23 TDn31a23 1.302320e-014
Cn19an31a13 TDn19a25 TDn31a25 1.302320e-014
Cn19an31a14 TDn19a27 TDn31a27 1.302320e-014
Cn19an31a15 TDn19a29 TDn31a29 1.302320e-014
Cn19an31a16 TDn19a31 TDn31a31 1.302320e-014
Cn19an31a17 TDn19a33 TDn31a33 1.690880e-014
Cn19an32a1 TDn19a1 TDn32a1 1.690880e-014
Cn19an32a2 TDn19a3 TDn32a3 1.302320e-014
Cn19an32a3 TDn19a5 TDn32a5 1.302320e-014
Cn19an32a4 TDn19a7 TDn32a7 1.302320e-014
Cn19an32a5 TDn19a9 TDn32a9 1.302320e-014
Cn19an32a6 TDn19a11 TDn32a11 1.302320e-014
Cn19an32a7 TDn19a13 TDn32a13 1.302320e-014
Cn19an32a8 TDn19a15 TDn32a15 1.302320e-014
Cn19an32a9 TDn19a17 TDn32a17 1.302320e-014
Cn19an32a10 TDn19a19 TDn32a19 1.302320e-014
Cn19an32a11 TDn19a21 TDn32a21 1.302320e-014
Cn19an32a12 TDn19a23 TDn32a23 1.302320e-014
Cn19an32a13 TDn19a25 TDn32a25 1.302320e-014
Cn19an32a14 TDn19a27 TDn32a27 1.302320e-014
Cn19an32a15 TDn19a29 TDn32a29 1.302320e-014
Cn19an32a16 TDn19a31 TDn32a31 1.302320e-014
Cn19an32a17 TDn19a33 TDn32a33 1.690880e-014
Cn19anva1 TDn19a1 TDnva1 1.690880e-014
Cn19anva2 TDn19a3 TDnva3 1.690880e-014
Cn19anva3 TDn19a5 TDnva5 1.690880e-014
Cn19anva4 TDn19a7 TDnva7 1.690880e-014
Cn19anva5 TDn19a9 TDnva9 1.690880e-014
Cn19anva6 TDn19a11 TDnva11 1.690880e-014
Cn19anva7 TDn19a13 TDnva13 1.690880e-014
Cn19anva8 TDn19a15 TDnva15 1.690880e-014
Cn19anva9 TDn19a17 TDnva17 1.690880e-014
Cn19anva10 TDn19a19 TDnva19 1.690880e-014
Cn19anva11 TDn19a21 TDnva21 1.690880e-014
Cn19anva12 TDn19a23 TDnva23 1.690880e-014
Cn19anva13 TDn19a25 TDnva25 1.690880e-014
Cn19anva14 TDn19a27 TDnva27 1.690880e-014
Cn19anva15 TDn19a29 TDnva29 1.690880e-014
Cn19anva16 TDn19a31 TDnva31 1.690880e-014
Cn19anva17 TDn19a33 TDnva33 1.690880e-014
Cn20an21a1 TDn20a1 TDn21a1 1.690880e-014
Cn20an21a2 TDn20a3 TDn21a3 1.302320e-014
Cn20an21a3 TDn20a5 TDn21a5 1.302320e-014
Cn20an21a4 TDn20a7 TDn21a7 1.302320e-014
Cn20an21a5 TDn20a9 TDn21a9 1.302320e-014
Cn20an21a6 TDn20a11 TDn21a11 1.302320e-014
Cn20an21a7 TDn20a13 TDn21a13 1.302320e-014
Cn20an21a8 TDn20a15 TDn21a15 1.302320e-014
Cn20an21a9 TDn20a17 TDn21a17 1.302320e-014
Cn20an21a10 TDn20a19 TDn21a19 1.302320e-014
Cn20an21a11 TDn20a21 TDn21a21 1.302320e-014
Cn20an21a12 TDn20a23 TDn21a23 1.302320e-014
Cn20an21a13 TDn20a25 TDn21a25 1.302320e-014
Cn20an21a14 TDn20a27 TDn21a27 1.302320e-014
Cn20an21a15 TDn20a29 TDn21a29 1.302320e-014
Cn20an21a16 TDn20a31 TDn21a31 1.302320e-014
Cn20an21a17 TDn20a33 TDn21a33 1.690880e-014
Cn20an22a1 TDn20a1 TDn22a1 1.690880e-014
Cn20an22a2 TDn20a3 TDn22a3 1.302320e-014
Cn20an22a3 TDn20a5 TDn22a5 1.302320e-014
Cn20an22a4 TDn20a7 TDn22a7 1.302320e-014
Cn20an22a5 TDn20a9 TDn22a9 1.302320e-014
Cn20an22a6 TDn20a11 TDn22a11 1.302320e-014
Cn20an22a7 TDn20a13 TDn22a13 1.302320e-014
Cn20an22a8 TDn20a15 TDn22a15 1.302320e-014
Cn20an22a9 TDn20a17 TDn22a17 1.302320e-014
Cn20an22a10 TDn20a19 TDn22a19 1.302320e-014
Cn20an22a11 TDn20a21 TDn22a21 1.302320e-014
Cn20an22a12 TDn20a23 TDn22a23 1.302320e-014
Cn20an22a13 TDn20a25 TDn22a25 1.302320e-014
Cn20an22a14 TDn20a27 TDn22a27 1.302320e-014
Cn20an22a15 TDn20a29 TDn22a29 1.302320e-014
Cn20an22a16 TDn20a31 TDn22a31 1.302320e-014
Cn20an22a17 TDn20a33 TDn22a33 1.690880e-014
Cn20an23a1 TDn20a1 TDn23a1 1.690880e-014
Cn20an23a2 TDn20a3 TDn23a3 1.302320e-014
Cn20an23a3 TDn20a5 TDn23a5 1.302320e-014
Cn20an23a4 TDn20a7 TDn23a7 1.302320e-014
Cn20an23a5 TDn20a9 TDn23a9 1.302320e-014
Cn20an23a6 TDn20a11 TDn23a11 1.302320e-014
Cn20an23a7 TDn20a13 TDn23a13 1.302320e-014
Cn20an23a8 TDn20a15 TDn23a15 1.302320e-014
Cn20an23a9 TDn20a17 TDn23a17 1.302320e-014
Cn20an23a10 TDn20a19 TDn23a19 1.302320e-014
Cn20an23a11 TDn20a21 TDn23a21 1.302320e-014
Cn20an23a12 TDn20a23 TDn23a23 1.302320e-014
Cn20an23a13 TDn20a25 TDn23a25 1.302320e-014
Cn20an23a14 TDn20a27 TDn23a27 1.302320e-014
Cn20an23a15 TDn20a29 TDn23a29 1.302320e-014
Cn20an23a16 TDn20a31 TDn23a31 1.302320e-014
Cn20an23a17 TDn20a33 TDn23a33 1.690880e-014
Cn20an24a1 TDn20a1 TDn24a1 1.690880e-014
Cn20an24a2 TDn20a3 TDn24a3 1.302320e-014
Cn20an24a3 TDn20a5 TDn24a5 1.302320e-014
Cn20an24a4 TDn20a7 TDn24a7 1.302320e-014
Cn20an24a5 TDn20a9 TDn24a9 1.302320e-014
Cn20an24a6 TDn20a11 TDn24a11 1.302320e-014
Cn20an24a7 TDn20a13 TDn24a13 1.302320e-014
Cn20an24a8 TDn20a15 TDn24a15 1.302320e-014
Cn20an24a9 TDn20a17 TDn24a17 1.302320e-014
Cn20an24a10 TDn20a19 TDn24a19 1.302320e-014
Cn20an24a11 TDn20a21 TDn24a21 1.302320e-014
Cn20an24a12 TDn20a23 TDn24a23 1.302320e-014
Cn20an24a13 TDn20a25 TDn24a25 1.302320e-014
Cn20an24a14 TDn20a27 TDn24a27 1.302320e-014
Cn20an24a15 TDn20a29 TDn24a29 1.302320e-014
Cn20an24a16 TDn20a31 TDn24a31 1.302320e-014
Cn20an24a17 TDn20a33 TDn24a33 1.690880e-014
Cn20an25a1 TDn20a1 TDn25a1 1.690880e-014
Cn20an25a2 TDn20a3 TDn25a3 1.302320e-014
Cn20an25a3 TDn20a5 TDn25a5 1.302320e-014
Cn20an25a4 TDn20a7 TDn25a7 1.302320e-014
Cn20an25a5 TDn20a9 TDn25a9 1.302320e-014
Cn20an25a6 TDn20a11 TDn25a11 1.302320e-014
Cn20an25a7 TDn20a13 TDn25a13 1.302320e-014
Cn20an25a8 TDn20a15 TDn25a15 1.302320e-014
Cn20an25a9 TDn20a17 TDn25a17 1.302320e-014
Cn20an25a10 TDn20a19 TDn25a19 1.302320e-014
Cn20an25a11 TDn20a21 TDn25a21 1.302320e-014
Cn20an25a12 TDn20a23 TDn25a23 1.302320e-014
Cn20an25a13 TDn20a25 TDn25a25 1.302320e-014
Cn20an25a14 TDn20a27 TDn25a27 1.302320e-014
Cn20an25a15 TDn20a29 TDn25a29 1.302320e-014
Cn20an25a16 TDn20a31 TDn25a31 1.302320e-014
Cn20an25a17 TDn20a33 TDn25a33 1.690880e-014
Cn20an26a1 TDn20a1 TDn26a1 1.690880e-014
Cn20an26a2 TDn20a3 TDn26a3 1.302320e-014
Cn20an26a3 TDn20a5 TDn26a5 1.302320e-014
Cn20an26a4 TDn20a7 TDn26a7 1.302320e-014
Cn20an26a5 TDn20a9 TDn26a9 1.302320e-014
Cn20an26a6 TDn20a11 TDn26a11 1.302320e-014
Cn20an26a7 TDn20a13 TDn26a13 1.302320e-014
Cn20an26a8 TDn20a15 TDn26a15 1.302320e-014
Cn20an26a9 TDn20a17 TDn26a17 1.302320e-014
Cn20an26a10 TDn20a19 TDn26a19 1.302320e-014
Cn20an26a11 TDn20a21 TDn26a21 1.302320e-014
Cn20an26a12 TDn20a23 TDn26a23 1.302320e-014
Cn20an26a13 TDn20a25 TDn26a25 1.302320e-014
Cn20an26a14 TDn20a27 TDn26a27 1.302320e-014
Cn20an26a15 TDn20a29 TDn26a29 1.302320e-014
Cn20an26a16 TDn20a31 TDn26a31 1.302320e-014
Cn20an26a17 TDn20a33 TDn26a33 1.690880e-014
Cn20an27a1 TDn20a1 TDn27a1 1.690880e-014
Cn20an27a2 TDn20a3 TDn27a3 1.302320e-014
Cn20an27a3 TDn20a5 TDn27a5 1.302320e-014
Cn20an27a4 TDn20a7 TDn27a7 1.302320e-014
Cn20an27a5 TDn20a9 TDn27a9 1.302320e-014
Cn20an27a6 TDn20a11 TDn27a11 1.302320e-014
Cn20an27a7 TDn20a13 TDn27a13 1.302320e-014
Cn20an27a8 TDn20a15 TDn27a15 1.302320e-014
Cn20an27a9 TDn20a17 TDn27a17 1.302320e-014
Cn20an27a10 TDn20a19 TDn27a19 1.302320e-014
Cn20an27a11 TDn20a21 TDn27a21 1.302320e-014
Cn20an27a12 TDn20a23 TDn27a23 1.302320e-014
Cn20an27a13 TDn20a25 TDn27a25 1.302320e-014
Cn20an27a14 TDn20a27 TDn27a27 1.302320e-014
Cn20an27a15 TDn20a29 TDn27a29 1.302320e-014
Cn20an27a16 TDn20a31 TDn27a31 1.302320e-014
Cn20an27a17 TDn20a33 TDn27a33 1.690880e-014
Cn20an28a1 TDn20a1 TDn28a1 1.690880e-014
Cn20an28a2 TDn20a3 TDn28a3 1.302320e-014
Cn20an28a3 TDn20a5 TDn28a5 1.302320e-014
Cn20an28a4 TDn20a7 TDn28a7 1.302320e-014
Cn20an28a5 TDn20a9 TDn28a9 1.302320e-014
Cn20an28a6 TDn20a11 TDn28a11 1.302320e-014
Cn20an28a7 TDn20a13 TDn28a13 1.302320e-014
Cn20an28a8 TDn20a15 TDn28a15 1.302320e-014
Cn20an28a9 TDn20a17 TDn28a17 1.302320e-014
Cn20an28a10 TDn20a19 TDn28a19 1.302320e-014
Cn20an28a11 TDn20a21 TDn28a21 1.302320e-014
Cn20an28a12 TDn20a23 TDn28a23 1.302320e-014
Cn20an28a13 TDn20a25 TDn28a25 1.302320e-014
Cn20an28a14 TDn20a27 TDn28a27 1.302320e-014
Cn20an28a15 TDn20a29 TDn28a29 1.302320e-014
Cn20an28a16 TDn20a31 TDn28a31 1.302320e-014
Cn20an28a17 TDn20a33 TDn28a33 1.690880e-014
Cn20an29a1 TDn20a1 TDn29a1 1.690880e-014
Cn20an29a2 TDn20a3 TDn29a3 1.302320e-014
Cn20an29a3 TDn20a5 TDn29a5 1.302320e-014
Cn20an29a4 TDn20a7 TDn29a7 1.302320e-014
Cn20an29a5 TDn20a9 TDn29a9 1.302320e-014
Cn20an29a6 TDn20a11 TDn29a11 1.302320e-014
Cn20an29a7 TDn20a13 TDn29a13 1.302320e-014
Cn20an29a8 TDn20a15 TDn29a15 1.302320e-014
Cn20an29a9 TDn20a17 TDn29a17 1.302320e-014
Cn20an29a10 TDn20a19 TDn29a19 1.302320e-014
Cn20an29a11 TDn20a21 TDn29a21 1.302320e-014
Cn20an29a12 TDn20a23 TDn29a23 1.302320e-014
Cn20an29a13 TDn20a25 TDn29a25 1.302320e-014
Cn20an29a14 TDn20a27 TDn29a27 1.302320e-014
Cn20an29a15 TDn20a29 TDn29a29 1.302320e-014
Cn20an29a16 TDn20a31 TDn29a31 1.302320e-014
Cn20an29a17 TDn20a33 TDn29a33 1.690880e-014
Cn20an30a1 TDn20a1 TDn30a1 1.690880e-014
Cn20an30a2 TDn20a3 TDn30a3 1.302320e-014
Cn20an30a3 TDn20a5 TDn30a5 1.302320e-014
Cn20an30a4 TDn20a7 TDn30a7 1.302320e-014
Cn20an30a5 TDn20a9 TDn30a9 1.302320e-014
Cn20an30a6 TDn20a11 TDn30a11 1.302320e-014
Cn20an30a7 TDn20a13 TDn30a13 1.302320e-014
Cn20an30a8 TDn20a15 TDn30a15 1.302320e-014
Cn20an30a9 TDn20a17 TDn30a17 1.302320e-014
Cn20an30a10 TDn20a19 TDn30a19 1.302320e-014
Cn20an30a11 TDn20a21 TDn30a21 1.302320e-014
Cn20an30a12 TDn20a23 TDn30a23 1.302320e-014
Cn20an30a13 TDn20a25 TDn30a25 1.302320e-014
Cn20an30a14 TDn20a27 TDn30a27 1.302320e-014
Cn20an30a15 TDn20a29 TDn30a29 1.302320e-014
Cn20an30a16 TDn20a31 TDn30a31 1.302320e-014
Cn20an30a17 TDn20a33 TDn30a33 1.690880e-014
Cn20an31a1 TDn20a1 TDn31a1 1.690880e-014
Cn20an31a2 TDn20a3 TDn31a3 1.302320e-014
Cn20an31a3 TDn20a5 TDn31a5 1.302320e-014
Cn20an31a4 TDn20a7 TDn31a7 1.302320e-014
Cn20an31a5 TDn20a9 TDn31a9 1.302320e-014
Cn20an31a6 TDn20a11 TDn31a11 1.302320e-014
Cn20an31a7 TDn20a13 TDn31a13 1.302320e-014
Cn20an31a8 TDn20a15 TDn31a15 1.302320e-014
Cn20an31a9 TDn20a17 TDn31a17 1.302320e-014
Cn20an31a10 TDn20a19 TDn31a19 1.302320e-014
Cn20an31a11 TDn20a21 TDn31a21 1.302320e-014
Cn20an31a12 TDn20a23 TDn31a23 1.302320e-014
Cn20an31a13 TDn20a25 TDn31a25 1.302320e-014
Cn20an31a14 TDn20a27 TDn31a27 1.302320e-014
Cn20an31a15 TDn20a29 TDn31a29 1.302320e-014
Cn20an31a16 TDn20a31 TDn31a31 1.302320e-014
Cn20an31a17 TDn20a33 TDn31a33 1.690880e-014
Cn20an32a1 TDn20a1 TDn32a1 1.690880e-014
Cn20an32a2 TDn20a3 TDn32a3 1.302320e-014
Cn20an32a3 TDn20a5 TDn32a5 1.302320e-014
Cn20an32a4 TDn20a7 TDn32a7 1.302320e-014
Cn20an32a5 TDn20a9 TDn32a9 1.302320e-014
Cn20an32a6 TDn20a11 TDn32a11 1.302320e-014
Cn20an32a7 TDn20a13 TDn32a13 1.302320e-014
Cn20an32a8 TDn20a15 TDn32a15 1.302320e-014
Cn20an32a9 TDn20a17 TDn32a17 1.302320e-014
Cn20an32a10 TDn20a19 TDn32a19 1.302320e-014
Cn20an32a11 TDn20a21 TDn32a21 1.302320e-014
Cn20an32a12 TDn20a23 TDn32a23 1.302320e-014
Cn20an32a13 TDn20a25 TDn32a25 1.302320e-014
Cn20an32a14 TDn20a27 TDn32a27 1.302320e-014
Cn20an32a15 TDn20a29 TDn32a29 1.302320e-014
Cn20an32a16 TDn20a31 TDn32a31 1.302320e-014
Cn20an32a17 TDn20a33 TDn32a33 1.690880e-014
Cn20anva1 TDn20a1 TDnva1 1.690880e-014
Cn20anva2 TDn20a3 TDnva3 1.690880e-014
Cn20anva3 TDn20a5 TDnva5 1.690880e-014
Cn20anva4 TDn20a7 TDnva7 1.690880e-014
Cn20anva5 TDn20a9 TDnva9 1.690880e-014
Cn20anva6 TDn20a11 TDnva11 1.690880e-014
Cn20anva7 TDn20a13 TDnva13 1.690880e-014
Cn20anva8 TDn20a15 TDnva15 1.690880e-014
Cn20anva9 TDn20a17 TDnva17 1.690880e-014
Cn20anva10 TDn20a19 TDnva19 1.690880e-014
Cn20anva11 TDn20a21 TDnva21 1.690880e-014
Cn20anva12 TDn20a23 TDnva23 1.690880e-014
Cn20anva13 TDn20a25 TDnva25 1.690880e-014
Cn20anva14 TDn20a27 TDnva27 1.690880e-014
Cn20anva15 TDn20a29 TDnva29 1.690880e-014
Cn20anva16 TDn20a31 TDnva31 1.690880e-014
Cn20anva17 TDn20a33 TDnva33 1.690880e-014
Cn21an22a1 TDn21a1 TDn22a1 1.690880e-014
Cn21an22a2 TDn21a3 TDn22a3 1.302320e-014
Cn21an22a3 TDn21a5 TDn22a5 1.302320e-014
Cn21an22a4 TDn21a7 TDn22a7 1.302320e-014
Cn21an22a5 TDn21a9 TDn22a9 1.302320e-014
Cn21an22a6 TDn21a11 TDn22a11 1.302320e-014
Cn21an22a7 TDn21a13 TDn22a13 1.302320e-014
Cn21an22a8 TDn21a15 TDn22a15 1.302320e-014
Cn21an22a9 TDn21a17 TDn22a17 1.302320e-014
Cn21an22a10 TDn21a19 TDn22a19 1.302320e-014
Cn21an22a11 TDn21a21 TDn22a21 1.302320e-014
Cn21an22a12 TDn21a23 TDn22a23 1.302320e-014
Cn21an22a13 TDn21a25 TDn22a25 1.302320e-014
Cn21an22a14 TDn21a27 TDn22a27 1.302320e-014
Cn21an22a15 TDn21a29 TDn22a29 1.302320e-014
Cn21an22a16 TDn21a31 TDn22a31 1.302320e-014
Cn21an22a17 TDn21a33 TDn22a33 1.690880e-014
Cn21an23a1 TDn21a1 TDn23a1 1.690880e-014
Cn21an23a2 TDn21a3 TDn23a3 1.302320e-014
Cn21an23a3 TDn21a5 TDn23a5 1.302320e-014
Cn21an23a4 TDn21a7 TDn23a7 1.302320e-014
Cn21an23a5 TDn21a9 TDn23a9 1.302320e-014
Cn21an23a6 TDn21a11 TDn23a11 1.302320e-014
Cn21an23a7 TDn21a13 TDn23a13 1.302320e-014
Cn21an23a8 TDn21a15 TDn23a15 1.302320e-014
Cn21an23a9 TDn21a17 TDn23a17 1.302320e-014
Cn21an23a10 TDn21a19 TDn23a19 1.302320e-014
Cn21an23a11 TDn21a21 TDn23a21 1.302320e-014
Cn21an23a12 TDn21a23 TDn23a23 1.302320e-014
Cn21an23a13 TDn21a25 TDn23a25 1.302320e-014
Cn21an23a14 TDn21a27 TDn23a27 1.302320e-014
Cn21an23a15 TDn21a29 TDn23a29 1.302320e-014
Cn21an23a16 TDn21a31 TDn23a31 1.302320e-014
Cn21an23a17 TDn21a33 TDn23a33 1.690880e-014
Cn21an24a1 TDn21a1 TDn24a1 1.690880e-014
Cn21an24a2 TDn21a3 TDn24a3 1.302320e-014
Cn21an24a3 TDn21a5 TDn24a5 1.302320e-014
Cn21an24a4 TDn21a7 TDn24a7 1.302320e-014
Cn21an24a5 TDn21a9 TDn24a9 1.302320e-014
Cn21an24a6 TDn21a11 TDn24a11 1.302320e-014
Cn21an24a7 TDn21a13 TDn24a13 1.302320e-014
Cn21an24a8 TDn21a15 TDn24a15 1.302320e-014
Cn21an24a9 TDn21a17 TDn24a17 1.302320e-014
Cn21an24a10 TDn21a19 TDn24a19 1.302320e-014
Cn21an24a11 TDn21a21 TDn24a21 1.302320e-014
Cn21an24a12 TDn21a23 TDn24a23 1.302320e-014
Cn21an24a13 TDn21a25 TDn24a25 1.302320e-014
Cn21an24a14 TDn21a27 TDn24a27 1.302320e-014
Cn21an24a15 TDn21a29 TDn24a29 1.302320e-014
Cn21an24a16 TDn21a31 TDn24a31 1.302320e-014
Cn21an24a17 TDn21a33 TDn24a33 1.690880e-014
Cn21an25a1 TDn21a1 TDn25a1 1.690880e-014
Cn21an25a2 TDn21a3 TDn25a3 1.302320e-014
Cn21an25a3 TDn21a5 TDn25a5 1.302320e-014
Cn21an25a4 TDn21a7 TDn25a7 1.302320e-014
Cn21an25a5 TDn21a9 TDn25a9 1.302320e-014
Cn21an25a6 TDn21a11 TDn25a11 1.302320e-014
Cn21an25a7 TDn21a13 TDn25a13 1.302320e-014
Cn21an25a8 TDn21a15 TDn25a15 1.302320e-014
Cn21an25a9 TDn21a17 TDn25a17 1.302320e-014
Cn21an25a10 TDn21a19 TDn25a19 1.302320e-014
Cn21an25a11 TDn21a21 TDn25a21 1.302320e-014
Cn21an25a12 TDn21a23 TDn25a23 1.302320e-014
Cn21an25a13 TDn21a25 TDn25a25 1.302320e-014
Cn21an25a14 TDn21a27 TDn25a27 1.302320e-014
Cn21an25a15 TDn21a29 TDn25a29 1.302320e-014
Cn21an25a16 TDn21a31 TDn25a31 1.302320e-014
Cn21an25a17 TDn21a33 TDn25a33 1.690880e-014
Cn21an26a1 TDn21a1 TDn26a1 1.690880e-014
Cn21an26a2 TDn21a3 TDn26a3 1.302320e-014
Cn21an26a3 TDn21a5 TDn26a5 1.302320e-014
Cn21an26a4 TDn21a7 TDn26a7 1.302320e-014
Cn21an26a5 TDn21a9 TDn26a9 1.302320e-014
Cn21an26a6 TDn21a11 TDn26a11 1.302320e-014
Cn21an26a7 TDn21a13 TDn26a13 1.302320e-014
Cn21an26a8 TDn21a15 TDn26a15 1.302320e-014
Cn21an26a9 TDn21a17 TDn26a17 1.302320e-014
Cn21an26a10 TDn21a19 TDn26a19 1.302320e-014
Cn21an26a11 TDn21a21 TDn26a21 1.302320e-014
Cn21an26a12 TDn21a23 TDn26a23 1.302320e-014
Cn21an26a13 TDn21a25 TDn26a25 1.302320e-014
Cn21an26a14 TDn21a27 TDn26a27 1.302320e-014
Cn21an26a15 TDn21a29 TDn26a29 1.302320e-014
Cn21an26a16 TDn21a31 TDn26a31 1.302320e-014
Cn21an26a17 TDn21a33 TDn26a33 1.690880e-014
Cn21an27a1 TDn21a1 TDn27a1 1.690880e-014
Cn21an27a2 TDn21a3 TDn27a3 1.302320e-014
Cn21an27a3 TDn21a5 TDn27a5 1.302320e-014
Cn21an27a4 TDn21a7 TDn27a7 1.302320e-014
Cn21an27a5 TDn21a9 TDn27a9 1.302320e-014
Cn21an27a6 TDn21a11 TDn27a11 1.302320e-014
Cn21an27a7 TDn21a13 TDn27a13 1.302320e-014
Cn21an27a8 TDn21a15 TDn27a15 1.302320e-014
Cn21an27a9 TDn21a17 TDn27a17 1.302320e-014
Cn21an27a10 TDn21a19 TDn27a19 1.302320e-014
Cn21an27a11 TDn21a21 TDn27a21 1.302320e-014
Cn21an27a12 TDn21a23 TDn27a23 1.302320e-014
Cn21an27a13 TDn21a25 TDn27a25 1.302320e-014
Cn21an27a14 TDn21a27 TDn27a27 1.302320e-014
Cn21an27a15 TDn21a29 TDn27a29 1.302320e-014
Cn21an27a16 TDn21a31 TDn27a31 1.302320e-014
Cn21an27a17 TDn21a33 TDn27a33 1.690880e-014
Cn21an28a1 TDn21a1 TDn28a1 1.690880e-014
Cn21an28a2 TDn21a3 TDn28a3 1.302320e-014
Cn21an28a3 TDn21a5 TDn28a5 1.302320e-014
Cn21an28a4 TDn21a7 TDn28a7 1.302320e-014
Cn21an28a5 TDn21a9 TDn28a9 1.302320e-014
Cn21an28a6 TDn21a11 TDn28a11 1.302320e-014
Cn21an28a7 TDn21a13 TDn28a13 1.302320e-014
Cn21an28a8 TDn21a15 TDn28a15 1.302320e-014
Cn21an28a9 TDn21a17 TDn28a17 1.302320e-014
Cn21an28a10 TDn21a19 TDn28a19 1.302320e-014
Cn21an28a11 TDn21a21 TDn28a21 1.302320e-014
Cn21an28a12 TDn21a23 TDn28a23 1.302320e-014
Cn21an28a13 TDn21a25 TDn28a25 1.302320e-014
Cn21an28a14 TDn21a27 TDn28a27 1.302320e-014
Cn21an28a15 TDn21a29 TDn28a29 1.302320e-014
Cn21an28a16 TDn21a31 TDn28a31 1.302320e-014
Cn21an28a17 TDn21a33 TDn28a33 1.690880e-014
Cn21an29a1 TDn21a1 TDn29a1 1.690880e-014
Cn21an29a2 TDn21a3 TDn29a3 1.302320e-014
Cn21an29a3 TDn21a5 TDn29a5 1.302320e-014
Cn21an29a4 TDn21a7 TDn29a7 1.302320e-014
Cn21an29a5 TDn21a9 TDn29a9 1.302320e-014
Cn21an29a6 TDn21a11 TDn29a11 1.302320e-014
Cn21an29a7 TDn21a13 TDn29a13 1.302320e-014
Cn21an29a8 TDn21a15 TDn29a15 1.302320e-014
Cn21an29a9 TDn21a17 TDn29a17 1.302320e-014
Cn21an29a10 TDn21a19 TDn29a19 1.302320e-014
Cn21an29a11 TDn21a21 TDn29a21 1.302320e-014
Cn21an29a12 TDn21a23 TDn29a23 1.302320e-014
Cn21an29a13 TDn21a25 TDn29a25 1.302320e-014
Cn21an29a14 TDn21a27 TDn29a27 1.302320e-014
Cn21an29a15 TDn21a29 TDn29a29 1.302320e-014
Cn21an29a16 TDn21a31 TDn29a31 1.302320e-014
Cn21an29a17 TDn21a33 TDn29a33 1.690880e-014
Cn21an30a1 TDn21a1 TDn30a1 1.690880e-014
Cn21an30a2 TDn21a3 TDn30a3 1.302320e-014
Cn21an30a3 TDn21a5 TDn30a5 1.302320e-014
Cn21an30a4 TDn21a7 TDn30a7 1.302320e-014
Cn21an30a5 TDn21a9 TDn30a9 1.302320e-014
Cn21an30a6 TDn21a11 TDn30a11 1.302320e-014
Cn21an30a7 TDn21a13 TDn30a13 1.302320e-014
Cn21an30a8 TDn21a15 TDn30a15 1.302320e-014
Cn21an30a9 TDn21a17 TDn30a17 1.302320e-014
Cn21an30a10 TDn21a19 TDn30a19 1.302320e-014
Cn21an30a11 TDn21a21 TDn30a21 1.302320e-014
Cn21an30a12 TDn21a23 TDn30a23 1.302320e-014
Cn21an30a13 TDn21a25 TDn30a25 1.302320e-014
Cn21an30a14 TDn21a27 TDn30a27 1.302320e-014
Cn21an30a15 TDn21a29 TDn30a29 1.302320e-014
Cn21an30a16 TDn21a31 TDn30a31 1.302320e-014
Cn21an30a17 TDn21a33 TDn30a33 1.690880e-014
Cn21an31a1 TDn21a1 TDn31a1 1.690880e-014
Cn21an31a2 TDn21a3 TDn31a3 1.302320e-014
Cn21an31a3 TDn21a5 TDn31a5 1.302320e-014
Cn21an31a4 TDn21a7 TDn31a7 1.302320e-014
Cn21an31a5 TDn21a9 TDn31a9 1.302320e-014
Cn21an31a6 TDn21a11 TDn31a11 1.302320e-014
Cn21an31a7 TDn21a13 TDn31a13 1.302320e-014
Cn21an31a8 TDn21a15 TDn31a15 1.302320e-014
Cn21an31a9 TDn21a17 TDn31a17 1.302320e-014
Cn21an31a10 TDn21a19 TDn31a19 1.302320e-014
Cn21an31a11 TDn21a21 TDn31a21 1.302320e-014
Cn21an31a12 TDn21a23 TDn31a23 1.302320e-014
Cn21an31a13 TDn21a25 TDn31a25 1.302320e-014
Cn21an31a14 TDn21a27 TDn31a27 1.302320e-014
Cn21an31a15 TDn21a29 TDn31a29 1.302320e-014
Cn21an31a16 TDn21a31 TDn31a31 1.302320e-014
Cn21an31a17 TDn21a33 TDn31a33 1.690880e-014
Cn21an32a1 TDn21a1 TDn32a1 1.690880e-014
Cn21an32a2 TDn21a3 TDn32a3 1.302320e-014
Cn21an32a3 TDn21a5 TDn32a5 1.302320e-014
Cn21an32a4 TDn21a7 TDn32a7 1.302320e-014
Cn21an32a5 TDn21a9 TDn32a9 1.302320e-014
Cn21an32a6 TDn21a11 TDn32a11 1.302320e-014
Cn21an32a7 TDn21a13 TDn32a13 1.302320e-014
Cn21an32a8 TDn21a15 TDn32a15 1.302320e-014
Cn21an32a9 TDn21a17 TDn32a17 1.302320e-014
Cn21an32a10 TDn21a19 TDn32a19 1.302320e-014
Cn21an32a11 TDn21a21 TDn32a21 1.302320e-014
Cn21an32a12 TDn21a23 TDn32a23 1.302320e-014
Cn21an32a13 TDn21a25 TDn32a25 1.302320e-014
Cn21an32a14 TDn21a27 TDn32a27 1.302320e-014
Cn21an32a15 TDn21a29 TDn32a29 1.302320e-014
Cn21an32a16 TDn21a31 TDn32a31 1.302320e-014
Cn21an32a17 TDn21a33 TDn32a33 1.690880e-014
Cn21anva1 TDn21a1 TDnva1 1.690880e-014
Cn21anva2 TDn21a3 TDnva3 1.690880e-014
Cn21anva3 TDn21a5 TDnva5 1.690880e-014
Cn21anva4 TDn21a7 TDnva7 1.690880e-014
Cn21anva5 TDn21a9 TDnva9 1.690880e-014
Cn21anva6 TDn21a11 TDnva11 1.690880e-014
Cn21anva7 TDn21a13 TDnva13 1.690880e-014
Cn21anva8 TDn21a15 TDnva15 1.690880e-014
Cn21anva9 TDn21a17 TDnva17 1.690880e-014
Cn21anva10 TDn21a19 TDnva19 1.690880e-014
Cn21anva11 TDn21a21 TDnva21 1.690880e-014
Cn21anva12 TDn21a23 TDnva23 1.690880e-014
Cn21anva13 TDn21a25 TDnva25 1.690880e-014
Cn21anva14 TDn21a27 TDnva27 1.690880e-014
Cn21anva15 TDn21a29 TDnva29 1.690880e-014
Cn21anva16 TDn21a31 TDnva31 1.690880e-014
Cn21anva17 TDn21a33 TDnva33 1.690880e-014
Cn22an23a1 TDn22a1 TDn23a1 1.690880e-014
Cn22an23a2 TDn22a3 TDn23a3 1.302320e-014
Cn22an23a3 TDn22a5 TDn23a5 1.302320e-014
Cn22an23a4 TDn22a7 TDn23a7 1.302320e-014
Cn22an23a5 TDn22a9 TDn23a9 1.302320e-014
Cn22an23a6 TDn22a11 TDn23a11 1.302320e-014
Cn22an23a7 TDn22a13 TDn23a13 1.302320e-014
Cn22an23a8 TDn22a15 TDn23a15 1.302320e-014
Cn22an23a9 TDn22a17 TDn23a17 1.302320e-014
Cn22an23a10 TDn22a19 TDn23a19 1.302320e-014
Cn22an23a11 TDn22a21 TDn23a21 1.302320e-014
Cn22an23a12 TDn22a23 TDn23a23 1.302320e-014
Cn22an23a13 TDn22a25 TDn23a25 1.302320e-014
Cn22an23a14 TDn22a27 TDn23a27 1.302320e-014
Cn22an23a15 TDn22a29 TDn23a29 1.302320e-014
Cn22an23a16 TDn22a31 TDn23a31 1.302320e-014
Cn22an23a17 TDn22a33 TDn23a33 1.690880e-014
Cn22an24a1 TDn22a1 TDn24a1 1.690880e-014
Cn22an24a2 TDn22a3 TDn24a3 1.302320e-014
Cn22an24a3 TDn22a5 TDn24a5 1.302320e-014
Cn22an24a4 TDn22a7 TDn24a7 1.302320e-014
Cn22an24a5 TDn22a9 TDn24a9 1.302320e-014
Cn22an24a6 TDn22a11 TDn24a11 1.302320e-014
Cn22an24a7 TDn22a13 TDn24a13 1.302320e-014
Cn22an24a8 TDn22a15 TDn24a15 1.302320e-014
Cn22an24a9 TDn22a17 TDn24a17 1.302320e-014
Cn22an24a10 TDn22a19 TDn24a19 1.302320e-014
Cn22an24a11 TDn22a21 TDn24a21 1.302320e-014
Cn22an24a12 TDn22a23 TDn24a23 1.302320e-014
Cn22an24a13 TDn22a25 TDn24a25 1.302320e-014
Cn22an24a14 TDn22a27 TDn24a27 1.302320e-014
Cn22an24a15 TDn22a29 TDn24a29 1.302320e-014
Cn22an24a16 TDn22a31 TDn24a31 1.302320e-014
Cn22an24a17 TDn22a33 TDn24a33 1.690880e-014
Cn22an25a1 TDn22a1 TDn25a1 1.690880e-014
Cn22an25a2 TDn22a3 TDn25a3 1.302320e-014
Cn22an25a3 TDn22a5 TDn25a5 1.302320e-014
Cn22an25a4 TDn22a7 TDn25a7 1.302320e-014
Cn22an25a5 TDn22a9 TDn25a9 1.302320e-014
Cn22an25a6 TDn22a11 TDn25a11 1.302320e-014
Cn22an25a7 TDn22a13 TDn25a13 1.302320e-014
Cn22an25a8 TDn22a15 TDn25a15 1.302320e-014
Cn22an25a9 TDn22a17 TDn25a17 1.302320e-014
Cn22an25a10 TDn22a19 TDn25a19 1.302320e-014
Cn22an25a11 TDn22a21 TDn25a21 1.302320e-014
Cn22an25a12 TDn22a23 TDn25a23 1.302320e-014
Cn22an25a13 TDn22a25 TDn25a25 1.302320e-014
Cn22an25a14 TDn22a27 TDn25a27 1.302320e-014
Cn22an25a15 TDn22a29 TDn25a29 1.302320e-014
Cn22an25a16 TDn22a31 TDn25a31 1.302320e-014
Cn22an25a17 TDn22a33 TDn25a33 1.690880e-014
Cn22an26a1 TDn22a1 TDn26a1 1.690880e-014
Cn22an26a2 TDn22a3 TDn26a3 1.302320e-014
Cn22an26a3 TDn22a5 TDn26a5 1.302320e-014
Cn22an26a4 TDn22a7 TDn26a7 1.302320e-014
Cn22an26a5 TDn22a9 TDn26a9 1.302320e-014
Cn22an26a6 TDn22a11 TDn26a11 1.302320e-014
Cn22an26a7 TDn22a13 TDn26a13 1.302320e-014
Cn22an26a8 TDn22a15 TDn26a15 1.302320e-014
Cn22an26a9 TDn22a17 TDn26a17 1.302320e-014
Cn22an26a10 TDn22a19 TDn26a19 1.302320e-014
Cn22an26a11 TDn22a21 TDn26a21 1.302320e-014
Cn22an26a12 TDn22a23 TDn26a23 1.302320e-014
Cn22an26a13 TDn22a25 TDn26a25 1.302320e-014
Cn22an26a14 TDn22a27 TDn26a27 1.302320e-014
Cn22an26a15 TDn22a29 TDn26a29 1.302320e-014
Cn22an26a16 TDn22a31 TDn26a31 1.302320e-014
Cn22an26a17 TDn22a33 TDn26a33 1.690880e-014
Cn22an27a1 TDn22a1 TDn27a1 1.690880e-014
Cn22an27a2 TDn22a3 TDn27a3 1.302320e-014
Cn22an27a3 TDn22a5 TDn27a5 1.302320e-014
Cn22an27a4 TDn22a7 TDn27a7 1.302320e-014
Cn22an27a5 TDn22a9 TDn27a9 1.302320e-014
Cn22an27a6 TDn22a11 TDn27a11 1.302320e-014
Cn22an27a7 TDn22a13 TDn27a13 1.302320e-014
Cn22an27a8 TDn22a15 TDn27a15 1.302320e-014
Cn22an27a9 TDn22a17 TDn27a17 1.302320e-014
Cn22an27a10 TDn22a19 TDn27a19 1.302320e-014
Cn22an27a11 TDn22a21 TDn27a21 1.302320e-014
Cn22an27a12 TDn22a23 TDn27a23 1.302320e-014
Cn22an27a13 TDn22a25 TDn27a25 1.302320e-014
Cn22an27a14 TDn22a27 TDn27a27 1.302320e-014
Cn22an27a15 TDn22a29 TDn27a29 1.302320e-014
Cn22an27a16 TDn22a31 TDn27a31 1.302320e-014
Cn22an27a17 TDn22a33 TDn27a33 1.690880e-014
Cn22an28a1 TDn22a1 TDn28a1 1.690880e-014
Cn22an28a2 TDn22a3 TDn28a3 1.302320e-014
Cn22an28a3 TDn22a5 TDn28a5 1.302320e-014
Cn22an28a4 TDn22a7 TDn28a7 1.302320e-014
Cn22an28a5 TDn22a9 TDn28a9 1.302320e-014
Cn22an28a6 TDn22a11 TDn28a11 1.302320e-014
Cn22an28a7 TDn22a13 TDn28a13 1.302320e-014
Cn22an28a8 TDn22a15 TDn28a15 1.302320e-014
Cn22an28a9 TDn22a17 TDn28a17 1.302320e-014
Cn22an28a10 TDn22a19 TDn28a19 1.302320e-014
Cn22an28a11 TDn22a21 TDn28a21 1.302320e-014
Cn22an28a12 TDn22a23 TDn28a23 1.302320e-014
Cn22an28a13 TDn22a25 TDn28a25 1.302320e-014
Cn22an28a14 TDn22a27 TDn28a27 1.302320e-014
Cn22an28a15 TDn22a29 TDn28a29 1.302320e-014
Cn22an28a16 TDn22a31 TDn28a31 1.302320e-014
Cn22an28a17 TDn22a33 TDn28a33 1.690880e-014
Cn22an29a1 TDn22a1 TDn29a1 1.690880e-014
Cn22an29a2 TDn22a3 TDn29a3 1.302320e-014
Cn22an29a3 TDn22a5 TDn29a5 1.302320e-014
Cn22an29a4 TDn22a7 TDn29a7 1.302320e-014
Cn22an29a5 TDn22a9 TDn29a9 1.302320e-014
Cn22an29a6 TDn22a11 TDn29a11 1.302320e-014
Cn22an29a7 TDn22a13 TDn29a13 1.302320e-014
Cn22an29a8 TDn22a15 TDn29a15 1.302320e-014
Cn22an29a9 TDn22a17 TDn29a17 1.302320e-014
Cn22an29a10 TDn22a19 TDn29a19 1.302320e-014
Cn22an29a11 TDn22a21 TDn29a21 1.302320e-014
Cn22an29a12 TDn22a23 TDn29a23 1.302320e-014
Cn22an29a13 TDn22a25 TDn29a25 1.302320e-014
Cn22an29a14 TDn22a27 TDn29a27 1.302320e-014
Cn22an29a15 TDn22a29 TDn29a29 1.302320e-014
Cn22an29a16 TDn22a31 TDn29a31 1.302320e-014
Cn22an29a17 TDn22a33 TDn29a33 1.690880e-014
Cn22an30a1 TDn22a1 TDn30a1 1.690880e-014
Cn22an30a2 TDn22a3 TDn30a3 1.302320e-014
Cn22an30a3 TDn22a5 TDn30a5 1.302320e-014
Cn22an30a4 TDn22a7 TDn30a7 1.302320e-014
Cn22an30a5 TDn22a9 TDn30a9 1.302320e-014
Cn22an30a6 TDn22a11 TDn30a11 1.302320e-014
Cn22an30a7 TDn22a13 TDn30a13 1.302320e-014
Cn22an30a8 TDn22a15 TDn30a15 1.302320e-014
Cn22an30a9 TDn22a17 TDn30a17 1.302320e-014
Cn22an30a10 TDn22a19 TDn30a19 1.302320e-014
Cn22an30a11 TDn22a21 TDn30a21 1.302320e-014
Cn22an30a12 TDn22a23 TDn30a23 1.302320e-014
Cn22an30a13 TDn22a25 TDn30a25 1.302320e-014
Cn22an30a14 TDn22a27 TDn30a27 1.302320e-014
Cn22an30a15 TDn22a29 TDn30a29 1.302320e-014
Cn22an30a16 TDn22a31 TDn30a31 1.302320e-014
Cn22an30a17 TDn22a33 TDn30a33 1.690880e-014
Cn22an31a1 TDn22a1 TDn31a1 1.690880e-014
Cn22an31a2 TDn22a3 TDn31a3 1.302320e-014
Cn22an31a3 TDn22a5 TDn31a5 1.302320e-014
Cn22an31a4 TDn22a7 TDn31a7 1.302320e-014
Cn22an31a5 TDn22a9 TDn31a9 1.302320e-014
Cn22an31a6 TDn22a11 TDn31a11 1.302320e-014
Cn22an31a7 TDn22a13 TDn31a13 1.302320e-014
Cn22an31a8 TDn22a15 TDn31a15 1.302320e-014
Cn22an31a9 TDn22a17 TDn31a17 1.302320e-014
Cn22an31a10 TDn22a19 TDn31a19 1.302320e-014
Cn22an31a11 TDn22a21 TDn31a21 1.302320e-014
Cn22an31a12 TDn22a23 TDn31a23 1.302320e-014
Cn22an31a13 TDn22a25 TDn31a25 1.302320e-014
Cn22an31a14 TDn22a27 TDn31a27 1.302320e-014
Cn22an31a15 TDn22a29 TDn31a29 1.302320e-014
Cn22an31a16 TDn22a31 TDn31a31 1.302320e-014
Cn22an31a17 TDn22a33 TDn31a33 1.690880e-014
Cn22an32a1 TDn22a1 TDn32a1 1.690880e-014
Cn22an32a2 TDn22a3 TDn32a3 1.302320e-014
Cn22an32a3 TDn22a5 TDn32a5 1.302320e-014
Cn22an32a4 TDn22a7 TDn32a7 1.302320e-014
Cn22an32a5 TDn22a9 TDn32a9 1.302320e-014
Cn22an32a6 TDn22a11 TDn32a11 1.302320e-014
Cn22an32a7 TDn22a13 TDn32a13 1.302320e-014
Cn22an32a8 TDn22a15 TDn32a15 1.302320e-014
Cn22an32a9 TDn22a17 TDn32a17 1.302320e-014
Cn22an32a10 TDn22a19 TDn32a19 1.302320e-014
Cn22an32a11 TDn22a21 TDn32a21 1.302320e-014
Cn22an32a12 TDn22a23 TDn32a23 1.302320e-014
Cn22an32a13 TDn22a25 TDn32a25 1.302320e-014
Cn22an32a14 TDn22a27 TDn32a27 1.302320e-014
Cn22an32a15 TDn22a29 TDn32a29 1.302320e-014
Cn22an32a16 TDn22a31 TDn32a31 1.302320e-014
Cn22an32a17 TDn22a33 TDn32a33 1.690880e-014
Cn22anva1 TDn22a1 TDnva1 1.690880e-014
Cn22anva2 TDn22a3 TDnva3 1.690880e-014
Cn22anva3 TDn22a5 TDnva5 1.690880e-014
Cn22anva4 TDn22a7 TDnva7 1.690880e-014
Cn22anva5 TDn22a9 TDnva9 1.690880e-014
Cn22anva6 TDn22a11 TDnva11 1.690880e-014
Cn22anva7 TDn22a13 TDnva13 1.690880e-014
Cn22anva8 TDn22a15 TDnva15 1.690880e-014
Cn22anva9 TDn22a17 TDnva17 1.690880e-014
Cn22anva10 TDn22a19 TDnva19 1.690880e-014
Cn22anva11 TDn22a21 TDnva21 1.690880e-014
Cn22anva12 TDn22a23 TDnva23 1.690880e-014
Cn22anva13 TDn22a25 TDnva25 1.690880e-014
Cn22anva14 TDn22a27 TDnva27 1.690880e-014
Cn22anva15 TDn22a29 TDnva29 1.690880e-014
Cn22anva16 TDn22a31 TDnva31 1.690880e-014
Cn22anva17 TDn22a33 TDnva33 1.690880e-014
Cn23an24a1 TDn23a1 TDn24a1 1.690880e-014
Cn23an24a2 TDn23a3 TDn24a3 1.302320e-014
Cn23an24a3 TDn23a5 TDn24a5 1.302320e-014
Cn23an24a4 TDn23a7 TDn24a7 1.302320e-014
Cn23an24a5 TDn23a9 TDn24a9 1.302320e-014
Cn23an24a6 TDn23a11 TDn24a11 1.302320e-014
Cn23an24a7 TDn23a13 TDn24a13 1.302320e-014
Cn23an24a8 TDn23a15 TDn24a15 1.302320e-014
Cn23an24a9 TDn23a17 TDn24a17 1.302320e-014
Cn23an24a10 TDn23a19 TDn24a19 1.302320e-014
Cn23an24a11 TDn23a21 TDn24a21 1.302320e-014
Cn23an24a12 TDn23a23 TDn24a23 1.302320e-014
Cn23an24a13 TDn23a25 TDn24a25 1.302320e-014
Cn23an24a14 TDn23a27 TDn24a27 1.302320e-014
Cn23an24a15 TDn23a29 TDn24a29 1.302320e-014
Cn23an24a16 TDn23a31 TDn24a31 1.302320e-014
Cn23an24a17 TDn23a33 TDn24a33 1.690880e-014
Cn23an25a1 TDn23a1 TDn25a1 1.690880e-014
Cn23an25a2 TDn23a3 TDn25a3 1.302320e-014
Cn23an25a3 TDn23a5 TDn25a5 1.302320e-014
Cn23an25a4 TDn23a7 TDn25a7 1.302320e-014
Cn23an25a5 TDn23a9 TDn25a9 1.302320e-014
Cn23an25a6 TDn23a11 TDn25a11 1.302320e-014
Cn23an25a7 TDn23a13 TDn25a13 1.302320e-014
Cn23an25a8 TDn23a15 TDn25a15 1.302320e-014
Cn23an25a9 TDn23a17 TDn25a17 1.302320e-014
Cn23an25a10 TDn23a19 TDn25a19 1.302320e-014
Cn23an25a11 TDn23a21 TDn25a21 1.302320e-014
Cn23an25a12 TDn23a23 TDn25a23 1.302320e-014
Cn23an25a13 TDn23a25 TDn25a25 1.302320e-014
Cn23an25a14 TDn23a27 TDn25a27 1.302320e-014
Cn23an25a15 TDn23a29 TDn25a29 1.302320e-014
Cn23an25a16 TDn23a31 TDn25a31 1.302320e-014
Cn23an25a17 TDn23a33 TDn25a33 1.690880e-014
Cn23an26a1 TDn23a1 TDn26a1 1.690880e-014
Cn23an26a2 TDn23a3 TDn26a3 1.302320e-014
Cn23an26a3 TDn23a5 TDn26a5 1.302320e-014
Cn23an26a4 TDn23a7 TDn26a7 1.302320e-014
Cn23an26a5 TDn23a9 TDn26a9 1.302320e-014
Cn23an26a6 TDn23a11 TDn26a11 1.302320e-014
Cn23an26a7 TDn23a13 TDn26a13 1.302320e-014
Cn23an26a8 TDn23a15 TDn26a15 1.302320e-014
Cn23an26a9 TDn23a17 TDn26a17 1.302320e-014
Cn23an26a10 TDn23a19 TDn26a19 1.302320e-014
Cn23an26a11 TDn23a21 TDn26a21 1.302320e-014
Cn23an26a12 TDn23a23 TDn26a23 1.302320e-014
Cn23an26a13 TDn23a25 TDn26a25 1.302320e-014
Cn23an26a14 TDn23a27 TDn26a27 1.302320e-014
Cn23an26a15 TDn23a29 TDn26a29 1.302320e-014
Cn23an26a16 TDn23a31 TDn26a31 1.302320e-014
Cn23an26a17 TDn23a33 TDn26a33 1.690880e-014
Cn23an27a1 TDn23a1 TDn27a1 1.690880e-014
Cn23an27a2 TDn23a3 TDn27a3 1.302320e-014
Cn23an27a3 TDn23a5 TDn27a5 1.302320e-014
Cn23an27a4 TDn23a7 TDn27a7 1.302320e-014
Cn23an27a5 TDn23a9 TDn27a9 1.302320e-014
Cn23an27a6 TDn23a11 TDn27a11 1.302320e-014
Cn23an27a7 TDn23a13 TDn27a13 1.302320e-014
Cn23an27a8 TDn23a15 TDn27a15 1.302320e-014
Cn23an27a9 TDn23a17 TDn27a17 1.302320e-014
Cn23an27a10 TDn23a19 TDn27a19 1.302320e-014
Cn23an27a11 TDn23a21 TDn27a21 1.302320e-014
Cn23an27a12 TDn23a23 TDn27a23 1.302320e-014
Cn23an27a13 TDn23a25 TDn27a25 1.302320e-014
Cn23an27a14 TDn23a27 TDn27a27 1.302320e-014
Cn23an27a15 TDn23a29 TDn27a29 1.302320e-014
Cn23an27a16 TDn23a31 TDn27a31 1.302320e-014
Cn23an27a17 TDn23a33 TDn27a33 1.690880e-014
Cn23an28a1 TDn23a1 TDn28a1 1.690880e-014
Cn23an28a2 TDn23a3 TDn28a3 1.302320e-014
Cn23an28a3 TDn23a5 TDn28a5 1.302320e-014
Cn23an28a4 TDn23a7 TDn28a7 1.302320e-014
Cn23an28a5 TDn23a9 TDn28a9 1.302320e-014
Cn23an28a6 TDn23a11 TDn28a11 1.302320e-014
Cn23an28a7 TDn23a13 TDn28a13 1.302320e-014
Cn23an28a8 TDn23a15 TDn28a15 1.302320e-014
Cn23an28a9 TDn23a17 TDn28a17 1.302320e-014
Cn23an28a10 TDn23a19 TDn28a19 1.302320e-014
Cn23an28a11 TDn23a21 TDn28a21 1.302320e-014
Cn23an28a12 TDn23a23 TDn28a23 1.302320e-014
Cn23an28a13 TDn23a25 TDn28a25 1.302320e-014
Cn23an28a14 TDn23a27 TDn28a27 1.302320e-014
Cn23an28a15 TDn23a29 TDn28a29 1.302320e-014
Cn23an28a16 TDn23a31 TDn28a31 1.302320e-014
Cn23an28a17 TDn23a33 TDn28a33 1.690880e-014
Cn23an29a1 TDn23a1 TDn29a1 1.690880e-014
Cn23an29a2 TDn23a3 TDn29a3 1.302320e-014
Cn23an29a3 TDn23a5 TDn29a5 1.302320e-014
Cn23an29a4 TDn23a7 TDn29a7 1.302320e-014
Cn23an29a5 TDn23a9 TDn29a9 1.302320e-014
Cn23an29a6 TDn23a11 TDn29a11 1.302320e-014
Cn23an29a7 TDn23a13 TDn29a13 1.302320e-014
Cn23an29a8 TDn23a15 TDn29a15 1.302320e-014
Cn23an29a9 TDn23a17 TDn29a17 1.302320e-014
Cn23an29a10 TDn23a19 TDn29a19 1.302320e-014
Cn23an29a11 TDn23a21 TDn29a21 1.302320e-014
Cn23an29a12 TDn23a23 TDn29a23 1.302320e-014
Cn23an29a13 TDn23a25 TDn29a25 1.302320e-014
Cn23an29a14 TDn23a27 TDn29a27 1.302320e-014
Cn23an29a15 TDn23a29 TDn29a29 1.302320e-014
Cn23an29a16 TDn23a31 TDn29a31 1.302320e-014
Cn23an29a17 TDn23a33 TDn29a33 1.690880e-014
Cn23an30a1 TDn23a1 TDn30a1 1.690880e-014
Cn23an30a2 TDn23a3 TDn30a3 1.302320e-014
Cn23an30a3 TDn23a5 TDn30a5 1.302320e-014
Cn23an30a4 TDn23a7 TDn30a7 1.302320e-014
Cn23an30a5 TDn23a9 TDn30a9 1.302320e-014
Cn23an30a6 TDn23a11 TDn30a11 1.302320e-014
Cn23an30a7 TDn23a13 TDn30a13 1.302320e-014
Cn23an30a8 TDn23a15 TDn30a15 1.302320e-014
Cn23an30a9 TDn23a17 TDn30a17 1.302320e-014
Cn23an30a10 TDn23a19 TDn30a19 1.302320e-014
Cn23an30a11 TDn23a21 TDn30a21 1.302320e-014
Cn23an30a12 TDn23a23 TDn30a23 1.302320e-014
Cn23an30a13 TDn23a25 TDn30a25 1.302320e-014
Cn23an30a14 TDn23a27 TDn30a27 1.302320e-014
Cn23an30a15 TDn23a29 TDn30a29 1.302320e-014
Cn23an30a16 TDn23a31 TDn30a31 1.302320e-014
Cn23an30a17 TDn23a33 TDn30a33 1.690880e-014
Cn23an31a1 TDn23a1 TDn31a1 1.690880e-014
Cn23an31a2 TDn23a3 TDn31a3 1.302320e-014
Cn23an31a3 TDn23a5 TDn31a5 1.302320e-014
Cn23an31a4 TDn23a7 TDn31a7 1.302320e-014
Cn23an31a5 TDn23a9 TDn31a9 1.302320e-014
Cn23an31a6 TDn23a11 TDn31a11 1.302320e-014
Cn23an31a7 TDn23a13 TDn31a13 1.302320e-014
Cn23an31a8 TDn23a15 TDn31a15 1.302320e-014
Cn23an31a9 TDn23a17 TDn31a17 1.302320e-014
Cn23an31a10 TDn23a19 TDn31a19 1.302320e-014
Cn23an31a11 TDn23a21 TDn31a21 1.302320e-014
Cn23an31a12 TDn23a23 TDn31a23 1.302320e-014
Cn23an31a13 TDn23a25 TDn31a25 1.302320e-014
Cn23an31a14 TDn23a27 TDn31a27 1.302320e-014
Cn23an31a15 TDn23a29 TDn31a29 1.302320e-014
Cn23an31a16 TDn23a31 TDn31a31 1.302320e-014
Cn23an31a17 TDn23a33 TDn31a33 1.690880e-014
Cn23an32a1 TDn23a1 TDn32a1 1.690880e-014
Cn23an32a2 TDn23a3 TDn32a3 1.302320e-014
Cn23an32a3 TDn23a5 TDn32a5 1.302320e-014
Cn23an32a4 TDn23a7 TDn32a7 1.302320e-014
Cn23an32a5 TDn23a9 TDn32a9 1.302320e-014
Cn23an32a6 TDn23a11 TDn32a11 1.302320e-014
Cn23an32a7 TDn23a13 TDn32a13 1.302320e-014
Cn23an32a8 TDn23a15 TDn32a15 1.302320e-014
Cn23an32a9 TDn23a17 TDn32a17 1.302320e-014
Cn23an32a10 TDn23a19 TDn32a19 1.302320e-014
Cn23an32a11 TDn23a21 TDn32a21 1.302320e-014
Cn23an32a12 TDn23a23 TDn32a23 1.302320e-014
Cn23an32a13 TDn23a25 TDn32a25 1.302320e-014
Cn23an32a14 TDn23a27 TDn32a27 1.302320e-014
Cn23an32a15 TDn23a29 TDn32a29 1.302320e-014
Cn23an32a16 TDn23a31 TDn32a31 1.302320e-014
Cn23an32a17 TDn23a33 TDn32a33 1.690880e-014
Cn23anva1 TDn23a1 TDnva1 1.690880e-014
Cn23anva2 TDn23a3 TDnva3 1.690880e-014
Cn23anva3 TDn23a5 TDnva5 1.690880e-014
Cn23anva4 TDn23a7 TDnva7 1.690880e-014
Cn23anva5 TDn23a9 TDnva9 1.690880e-014
Cn23anva6 TDn23a11 TDnva11 1.690880e-014
Cn23anva7 TDn23a13 TDnva13 1.690880e-014
Cn23anva8 TDn23a15 TDnva15 1.690880e-014
Cn23anva9 TDn23a17 TDnva17 1.690880e-014
Cn23anva10 TDn23a19 TDnva19 1.690880e-014
Cn23anva11 TDn23a21 TDnva21 1.690880e-014
Cn23anva12 TDn23a23 TDnva23 1.690880e-014
Cn23anva13 TDn23a25 TDnva25 1.690880e-014
Cn23anva14 TDn23a27 TDnva27 1.690880e-014
Cn23anva15 TDn23a29 TDnva29 1.690880e-014
Cn23anva16 TDn23a31 TDnva31 1.690880e-014
Cn23anva17 TDn23a33 TDnva33 1.690880e-014
Cn24an25a1 TDn24a1 TDn25a1 1.690880e-014
Cn24an25a2 TDn24a3 TDn25a3 1.302320e-014
Cn24an25a3 TDn24a5 TDn25a5 1.302320e-014
Cn24an25a4 TDn24a7 TDn25a7 1.302320e-014
Cn24an25a5 TDn24a9 TDn25a9 1.302320e-014
Cn24an25a6 TDn24a11 TDn25a11 1.302320e-014
Cn24an25a7 TDn24a13 TDn25a13 1.302320e-014
Cn24an25a8 TDn24a15 TDn25a15 1.302320e-014
Cn24an25a9 TDn24a17 TDn25a17 1.302320e-014
Cn24an25a10 TDn24a19 TDn25a19 1.302320e-014
Cn24an25a11 TDn24a21 TDn25a21 1.302320e-014
Cn24an25a12 TDn24a23 TDn25a23 1.302320e-014
Cn24an25a13 TDn24a25 TDn25a25 1.302320e-014
Cn24an25a14 TDn24a27 TDn25a27 1.302320e-014
Cn24an25a15 TDn24a29 TDn25a29 1.302320e-014
Cn24an25a16 TDn24a31 TDn25a31 1.302320e-014
Cn24an25a17 TDn24a33 TDn25a33 1.690880e-014
Cn24an26a1 TDn24a1 TDn26a1 1.690880e-014
Cn24an26a2 TDn24a3 TDn26a3 1.302320e-014
Cn24an26a3 TDn24a5 TDn26a5 1.302320e-014
Cn24an26a4 TDn24a7 TDn26a7 1.302320e-014
Cn24an26a5 TDn24a9 TDn26a9 1.302320e-014
Cn24an26a6 TDn24a11 TDn26a11 1.302320e-014
Cn24an26a7 TDn24a13 TDn26a13 1.302320e-014
Cn24an26a8 TDn24a15 TDn26a15 1.302320e-014
Cn24an26a9 TDn24a17 TDn26a17 1.302320e-014
Cn24an26a10 TDn24a19 TDn26a19 1.302320e-014
Cn24an26a11 TDn24a21 TDn26a21 1.302320e-014
Cn24an26a12 TDn24a23 TDn26a23 1.302320e-014
Cn24an26a13 TDn24a25 TDn26a25 1.302320e-014
Cn24an26a14 TDn24a27 TDn26a27 1.302320e-014
Cn24an26a15 TDn24a29 TDn26a29 1.302320e-014
Cn24an26a16 TDn24a31 TDn26a31 1.302320e-014
Cn24an26a17 TDn24a33 TDn26a33 1.690880e-014
Cn24an27a1 TDn24a1 TDn27a1 1.690880e-014
Cn24an27a2 TDn24a3 TDn27a3 1.302320e-014
Cn24an27a3 TDn24a5 TDn27a5 1.302320e-014
Cn24an27a4 TDn24a7 TDn27a7 1.302320e-014
Cn24an27a5 TDn24a9 TDn27a9 1.302320e-014
Cn24an27a6 TDn24a11 TDn27a11 1.302320e-014
Cn24an27a7 TDn24a13 TDn27a13 1.302320e-014
Cn24an27a8 TDn24a15 TDn27a15 1.302320e-014
Cn24an27a9 TDn24a17 TDn27a17 1.302320e-014
Cn24an27a10 TDn24a19 TDn27a19 1.302320e-014
Cn24an27a11 TDn24a21 TDn27a21 1.302320e-014
Cn24an27a12 TDn24a23 TDn27a23 1.302320e-014
Cn24an27a13 TDn24a25 TDn27a25 1.302320e-014
Cn24an27a14 TDn24a27 TDn27a27 1.302320e-014
Cn24an27a15 TDn24a29 TDn27a29 1.302320e-014
Cn24an27a16 TDn24a31 TDn27a31 1.302320e-014
Cn24an27a17 TDn24a33 TDn27a33 1.690880e-014
Cn24an28a1 TDn24a1 TDn28a1 1.690880e-014
Cn24an28a2 TDn24a3 TDn28a3 1.302320e-014
Cn24an28a3 TDn24a5 TDn28a5 1.302320e-014
Cn24an28a4 TDn24a7 TDn28a7 1.302320e-014
Cn24an28a5 TDn24a9 TDn28a9 1.302320e-014
Cn24an28a6 TDn24a11 TDn28a11 1.302320e-014
Cn24an28a7 TDn24a13 TDn28a13 1.302320e-014
Cn24an28a8 TDn24a15 TDn28a15 1.302320e-014
Cn24an28a9 TDn24a17 TDn28a17 1.302320e-014
Cn24an28a10 TDn24a19 TDn28a19 1.302320e-014
Cn24an28a11 TDn24a21 TDn28a21 1.302320e-014
Cn24an28a12 TDn24a23 TDn28a23 1.302320e-014
Cn24an28a13 TDn24a25 TDn28a25 1.302320e-014
Cn24an28a14 TDn24a27 TDn28a27 1.302320e-014
Cn24an28a15 TDn24a29 TDn28a29 1.302320e-014
Cn24an28a16 TDn24a31 TDn28a31 1.302320e-014
Cn24an28a17 TDn24a33 TDn28a33 1.690880e-014
Cn24an29a1 TDn24a1 TDn29a1 1.690880e-014
Cn24an29a2 TDn24a3 TDn29a3 1.302320e-014
Cn24an29a3 TDn24a5 TDn29a5 1.302320e-014
Cn24an29a4 TDn24a7 TDn29a7 1.302320e-014
Cn24an29a5 TDn24a9 TDn29a9 1.302320e-014
Cn24an29a6 TDn24a11 TDn29a11 1.302320e-014
Cn24an29a7 TDn24a13 TDn29a13 1.302320e-014
Cn24an29a8 TDn24a15 TDn29a15 1.302320e-014
Cn24an29a9 TDn24a17 TDn29a17 1.302320e-014
Cn24an29a10 TDn24a19 TDn29a19 1.302320e-014
Cn24an29a11 TDn24a21 TDn29a21 1.302320e-014
Cn24an29a12 TDn24a23 TDn29a23 1.302320e-014
Cn24an29a13 TDn24a25 TDn29a25 1.302320e-014
Cn24an29a14 TDn24a27 TDn29a27 1.302320e-014
Cn24an29a15 TDn24a29 TDn29a29 1.302320e-014
Cn24an29a16 TDn24a31 TDn29a31 1.302320e-014
Cn24an29a17 TDn24a33 TDn29a33 1.690880e-014
Cn24an30a1 TDn24a1 TDn30a1 1.690880e-014
Cn24an30a2 TDn24a3 TDn30a3 1.302320e-014
Cn24an30a3 TDn24a5 TDn30a5 1.302320e-014
Cn24an30a4 TDn24a7 TDn30a7 1.302320e-014
Cn24an30a5 TDn24a9 TDn30a9 1.302320e-014
Cn24an30a6 TDn24a11 TDn30a11 1.302320e-014
Cn24an30a7 TDn24a13 TDn30a13 1.302320e-014
Cn24an30a8 TDn24a15 TDn30a15 1.302320e-014
Cn24an30a9 TDn24a17 TDn30a17 1.302320e-014
Cn24an30a10 TDn24a19 TDn30a19 1.302320e-014
Cn24an30a11 TDn24a21 TDn30a21 1.302320e-014
Cn24an30a12 TDn24a23 TDn30a23 1.302320e-014
Cn24an30a13 TDn24a25 TDn30a25 1.302320e-014
Cn24an30a14 TDn24a27 TDn30a27 1.302320e-014
Cn24an30a15 TDn24a29 TDn30a29 1.302320e-014
Cn24an30a16 TDn24a31 TDn30a31 1.302320e-014
Cn24an30a17 TDn24a33 TDn30a33 1.690880e-014
Cn24an31a1 TDn24a1 TDn31a1 1.690880e-014
Cn24an31a2 TDn24a3 TDn31a3 1.302320e-014
Cn24an31a3 TDn24a5 TDn31a5 1.302320e-014
Cn24an31a4 TDn24a7 TDn31a7 1.302320e-014
Cn24an31a5 TDn24a9 TDn31a9 1.302320e-014
Cn24an31a6 TDn24a11 TDn31a11 1.302320e-014
Cn24an31a7 TDn24a13 TDn31a13 1.302320e-014
Cn24an31a8 TDn24a15 TDn31a15 1.302320e-014
Cn24an31a9 TDn24a17 TDn31a17 1.302320e-014
Cn24an31a10 TDn24a19 TDn31a19 1.302320e-014
Cn24an31a11 TDn24a21 TDn31a21 1.302320e-014
Cn24an31a12 TDn24a23 TDn31a23 1.302320e-014
Cn24an31a13 TDn24a25 TDn31a25 1.302320e-014
Cn24an31a14 TDn24a27 TDn31a27 1.302320e-014
Cn24an31a15 TDn24a29 TDn31a29 1.302320e-014
Cn24an31a16 TDn24a31 TDn31a31 1.302320e-014
Cn24an31a17 TDn24a33 TDn31a33 1.690880e-014
Cn24an32a1 TDn24a1 TDn32a1 1.690880e-014
Cn24an32a2 TDn24a3 TDn32a3 1.302320e-014
Cn24an32a3 TDn24a5 TDn32a5 1.302320e-014
Cn24an32a4 TDn24a7 TDn32a7 1.302320e-014
Cn24an32a5 TDn24a9 TDn32a9 1.302320e-014
Cn24an32a6 TDn24a11 TDn32a11 1.302320e-014
Cn24an32a7 TDn24a13 TDn32a13 1.302320e-014
Cn24an32a8 TDn24a15 TDn32a15 1.302320e-014
Cn24an32a9 TDn24a17 TDn32a17 1.302320e-014
Cn24an32a10 TDn24a19 TDn32a19 1.302320e-014
Cn24an32a11 TDn24a21 TDn32a21 1.302320e-014
Cn24an32a12 TDn24a23 TDn32a23 1.302320e-014
Cn24an32a13 TDn24a25 TDn32a25 1.302320e-014
Cn24an32a14 TDn24a27 TDn32a27 1.302320e-014
Cn24an32a15 TDn24a29 TDn32a29 1.302320e-014
Cn24an32a16 TDn24a31 TDn32a31 1.302320e-014
Cn24an32a17 TDn24a33 TDn32a33 1.690880e-014
Cn24anva1 TDn24a1 TDnva1 1.690880e-014
Cn24anva2 TDn24a3 TDnva3 1.690880e-014
Cn24anva3 TDn24a5 TDnva5 1.690880e-014
Cn24anva4 TDn24a7 TDnva7 1.690880e-014
Cn24anva5 TDn24a9 TDnva9 1.690880e-014
Cn24anva6 TDn24a11 TDnva11 1.690880e-014
Cn24anva7 TDn24a13 TDnva13 1.690880e-014
Cn24anva8 TDn24a15 TDnva15 1.690880e-014
Cn24anva9 TDn24a17 TDnva17 1.690880e-014
Cn24anva10 TDn24a19 TDnva19 1.690880e-014
Cn24anva11 TDn24a21 TDnva21 1.690880e-014
Cn24anva12 TDn24a23 TDnva23 1.690880e-014
Cn24anva13 TDn24a25 TDnva25 1.690880e-014
Cn24anva14 TDn24a27 TDnva27 1.690880e-014
Cn24anva15 TDn24a29 TDnva29 1.690880e-014
Cn24anva16 TDn24a31 TDnva31 1.690880e-014
Cn24anva17 TDn24a33 TDnva33 1.690880e-014
Cn25an26a1 TDn25a1 TDn26a1 1.690880e-014
Cn25an26a2 TDn25a3 TDn26a3 1.302320e-014
Cn25an26a3 TDn25a5 TDn26a5 1.302320e-014
Cn25an26a4 TDn25a7 TDn26a7 1.302320e-014
Cn25an26a5 TDn25a9 TDn26a9 1.302320e-014
Cn25an26a6 TDn25a11 TDn26a11 1.302320e-014
Cn25an26a7 TDn25a13 TDn26a13 1.302320e-014
Cn25an26a8 TDn25a15 TDn26a15 1.302320e-014
Cn25an26a9 TDn25a17 TDn26a17 1.302320e-014
Cn25an26a10 TDn25a19 TDn26a19 1.302320e-014
Cn25an26a11 TDn25a21 TDn26a21 1.302320e-014
Cn25an26a12 TDn25a23 TDn26a23 1.302320e-014
Cn25an26a13 TDn25a25 TDn26a25 1.302320e-014
Cn25an26a14 TDn25a27 TDn26a27 1.302320e-014
Cn25an26a15 TDn25a29 TDn26a29 1.302320e-014
Cn25an26a16 TDn25a31 TDn26a31 1.302320e-014
Cn25an26a17 TDn25a33 TDn26a33 1.690880e-014
Cn25an27a1 TDn25a1 TDn27a1 1.690880e-014
Cn25an27a2 TDn25a3 TDn27a3 1.302320e-014
Cn25an27a3 TDn25a5 TDn27a5 1.302320e-014
Cn25an27a4 TDn25a7 TDn27a7 1.302320e-014
Cn25an27a5 TDn25a9 TDn27a9 1.302320e-014
Cn25an27a6 TDn25a11 TDn27a11 1.302320e-014
Cn25an27a7 TDn25a13 TDn27a13 1.302320e-014
Cn25an27a8 TDn25a15 TDn27a15 1.302320e-014
Cn25an27a9 TDn25a17 TDn27a17 1.302320e-014
Cn25an27a10 TDn25a19 TDn27a19 1.302320e-014
Cn25an27a11 TDn25a21 TDn27a21 1.302320e-014
Cn25an27a12 TDn25a23 TDn27a23 1.302320e-014
Cn25an27a13 TDn25a25 TDn27a25 1.302320e-014
Cn25an27a14 TDn25a27 TDn27a27 1.302320e-014
Cn25an27a15 TDn25a29 TDn27a29 1.302320e-014
Cn25an27a16 TDn25a31 TDn27a31 1.302320e-014
Cn25an27a17 TDn25a33 TDn27a33 1.690880e-014
Cn25an28a1 TDn25a1 TDn28a1 1.690880e-014
Cn25an28a2 TDn25a3 TDn28a3 1.302320e-014
Cn25an28a3 TDn25a5 TDn28a5 1.302320e-014
Cn25an28a4 TDn25a7 TDn28a7 1.302320e-014
Cn25an28a5 TDn25a9 TDn28a9 1.302320e-014
Cn25an28a6 TDn25a11 TDn28a11 1.302320e-014
Cn25an28a7 TDn25a13 TDn28a13 1.302320e-014
Cn25an28a8 TDn25a15 TDn28a15 1.302320e-014
Cn25an28a9 TDn25a17 TDn28a17 1.302320e-014
Cn25an28a10 TDn25a19 TDn28a19 1.302320e-014
Cn25an28a11 TDn25a21 TDn28a21 1.302320e-014
Cn25an28a12 TDn25a23 TDn28a23 1.302320e-014
Cn25an28a13 TDn25a25 TDn28a25 1.302320e-014
Cn25an28a14 TDn25a27 TDn28a27 1.302320e-014
Cn25an28a15 TDn25a29 TDn28a29 1.302320e-014
Cn25an28a16 TDn25a31 TDn28a31 1.302320e-014
Cn25an28a17 TDn25a33 TDn28a33 1.690880e-014
Cn25an29a1 TDn25a1 TDn29a1 1.690880e-014
Cn25an29a2 TDn25a3 TDn29a3 1.302320e-014
Cn25an29a3 TDn25a5 TDn29a5 1.302320e-014
Cn25an29a4 TDn25a7 TDn29a7 1.302320e-014
Cn25an29a5 TDn25a9 TDn29a9 1.302320e-014
Cn25an29a6 TDn25a11 TDn29a11 1.302320e-014
Cn25an29a7 TDn25a13 TDn29a13 1.302320e-014
Cn25an29a8 TDn25a15 TDn29a15 1.302320e-014
Cn25an29a9 TDn25a17 TDn29a17 1.302320e-014
Cn25an29a10 TDn25a19 TDn29a19 1.302320e-014
Cn25an29a11 TDn25a21 TDn29a21 1.302320e-014
Cn25an29a12 TDn25a23 TDn29a23 1.302320e-014
Cn25an29a13 TDn25a25 TDn29a25 1.302320e-014
Cn25an29a14 TDn25a27 TDn29a27 1.302320e-014
Cn25an29a15 TDn25a29 TDn29a29 1.302320e-014
Cn25an29a16 TDn25a31 TDn29a31 1.302320e-014
Cn25an29a17 TDn25a33 TDn29a33 1.690880e-014
Cn25an30a1 TDn25a1 TDn30a1 1.690880e-014
Cn25an30a2 TDn25a3 TDn30a3 1.302320e-014
Cn25an30a3 TDn25a5 TDn30a5 1.302320e-014
Cn25an30a4 TDn25a7 TDn30a7 1.302320e-014
Cn25an30a5 TDn25a9 TDn30a9 1.302320e-014
Cn25an30a6 TDn25a11 TDn30a11 1.302320e-014
Cn25an30a7 TDn25a13 TDn30a13 1.302320e-014
Cn25an30a8 TDn25a15 TDn30a15 1.302320e-014
Cn25an30a9 TDn25a17 TDn30a17 1.302320e-014
Cn25an30a10 TDn25a19 TDn30a19 1.302320e-014
Cn25an30a11 TDn25a21 TDn30a21 1.302320e-014
Cn25an30a12 TDn25a23 TDn30a23 1.302320e-014
Cn25an30a13 TDn25a25 TDn30a25 1.302320e-014
Cn25an30a14 TDn25a27 TDn30a27 1.302320e-014
Cn25an30a15 TDn25a29 TDn30a29 1.302320e-014
Cn25an30a16 TDn25a31 TDn30a31 1.302320e-014
Cn25an30a17 TDn25a33 TDn30a33 1.690880e-014
Cn25an31a1 TDn25a1 TDn31a1 1.690880e-014
Cn25an31a2 TDn25a3 TDn31a3 1.302320e-014
Cn25an31a3 TDn25a5 TDn31a5 1.302320e-014
Cn25an31a4 TDn25a7 TDn31a7 1.302320e-014
Cn25an31a5 TDn25a9 TDn31a9 1.302320e-014
Cn25an31a6 TDn25a11 TDn31a11 1.302320e-014
Cn25an31a7 TDn25a13 TDn31a13 1.302320e-014
Cn25an31a8 TDn25a15 TDn31a15 1.302320e-014
Cn25an31a9 TDn25a17 TDn31a17 1.302320e-014
Cn25an31a10 TDn25a19 TDn31a19 1.302320e-014
Cn25an31a11 TDn25a21 TDn31a21 1.302320e-014
Cn25an31a12 TDn25a23 TDn31a23 1.302320e-014
Cn25an31a13 TDn25a25 TDn31a25 1.302320e-014
Cn25an31a14 TDn25a27 TDn31a27 1.302320e-014
Cn25an31a15 TDn25a29 TDn31a29 1.302320e-014
Cn25an31a16 TDn25a31 TDn31a31 1.302320e-014
Cn25an31a17 TDn25a33 TDn31a33 1.690880e-014
Cn25an32a1 TDn25a1 TDn32a1 1.690880e-014
Cn25an32a2 TDn25a3 TDn32a3 1.302320e-014
Cn25an32a3 TDn25a5 TDn32a5 1.302320e-014
Cn25an32a4 TDn25a7 TDn32a7 1.302320e-014
Cn25an32a5 TDn25a9 TDn32a9 1.302320e-014
Cn25an32a6 TDn25a11 TDn32a11 1.302320e-014
Cn25an32a7 TDn25a13 TDn32a13 1.302320e-014
Cn25an32a8 TDn25a15 TDn32a15 1.302320e-014
Cn25an32a9 TDn25a17 TDn32a17 1.302320e-014
Cn25an32a10 TDn25a19 TDn32a19 1.302320e-014
Cn25an32a11 TDn25a21 TDn32a21 1.302320e-014
Cn25an32a12 TDn25a23 TDn32a23 1.302320e-014
Cn25an32a13 TDn25a25 TDn32a25 1.302320e-014
Cn25an32a14 TDn25a27 TDn32a27 1.302320e-014
Cn25an32a15 TDn25a29 TDn32a29 1.302320e-014
Cn25an32a16 TDn25a31 TDn32a31 1.302320e-014
Cn25an32a17 TDn25a33 TDn32a33 1.690880e-014
Cn25anva1 TDn25a1 TDnva1 1.690880e-014
Cn25anva2 TDn25a3 TDnva3 1.690880e-014
Cn25anva3 TDn25a5 TDnva5 1.690880e-014
Cn25anva4 TDn25a7 TDnva7 1.690880e-014
Cn25anva5 TDn25a9 TDnva9 1.690880e-014
Cn25anva6 TDn25a11 TDnva11 1.690880e-014
Cn25anva7 TDn25a13 TDnva13 1.690880e-014
Cn25anva8 TDn25a15 TDnva15 1.690880e-014
Cn25anva9 TDn25a17 TDnva17 1.690880e-014
Cn25anva10 TDn25a19 TDnva19 1.690880e-014
Cn25anva11 TDn25a21 TDnva21 1.690880e-014
Cn25anva12 TDn25a23 TDnva23 1.690880e-014
Cn25anva13 TDn25a25 TDnva25 1.690880e-014
Cn25anva14 TDn25a27 TDnva27 1.690880e-014
Cn25anva15 TDn25a29 TDnva29 1.690880e-014
Cn25anva16 TDn25a31 TDnva31 1.690880e-014
Cn25anva17 TDn25a33 TDnva33 1.690880e-014
Cn26an27a1 TDn26a1 TDn27a1 1.690880e-014
Cn26an27a2 TDn26a3 TDn27a3 1.302320e-014
Cn26an27a3 TDn26a5 TDn27a5 1.302320e-014
Cn26an27a4 TDn26a7 TDn27a7 1.302320e-014
Cn26an27a5 TDn26a9 TDn27a9 1.302320e-014
Cn26an27a6 TDn26a11 TDn27a11 1.302320e-014
Cn26an27a7 TDn26a13 TDn27a13 1.302320e-014
Cn26an27a8 TDn26a15 TDn27a15 1.302320e-014
Cn26an27a9 TDn26a17 TDn27a17 1.302320e-014
Cn26an27a10 TDn26a19 TDn27a19 1.302320e-014
Cn26an27a11 TDn26a21 TDn27a21 1.302320e-014
Cn26an27a12 TDn26a23 TDn27a23 1.302320e-014
Cn26an27a13 TDn26a25 TDn27a25 1.302320e-014
Cn26an27a14 TDn26a27 TDn27a27 1.302320e-014
Cn26an27a15 TDn26a29 TDn27a29 1.302320e-014
Cn26an27a16 TDn26a31 TDn27a31 1.302320e-014
Cn26an27a17 TDn26a33 TDn27a33 1.690880e-014
Cn26an28a1 TDn26a1 TDn28a1 1.690880e-014
Cn26an28a2 TDn26a3 TDn28a3 1.302320e-014
Cn26an28a3 TDn26a5 TDn28a5 1.302320e-014
Cn26an28a4 TDn26a7 TDn28a7 1.302320e-014
Cn26an28a5 TDn26a9 TDn28a9 1.302320e-014
Cn26an28a6 TDn26a11 TDn28a11 1.302320e-014
Cn26an28a7 TDn26a13 TDn28a13 1.302320e-014
Cn26an28a8 TDn26a15 TDn28a15 1.302320e-014
Cn26an28a9 TDn26a17 TDn28a17 1.302320e-014
Cn26an28a10 TDn26a19 TDn28a19 1.302320e-014
Cn26an28a11 TDn26a21 TDn28a21 1.302320e-014
Cn26an28a12 TDn26a23 TDn28a23 1.302320e-014
Cn26an28a13 TDn26a25 TDn28a25 1.302320e-014
Cn26an28a14 TDn26a27 TDn28a27 1.302320e-014
Cn26an28a15 TDn26a29 TDn28a29 1.302320e-014
Cn26an28a16 TDn26a31 TDn28a31 1.302320e-014
Cn26an28a17 TDn26a33 TDn28a33 1.690880e-014
Cn26an29a1 TDn26a1 TDn29a1 1.690880e-014
Cn26an29a2 TDn26a3 TDn29a3 1.302320e-014
Cn26an29a3 TDn26a5 TDn29a5 1.302320e-014
Cn26an29a4 TDn26a7 TDn29a7 1.302320e-014
Cn26an29a5 TDn26a9 TDn29a9 1.302320e-014
Cn26an29a6 TDn26a11 TDn29a11 1.302320e-014
Cn26an29a7 TDn26a13 TDn29a13 1.302320e-014
Cn26an29a8 TDn26a15 TDn29a15 1.302320e-014
Cn26an29a9 TDn26a17 TDn29a17 1.302320e-014
Cn26an29a10 TDn26a19 TDn29a19 1.302320e-014
Cn26an29a11 TDn26a21 TDn29a21 1.302320e-014
Cn26an29a12 TDn26a23 TDn29a23 1.302320e-014
Cn26an29a13 TDn26a25 TDn29a25 1.302320e-014
Cn26an29a14 TDn26a27 TDn29a27 1.302320e-014
Cn26an29a15 TDn26a29 TDn29a29 1.302320e-014
Cn26an29a16 TDn26a31 TDn29a31 1.302320e-014
Cn26an29a17 TDn26a33 TDn29a33 1.690880e-014
Cn26an30a1 TDn26a1 TDn30a1 1.690880e-014
Cn26an30a2 TDn26a3 TDn30a3 1.302320e-014
Cn26an30a3 TDn26a5 TDn30a5 1.302320e-014
Cn26an30a4 TDn26a7 TDn30a7 1.302320e-014
Cn26an30a5 TDn26a9 TDn30a9 1.302320e-014
Cn26an30a6 TDn26a11 TDn30a11 1.302320e-014
Cn26an30a7 TDn26a13 TDn30a13 1.302320e-014
Cn26an30a8 TDn26a15 TDn30a15 1.302320e-014
Cn26an30a9 TDn26a17 TDn30a17 1.302320e-014
Cn26an30a10 TDn26a19 TDn30a19 1.302320e-014
Cn26an30a11 TDn26a21 TDn30a21 1.302320e-014
Cn26an30a12 TDn26a23 TDn30a23 1.302320e-014
Cn26an30a13 TDn26a25 TDn30a25 1.302320e-014
Cn26an30a14 TDn26a27 TDn30a27 1.302320e-014
Cn26an30a15 TDn26a29 TDn30a29 1.302320e-014
Cn26an30a16 TDn26a31 TDn30a31 1.302320e-014
Cn26an30a17 TDn26a33 TDn30a33 1.690880e-014
Cn26an31a1 TDn26a1 TDn31a1 1.690880e-014
Cn26an31a2 TDn26a3 TDn31a3 1.302320e-014
Cn26an31a3 TDn26a5 TDn31a5 1.302320e-014
Cn26an31a4 TDn26a7 TDn31a7 1.302320e-014
Cn26an31a5 TDn26a9 TDn31a9 1.302320e-014
Cn26an31a6 TDn26a11 TDn31a11 1.302320e-014
Cn26an31a7 TDn26a13 TDn31a13 1.302320e-014
Cn26an31a8 TDn26a15 TDn31a15 1.302320e-014
Cn26an31a9 TDn26a17 TDn31a17 1.302320e-014
Cn26an31a10 TDn26a19 TDn31a19 1.302320e-014
Cn26an31a11 TDn26a21 TDn31a21 1.302320e-014
Cn26an31a12 TDn26a23 TDn31a23 1.302320e-014
Cn26an31a13 TDn26a25 TDn31a25 1.302320e-014
Cn26an31a14 TDn26a27 TDn31a27 1.302320e-014
Cn26an31a15 TDn26a29 TDn31a29 1.302320e-014
Cn26an31a16 TDn26a31 TDn31a31 1.302320e-014
Cn26an31a17 TDn26a33 TDn31a33 1.690880e-014
Cn26an32a1 TDn26a1 TDn32a1 1.690880e-014
Cn26an32a2 TDn26a3 TDn32a3 1.302320e-014
Cn26an32a3 TDn26a5 TDn32a5 1.302320e-014
Cn26an32a4 TDn26a7 TDn32a7 1.302320e-014
Cn26an32a5 TDn26a9 TDn32a9 1.302320e-014
Cn26an32a6 TDn26a11 TDn32a11 1.302320e-014
Cn26an32a7 TDn26a13 TDn32a13 1.302320e-014
Cn26an32a8 TDn26a15 TDn32a15 1.302320e-014
Cn26an32a9 TDn26a17 TDn32a17 1.302320e-014
Cn26an32a10 TDn26a19 TDn32a19 1.302320e-014
Cn26an32a11 TDn26a21 TDn32a21 1.302320e-014
Cn26an32a12 TDn26a23 TDn32a23 1.302320e-014
Cn26an32a13 TDn26a25 TDn32a25 1.302320e-014
Cn26an32a14 TDn26a27 TDn32a27 1.302320e-014
Cn26an32a15 TDn26a29 TDn32a29 1.302320e-014
Cn26an32a16 TDn26a31 TDn32a31 1.302320e-014
Cn26an32a17 TDn26a33 TDn32a33 1.690880e-014
Cn26anva1 TDn26a1 TDnva1 1.690880e-014
Cn26anva2 TDn26a3 TDnva3 1.690880e-014
Cn26anva3 TDn26a5 TDnva5 1.690880e-014
Cn26anva4 TDn26a7 TDnva7 1.690880e-014
Cn26anva5 TDn26a9 TDnva9 1.690880e-014
Cn26anva6 TDn26a11 TDnva11 1.690880e-014
Cn26anva7 TDn26a13 TDnva13 1.690880e-014
Cn26anva8 TDn26a15 TDnva15 1.690880e-014
Cn26anva9 TDn26a17 TDnva17 1.690880e-014
Cn26anva10 TDn26a19 TDnva19 1.690880e-014
Cn26anva11 TDn26a21 TDnva21 1.690880e-014
Cn26anva12 TDn26a23 TDnva23 1.690880e-014
Cn26anva13 TDn26a25 TDnva25 1.690880e-014
Cn26anva14 TDn26a27 TDnva27 1.690880e-014
Cn26anva15 TDn26a29 TDnva29 1.690880e-014
Cn26anva16 TDn26a31 TDnva31 1.690880e-014
Cn26anva17 TDn26a33 TDnva33 1.690880e-014
Cn27an28a1 TDn27a1 TDn28a1 1.690880e-014
Cn27an28a2 TDn27a3 TDn28a3 1.302320e-014
Cn27an28a3 TDn27a5 TDn28a5 1.302320e-014
Cn27an28a4 TDn27a7 TDn28a7 1.302320e-014
Cn27an28a5 TDn27a9 TDn28a9 1.302320e-014
Cn27an28a6 TDn27a11 TDn28a11 1.302320e-014
Cn27an28a7 TDn27a13 TDn28a13 1.302320e-014
Cn27an28a8 TDn27a15 TDn28a15 1.302320e-014
Cn27an28a9 TDn27a17 TDn28a17 1.302320e-014
Cn27an28a10 TDn27a19 TDn28a19 1.302320e-014
Cn27an28a11 TDn27a21 TDn28a21 1.302320e-014
Cn27an28a12 TDn27a23 TDn28a23 1.302320e-014
Cn27an28a13 TDn27a25 TDn28a25 1.302320e-014
Cn27an28a14 TDn27a27 TDn28a27 1.302320e-014
Cn27an28a15 TDn27a29 TDn28a29 1.302320e-014
Cn27an28a16 TDn27a31 TDn28a31 1.302320e-014
Cn27an28a17 TDn27a33 TDn28a33 1.690880e-014
Cn27an29a1 TDn27a1 TDn29a1 1.690880e-014
Cn27an29a2 TDn27a3 TDn29a3 1.302320e-014
Cn27an29a3 TDn27a5 TDn29a5 1.302320e-014
Cn27an29a4 TDn27a7 TDn29a7 1.302320e-014
Cn27an29a5 TDn27a9 TDn29a9 1.302320e-014
Cn27an29a6 TDn27a11 TDn29a11 1.302320e-014
Cn27an29a7 TDn27a13 TDn29a13 1.302320e-014
Cn27an29a8 TDn27a15 TDn29a15 1.302320e-014
Cn27an29a9 TDn27a17 TDn29a17 1.302320e-014
Cn27an29a10 TDn27a19 TDn29a19 1.302320e-014
Cn27an29a11 TDn27a21 TDn29a21 1.302320e-014
Cn27an29a12 TDn27a23 TDn29a23 1.302320e-014
Cn27an29a13 TDn27a25 TDn29a25 1.302320e-014
Cn27an29a14 TDn27a27 TDn29a27 1.302320e-014
Cn27an29a15 TDn27a29 TDn29a29 1.302320e-014
Cn27an29a16 TDn27a31 TDn29a31 1.302320e-014
Cn27an29a17 TDn27a33 TDn29a33 1.690880e-014
Cn27an30a1 TDn27a1 TDn30a1 1.690880e-014
Cn27an30a2 TDn27a3 TDn30a3 1.302320e-014
Cn27an30a3 TDn27a5 TDn30a5 1.302320e-014
Cn27an30a4 TDn27a7 TDn30a7 1.302320e-014
Cn27an30a5 TDn27a9 TDn30a9 1.302320e-014
Cn27an30a6 TDn27a11 TDn30a11 1.302320e-014
Cn27an30a7 TDn27a13 TDn30a13 1.302320e-014
Cn27an30a8 TDn27a15 TDn30a15 1.302320e-014
Cn27an30a9 TDn27a17 TDn30a17 1.302320e-014
Cn27an30a10 TDn27a19 TDn30a19 1.302320e-014
Cn27an30a11 TDn27a21 TDn30a21 1.302320e-014
Cn27an30a12 TDn27a23 TDn30a23 1.302320e-014
Cn27an30a13 TDn27a25 TDn30a25 1.302320e-014
Cn27an30a14 TDn27a27 TDn30a27 1.302320e-014
Cn27an30a15 TDn27a29 TDn30a29 1.302320e-014
Cn27an30a16 TDn27a31 TDn30a31 1.302320e-014
Cn27an30a17 TDn27a33 TDn30a33 1.690880e-014
Cn27an31a1 TDn27a1 TDn31a1 1.690880e-014
Cn27an31a2 TDn27a3 TDn31a3 1.302320e-014
Cn27an31a3 TDn27a5 TDn31a5 1.302320e-014
Cn27an31a4 TDn27a7 TDn31a7 1.302320e-014
Cn27an31a5 TDn27a9 TDn31a9 1.302320e-014
Cn27an31a6 TDn27a11 TDn31a11 1.302320e-014
Cn27an31a7 TDn27a13 TDn31a13 1.302320e-014
Cn27an31a8 TDn27a15 TDn31a15 1.302320e-014
Cn27an31a9 TDn27a17 TDn31a17 1.302320e-014
Cn27an31a10 TDn27a19 TDn31a19 1.302320e-014
Cn27an31a11 TDn27a21 TDn31a21 1.302320e-014
Cn27an31a12 TDn27a23 TDn31a23 1.302320e-014
Cn27an31a13 TDn27a25 TDn31a25 1.302320e-014
Cn27an31a14 TDn27a27 TDn31a27 1.302320e-014
Cn27an31a15 TDn27a29 TDn31a29 1.302320e-014
Cn27an31a16 TDn27a31 TDn31a31 1.302320e-014
Cn27an31a17 TDn27a33 TDn31a33 1.690880e-014
Cn27an32a1 TDn27a1 TDn32a1 1.690880e-014
Cn27an32a2 TDn27a3 TDn32a3 1.302320e-014
Cn27an32a3 TDn27a5 TDn32a5 1.302320e-014
Cn27an32a4 TDn27a7 TDn32a7 1.302320e-014
Cn27an32a5 TDn27a9 TDn32a9 1.302320e-014
Cn27an32a6 TDn27a11 TDn32a11 1.302320e-014
Cn27an32a7 TDn27a13 TDn32a13 1.302320e-014
Cn27an32a8 TDn27a15 TDn32a15 1.302320e-014
Cn27an32a9 TDn27a17 TDn32a17 1.302320e-014
Cn27an32a10 TDn27a19 TDn32a19 1.302320e-014
Cn27an32a11 TDn27a21 TDn32a21 1.302320e-014
Cn27an32a12 TDn27a23 TDn32a23 1.302320e-014
Cn27an32a13 TDn27a25 TDn32a25 1.302320e-014
Cn27an32a14 TDn27a27 TDn32a27 1.302320e-014
Cn27an32a15 TDn27a29 TDn32a29 1.302320e-014
Cn27an32a16 TDn27a31 TDn32a31 1.302320e-014
Cn27an32a17 TDn27a33 TDn32a33 1.690880e-014
Cn27anva1 TDn27a1 TDnva1 1.690880e-014
Cn27anva2 TDn27a3 TDnva3 1.690880e-014
Cn27anva3 TDn27a5 TDnva5 1.690880e-014
Cn27anva4 TDn27a7 TDnva7 1.690880e-014
Cn27anva5 TDn27a9 TDnva9 1.690880e-014
Cn27anva6 TDn27a11 TDnva11 1.690880e-014
Cn27anva7 TDn27a13 TDnva13 1.690880e-014
Cn27anva8 TDn27a15 TDnva15 1.690880e-014
Cn27anva9 TDn27a17 TDnva17 1.690880e-014
Cn27anva10 TDn27a19 TDnva19 1.690880e-014
Cn27anva11 TDn27a21 TDnva21 1.690880e-014
Cn27anva12 TDn27a23 TDnva23 1.690880e-014
Cn27anva13 TDn27a25 TDnva25 1.690880e-014
Cn27anva14 TDn27a27 TDnva27 1.690880e-014
Cn27anva15 TDn27a29 TDnva29 1.690880e-014
Cn27anva16 TDn27a31 TDnva31 1.690880e-014
Cn27anva17 TDn27a33 TDnva33 1.690880e-014
Cn28an29a1 TDn28a1 TDn29a1 1.690880e-014
Cn28an29a2 TDn28a3 TDn29a3 1.302320e-014
Cn28an29a3 TDn28a5 TDn29a5 1.302320e-014
Cn28an29a4 TDn28a7 TDn29a7 1.302320e-014
Cn28an29a5 TDn28a9 TDn29a9 1.302320e-014
Cn28an29a6 TDn28a11 TDn29a11 1.302320e-014
Cn28an29a7 TDn28a13 TDn29a13 1.302320e-014
Cn28an29a8 TDn28a15 TDn29a15 1.302320e-014
Cn28an29a9 TDn28a17 TDn29a17 1.302320e-014
Cn28an29a10 TDn28a19 TDn29a19 1.302320e-014
Cn28an29a11 TDn28a21 TDn29a21 1.302320e-014
Cn28an29a12 TDn28a23 TDn29a23 1.302320e-014
Cn28an29a13 TDn28a25 TDn29a25 1.302320e-014
Cn28an29a14 TDn28a27 TDn29a27 1.302320e-014
Cn28an29a15 TDn28a29 TDn29a29 1.302320e-014
Cn28an29a16 TDn28a31 TDn29a31 1.302320e-014
Cn28an29a17 TDn28a33 TDn29a33 1.690880e-014
Cn28an30a1 TDn28a1 TDn30a1 1.690880e-014
Cn28an30a2 TDn28a3 TDn30a3 1.302320e-014
Cn28an30a3 TDn28a5 TDn30a5 1.302320e-014
Cn28an30a4 TDn28a7 TDn30a7 1.302320e-014
Cn28an30a5 TDn28a9 TDn30a9 1.302320e-014
Cn28an30a6 TDn28a11 TDn30a11 1.302320e-014
Cn28an30a7 TDn28a13 TDn30a13 1.302320e-014
Cn28an30a8 TDn28a15 TDn30a15 1.302320e-014
Cn28an30a9 TDn28a17 TDn30a17 1.302320e-014
Cn28an30a10 TDn28a19 TDn30a19 1.302320e-014
Cn28an30a11 TDn28a21 TDn30a21 1.302320e-014
Cn28an30a12 TDn28a23 TDn30a23 1.302320e-014
Cn28an30a13 TDn28a25 TDn30a25 1.302320e-014
Cn28an30a14 TDn28a27 TDn30a27 1.302320e-014
Cn28an30a15 TDn28a29 TDn30a29 1.302320e-014
Cn28an30a16 TDn28a31 TDn30a31 1.302320e-014
Cn28an30a17 TDn28a33 TDn30a33 1.690880e-014
Cn28an31a1 TDn28a1 TDn31a1 1.690880e-014
Cn28an31a2 TDn28a3 TDn31a3 1.302320e-014
Cn28an31a3 TDn28a5 TDn31a5 1.302320e-014
Cn28an31a4 TDn28a7 TDn31a7 1.302320e-014
Cn28an31a5 TDn28a9 TDn31a9 1.302320e-014
Cn28an31a6 TDn28a11 TDn31a11 1.302320e-014
Cn28an31a7 TDn28a13 TDn31a13 1.302320e-014
Cn28an31a8 TDn28a15 TDn31a15 1.302320e-014
Cn28an31a9 TDn28a17 TDn31a17 1.302320e-014
Cn28an31a10 TDn28a19 TDn31a19 1.302320e-014
Cn28an31a11 TDn28a21 TDn31a21 1.302320e-014
Cn28an31a12 TDn28a23 TDn31a23 1.302320e-014
Cn28an31a13 TDn28a25 TDn31a25 1.302320e-014
Cn28an31a14 TDn28a27 TDn31a27 1.302320e-014
Cn28an31a15 TDn28a29 TDn31a29 1.302320e-014
Cn28an31a16 TDn28a31 TDn31a31 1.302320e-014
Cn28an31a17 TDn28a33 TDn31a33 1.690880e-014
Cn28an32a1 TDn28a1 TDn32a1 1.690880e-014
Cn28an32a2 TDn28a3 TDn32a3 1.302320e-014
Cn28an32a3 TDn28a5 TDn32a5 1.302320e-014
Cn28an32a4 TDn28a7 TDn32a7 1.302320e-014
Cn28an32a5 TDn28a9 TDn32a9 1.302320e-014
Cn28an32a6 TDn28a11 TDn32a11 1.302320e-014
Cn28an32a7 TDn28a13 TDn32a13 1.302320e-014
Cn28an32a8 TDn28a15 TDn32a15 1.302320e-014
Cn28an32a9 TDn28a17 TDn32a17 1.302320e-014
Cn28an32a10 TDn28a19 TDn32a19 1.302320e-014
Cn28an32a11 TDn28a21 TDn32a21 1.302320e-014
Cn28an32a12 TDn28a23 TDn32a23 1.302320e-014
Cn28an32a13 TDn28a25 TDn32a25 1.302320e-014
Cn28an32a14 TDn28a27 TDn32a27 1.302320e-014
Cn28an32a15 TDn28a29 TDn32a29 1.302320e-014
Cn28an32a16 TDn28a31 TDn32a31 1.302320e-014
Cn28an32a17 TDn28a33 TDn32a33 1.690880e-014
Cn28anva1 TDn28a1 TDnva1 1.690880e-014
Cn28anva2 TDn28a3 TDnva3 1.690880e-014
Cn28anva3 TDn28a5 TDnva5 1.690880e-014
Cn28anva4 TDn28a7 TDnva7 1.690880e-014
Cn28anva5 TDn28a9 TDnva9 1.690880e-014
Cn28anva6 TDn28a11 TDnva11 1.690880e-014
Cn28anva7 TDn28a13 TDnva13 1.690880e-014
Cn28anva8 TDn28a15 TDnva15 1.690880e-014
Cn28anva9 TDn28a17 TDnva17 1.690880e-014
Cn28anva10 TDn28a19 TDnva19 1.690880e-014
Cn28anva11 TDn28a21 TDnva21 1.690880e-014
Cn28anva12 TDn28a23 TDnva23 1.690880e-014
Cn28anva13 TDn28a25 TDnva25 1.690880e-014
Cn28anva14 TDn28a27 TDnva27 1.690880e-014
Cn28anva15 TDn28a29 TDnva29 1.690880e-014
Cn28anva16 TDn28a31 TDnva31 1.690880e-014
Cn28anva17 TDn28a33 TDnva33 1.690880e-014
Cn29an30a1 TDn29a1 TDn30a1 1.690880e-014
Cn29an30a2 TDn29a3 TDn30a3 1.302320e-014
Cn29an30a3 TDn29a5 TDn30a5 1.302320e-014
Cn29an30a4 TDn29a7 TDn30a7 1.302320e-014
Cn29an30a5 TDn29a9 TDn30a9 1.302320e-014
Cn29an30a6 TDn29a11 TDn30a11 1.302320e-014
Cn29an30a7 TDn29a13 TDn30a13 1.302320e-014
Cn29an30a8 TDn29a15 TDn30a15 1.302320e-014
Cn29an30a9 TDn29a17 TDn30a17 1.302320e-014
Cn29an30a10 TDn29a19 TDn30a19 1.302320e-014
Cn29an30a11 TDn29a21 TDn30a21 1.302320e-014
Cn29an30a12 TDn29a23 TDn30a23 1.302320e-014
Cn29an30a13 TDn29a25 TDn30a25 1.302320e-014
Cn29an30a14 TDn29a27 TDn30a27 1.302320e-014
Cn29an30a15 TDn29a29 TDn30a29 1.302320e-014
Cn29an30a16 TDn29a31 TDn30a31 1.302320e-014
Cn29an30a17 TDn29a33 TDn30a33 1.690880e-014
Cn29an31a1 TDn29a1 TDn31a1 1.690880e-014
Cn29an31a2 TDn29a3 TDn31a3 1.302320e-014
Cn29an31a3 TDn29a5 TDn31a5 1.302320e-014
Cn29an31a4 TDn29a7 TDn31a7 1.302320e-014
Cn29an31a5 TDn29a9 TDn31a9 1.302320e-014
Cn29an31a6 TDn29a11 TDn31a11 1.302320e-014
Cn29an31a7 TDn29a13 TDn31a13 1.302320e-014
Cn29an31a8 TDn29a15 TDn31a15 1.302320e-014
Cn29an31a9 TDn29a17 TDn31a17 1.302320e-014
Cn29an31a10 TDn29a19 TDn31a19 1.302320e-014
Cn29an31a11 TDn29a21 TDn31a21 1.302320e-014
Cn29an31a12 TDn29a23 TDn31a23 1.302320e-014
Cn29an31a13 TDn29a25 TDn31a25 1.302320e-014
Cn29an31a14 TDn29a27 TDn31a27 1.302320e-014
Cn29an31a15 TDn29a29 TDn31a29 1.302320e-014
Cn29an31a16 TDn29a31 TDn31a31 1.302320e-014
Cn29an31a17 TDn29a33 TDn31a33 1.690880e-014
Cn29an32a1 TDn29a1 TDn32a1 1.690880e-014
Cn29an32a2 TDn29a3 TDn32a3 1.302320e-014
Cn29an32a3 TDn29a5 TDn32a5 1.302320e-014
Cn29an32a4 TDn29a7 TDn32a7 1.302320e-014
Cn29an32a5 TDn29a9 TDn32a9 1.302320e-014
Cn29an32a6 TDn29a11 TDn32a11 1.302320e-014
Cn29an32a7 TDn29a13 TDn32a13 1.302320e-014
Cn29an32a8 TDn29a15 TDn32a15 1.302320e-014
Cn29an32a9 TDn29a17 TDn32a17 1.302320e-014
Cn29an32a10 TDn29a19 TDn32a19 1.302320e-014
Cn29an32a11 TDn29a21 TDn32a21 1.302320e-014
Cn29an32a12 TDn29a23 TDn32a23 1.302320e-014
Cn29an32a13 TDn29a25 TDn32a25 1.302320e-014
Cn29an32a14 TDn29a27 TDn32a27 1.302320e-014
Cn29an32a15 TDn29a29 TDn32a29 1.302320e-014
Cn29an32a16 TDn29a31 TDn32a31 1.302320e-014
Cn29an32a17 TDn29a33 TDn32a33 1.690880e-014
Cn29anva1 TDn29a1 TDnva1 1.690880e-014
Cn29anva2 TDn29a3 TDnva3 1.690880e-014
Cn29anva3 TDn29a5 TDnva5 1.690880e-014
Cn29anva4 TDn29a7 TDnva7 1.690880e-014
Cn29anva5 TDn29a9 TDnva9 1.690880e-014
Cn29anva6 TDn29a11 TDnva11 1.690880e-014
Cn29anva7 TDn29a13 TDnva13 1.690880e-014
Cn29anva8 TDn29a15 TDnva15 1.690880e-014
Cn29anva9 TDn29a17 TDnva17 1.690880e-014
Cn29anva10 TDn29a19 TDnva19 1.690880e-014
Cn29anva11 TDn29a21 TDnva21 1.690880e-014
Cn29anva12 TDn29a23 TDnva23 1.690880e-014
Cn29anva13 TDn29a25 TDnva25 1.690880e-014
Cn29anva14 TDn29a27 TDnva27 1.690880e-014
Cn29anva15 TDn29a29 TDnva29 1.690880e-014
Cn29anva16 TDn29a31 TDnva31 1.690880e-014
Cn29anva17 TDn29a33 TDnva33 1.690880e-014
Cn30an31a1 TDn30a1 TDn31a1 1.690880e-014
Cn30an31a2 TDn30a3 TDn31a3 1.302320e-014
Cn30an31a3 TDn30a5 TDn31a5 1.302320e-014
Cn30an31a4 TDn30a7 TDn31a7 1.302320e-014
Cn30an31a5 TDn30a9 TDn31a9 1.302320e-014
Cn30an31a6 TDn30a11 TDn31a11 1.302320e-014
Cn30an31a7 TDn30a13 TDn31a13 1.302320e-014
Cn30an31a8 TDn30a15 TDn31a15 1.302320e-014
Cn30an31a9 TDn30a17 TDn31a17 1.302320e-014
Cn30an31a10 TDn30a19 TDn31a19 1.302320e-014
Cn30an31a11 TDn30a21 TDn31a21 1.302320e-014
Cn30an31a12 TDn30a23 TDn31a23 1.302320e-014
Cn30an31a13 TDn30a25 TDn31a25 1.302320e-014
Cn30an31a14 TDn30a27 TDn31a27 1.302320e-014
Cn30an31a15 TDn30a29 TDn31a29 1.302320e-014
Cn30an31a16 TDn30a31 TDn31a31 1.302320e-014
Cn30an31a17 TDn30a33 TDn31a33 1.690880e-014
Cn30an32a1 TDn30a1 TDn32a1 1.690880e-014
Cn30an32a2 TDn30a3 TDn32a3 1.302320e-014
Cn30an32a3 TDn30a5 TDn32a5 1.302320e-014
Cn30an32a4 TDn30a7 TDn32a7 1.302320e-014
Cn30an32a5 TDn30a9 TDn32a9 1.302320e-014
Cn30an32a6 TDn30a11 TDn32a11 1.302320e-014
Cn30an32a7 TDn30a13 TDn32a13 1.302320e-014
Cn30an32a8 TDn30a15 TDn32a15 1.302320e-014
Cn30an32a9 TDn30a17 TDn32a17 1.302320e-014
Cn30an32a10 TDn30a19 TDn32a19 1.302320e-014
Cn30an32a11 TDn30a21 TDn32a21 1.302320e-014
Cn30an32a12 TDn30a23 TDn32a23 1.302320e-014
Cn30an32a13 TDn30a25 TDn32a25 1.302320e-014
Cn30an32a14 TDn30a27 TDn32a27 1.302320e-014
Cn30an32a15 TDn30a29 TDn32a29 1.302320e-014
Cn30an32a16 TDn30a31 TDn32a31 1.302320e-014
Cn30an32a17 TDn30a33 TDn32a33 1.690880e-014
Cn30anva1 TDn30a1 TDnva1 1.690880e-014
Cn30anva2 TDn30a3 TDnva3 1.690880e-014
Cn30anva3 TDn30a5 TDnva5 1.690880e-014
Cn30anva4 TDn30a7 TDnva7 1.690880e-014
Cn30anva5 TDn30a9 TDnva9 1.690880e-014
Cn30anva6 TDn30a11 TDnva11 1.690880e-014
Cn30anva7 TDn30a13 TDnva13 1.690880e-014
Cn30anva8 TDn30a15 TDnva15 1.690880e-014
Cn30anva9 TDn30a17 TDnva17 1.690880e-014
Cn30anva10 TDn30a19 TDnva19 1.690880e-014
Cn30anva11 TDn30a21 TDnva21 1.690880e-014
Cn30anva12 TDn30a23 TDnva23 1.690880e-014
Cn30anva13 TDn30a25 TDnva25 1.690880e-014
Cn30anva14 TDn30a27 TDnva27 1.690880e-014
Cn30anva15 TDn30a29 TDnva29 1.690880e-014
Cn30anva16 TDn30a31 TDnva31 1.690880e-014
Cn30anva17 TDn30a33 TDnva33 1.690880e-014
Cn31an32a1 TDn31a1 TDn32a1 1.690880e-014
Cn31an32a2 TDn31a3 TDn32a3 1.302320e-014
Cn31an32a3 TDn31a5 TDn32a5 1.302320e-014
Cn31an32a4 TDn31a7 TDn32a7 1.302320e-014
Cn31an32a5 TDn31a9 TDn32a9 1.302320e-014
Cn31an32a6 TDn31a11 TDn32a11 1.302320e-014
Cn31an32a7 TDn31a13 TDn32a13 1.302320e-014
Cn31an32a8 TDn31a15 TDn32a15 1.302320e-014
Cn31an32a9 TDn31a17 TDn32a17 1.302320e-014
Cn31an32a10 TDn31a19 TDn32a19 1.302320e-014
Cn31an32a11 TDn31a21 TDn32a21 1.302320e-014
Cn31an32a12 TDn31a23 TDn32a23 1.302320e-014
Cn31an32a13 TDn31a25 TDn32a25 1.302320e-014
Cn31an32a14 TDn31a27 TDn32a27 1.302320e-014
Cn31an32a15 TDn31a29 TDn32a29 1.302320e-014
Cn31an32a16 TDn31a31 TDn32a31 1.302320e-014
Cn31an32a17 TDn31a33 TDn32a33 1.690880e-014
Cn31anva1 TDn31a1 TDnva1 1.690880e-014
Cn31anva2 TDn31a3 TDnva3 1.690880e-014
Cn31anva3 TDn31a5 TDnva5 1.690880e-014
Cn31anva4 TDn31a7 TDnva7 1.690880e-014
Cn31anva5 TDn31a9 TDnva9 1.690880e-014
Cn31anva6 TDn31a11 TDnva11 1.690880e-014
Cn31anva7 TDn31a13 TDnva13 1.690880e-014
Cn31anva8 TDn31a15 TDnva15 1.690880e-014
Cn31anva9 TDn31a17 TDnva17 1.690880e-014
Cn31anva10 TDn31a19 TDnva19 1.690880e-014
Cn31anva11 TDn31a21 TDnva21 1.690880e-014
Cn31anva12 TDn31a23 TDnva23 1.690880e-014
Cn31anva13 TDn31a25 TDnva25 1.690880e-014
Cn31anva14 TDn31a27 TDnva27 1.690880e-014
Cn31anva15 TDn31a29 TDnva29 1.690880e-014
Cn31anva16 TDn31a31 TDnva31 1.690880e-014
Cn31anva17 TDn31a33 TDnva33 1.690880e-014
Cn32anva1 TDn32a1 TDnva1 1.690880e-014
Cn32anva2 TDn32a3 TDnva3 1.690880e-014
Cn32anva3 TDn32a5 TDnva5 1.690880e-014
Cn32anva4 TDn32a7 TDnva7 1.690880e-014
Cn32anva5 TDn32a9 TDnva9 1.690880e-014
Cn32anva6 TDn32a11 TDnva11 1.690880e-014
Cn32anva7 TDn32a13 TDnva13 1.690880e-014
Cn32anva8 TDn32a15 TDnva15 1.690880e-014
Cn32anva9 TDn32a17 TDnva17 1.690880e-014
Cn32anva10 TDn32a19 TDnva19 1.690880e-014
Cn32anva11 TDn32a21 TDnva21 1.690880e-014
Cn32anva12 TDn32a23 TDnva23 1.690880e-014
Cn32anva13 TDn32a25 TDnva25 1.690880e-014
Cn32anva14 TDn32a27 TDnva27 1.690880e-014
Cn32anva15 TDn32a29 TDnva29 1.690880e-014
Cn32anva16 TDn32a31 TDnva31 1.690880e-014
Cn32anva17 TDn32a33 TDnva33 1.690880e-014
.ENDS intercon
*.output v<cout1>
*.op
*.AC LIN 1000 0 10G
.Tran 1e-11 3e-8
.probe  V(TDn1a9)  V(TDn2a9)  V(TDn3a9)  V(TDn4a9)  V(TDn5a9)  V(TDn6a9)  V(TDn7a9)  V(TDn8a9)  V(TDn9a9)  V(TDn10a9)  V(TDn11a9)  V(TDn12a9)  V(TDn13a9)  V(TDn14a9)  V(TDn15a9)  V(TDn16a9)  V(TDn17a9)  V(TDn18a9)  V(TDn19a9)  V(TDn20a9)  V(TDn21a9)  V(TDn22a9)  V(TDn23a9)  V(TDn24a9)  V(TDn25a9)  V(TDn26a9)  V(TDn27a9)  V(TDn28a9)  V(TDn29a9)  V(TDn30a9)  V(TDn31a9)  V(TDn32a9)  V(TDn32a1)  V(TDn31a1)  V(TDn30a1)  V(TDn29a1)  V(TDn28a1)  V(TDn27a1)  V(TDn26a1)  V(TDn25a1)  V(TDn24a1)  V(TDn23a1)  V(TDn22a1)  V(TDn21a1)  V(TDn20a1)  V(TDn19a1)  V(TDn18a1)  V(TDn17a1)  V(TDn16a1)  V(TDn15a1)  V(TDn14a1)  V(TDn13a1)  V(TDn12a1)  V(TDn11a1)  V(TDn10a1)  V(TDn9a1)  V(TDn8a1)  V(TDn7a1)  V(TDn6a1)  V(TDn5a1)  V(TDn4a1)  V(TDn3a1)  V(TDn2a1)  V(TDn1a1)
.print  V(TDn1a9)  V(TDn2a9)  V(TDn3a9)  V(TDn4a9)  V(TDn5a9)  V(TDn6a9)  V(TDn7a9)  V(TDn8a9)  V(TDn9a9)  V(TDn10a9)  V(TDn11a9)  V(TDn12a9)  V(TDn13a9)  V(TDn14a9)  V(TDn15a9)  V(TDn16a9)  V(TDn17a9)  V(TDn18a9)  V(TDn19a9)  V(TDn20a9)  V(TDn21a9)  V(TDn22a9)  V(TDn23a9)  V(TDn24a9)  V(TDn25a9)  V(TDn26a9)  V(TDn27a9)  V(TDn28a9)  V(TDn29a9)  V(TDn30a9)  V(TDn31a9)  V(TDn32a9)  V(TDn32a1)  V(TDn31a1)  V(TDn30a1)  V(TDn29a1)  V(TDn28a1)  V(TDn27a1)  V(TDn26a1)  V(TDn25a1)  V(TDn24a1)  V(TDn23a1)  V(TDn22a1)  V(TDn21a1)  V(TDn20a1)  V(TDn19a1)  V(TDn18a1)  V(TDn17a1)  V(TDn16a1)  V(TDn15a1)  V(TDn14a1)  V(TDn13a1)  V(TDn12a1)  V(TDn11a1)  V(TDn10a1)  V(TDn9a1)  V(TDn8a1)  V(TDn7a1)  V(TDn6a1)  V(TDn5a1)  V(TDn4a1)  V(TDn3a1)  V(TDn2a1)  V(TDn1a1)
.end
