A RLC tree, level=7

V1 n0_1 0 AC 1

Rn1_1_1 n0_1 n1_1_1 3.000000e-001
Ln1_1_1 n1_1_1 n1_1_2 2.000000e-009
Cn1_1_1 n1_1_2 0 5.000000e-013
Rn1_1_2 n1_1_2 n1_1_3 3.000000e-001
Ln1_1_2 n1_1_3 n1_1_4 2.000000e-009
Cn1_1_2 n1_1_4 0 5.000000e-013
Rn1_1_3 n1_1_4 n1_1_5 3.000000e-001
Ln1_1_3 n1_1_5 n1_1_6 2.000000e-009
Cn1_1_3 n1_1_6 0 5.000000e-013
Rn1_1_4 n1_1_6 n1_1_7 3.000000e-001
Ln1_1_4 n1_1_7 n1_1 2.000000e-009
Cn1_1_4 n1_1 0 5.000000e-013

Rn2_1_1 n1_1 n2_1_1 3.000000e-001
Ln2_1_1 n2_1_1 n2_1_2 2.000000e-009
Cn2_1_1 n2_1_2 0 5.000000e-013
Rn2_1_2 n2_1_2 n2_1_3 3.000000e-001
Ln2_1_2 n2_1_3 n2_1_4 2.000000e-009
Cn2_1_2 n2_1_4 0 5.000000e-013
Rn2_1_3 n2_1_4 n2_1_5 3.000000e-001
Ln2_1_3 n2_1_5 n2_1_6 2.000000e-009
Cn2_1_3 n2_1_6 0 5.000000e-013
Rn2_1_4 n2_1_6 n2_1_7 3.000000e-001
Ln2_1_4 n2_1_7 n2_1 2.000000e-009
Cn2_1_4 n2_1 0 5.000000e-013

Rn2_2_1 n1_1 n2_2_1 3.000000e-001
Ln2_2_1 n2_2_1 n2_2_2 2.000000e-009
Cn2_2_1 n2_2_2 0 5.000000e-013
Rn2_2_2 n2_2_2 n2_2_3 3.000000e-001
Ln2_2_2 n2_2_3 n2_2_4 2.000000e-009
Cn2_2_2 n2_2_4 0 5.000000e-013
Rn2_2_3 n2_2_4 n2_2_5 3.000000e-001
Ln2_2_3 n2_2_5 n2_2_6 2.000000e-009
Cn2_2_3 n2_2_6 0 5.000000e-013
Rn2_2_4 n2_2_6 n2_2_7 3.000000e-001
Ln2_2_4 n2_2_7 n2_2 2.000000e-009
Cn2_2_4 n2_2 0 5.000000e-013

Rn3_1_1 n2_1 n3_1_1 3.000000e-001
Ln3_1_1 n3_1_1 n3_1_2 2.000000e-009
Cn3_1_1 n3_1_2 0 5.000000e-013
Rn3_1_2 n3_1_2 n3_1_3 3.000000e-001
Ln3_1_2 n3_1_3 n3_1_4 2.000000e-009
Cn3_1_2 n3_1_4 0 5.000000e-013
Rn3_1_3 n3_1_4 n3_1_5 3.000000e-001
Ln3_1_3 n3_1_5 n3_1_6 2.000000e-009
Cn3_1_3 n3_1_6 0 5.000000e-013
Rn3_1_4 n3_1_6 n3_1_7 3.000000e-001
Ln3_1_4 n3_1_7 n3_1 2.000000e-009
Cn3_1_4 n3_1 0 5.000000e-013

Rn3_2_1 n2_1 n3_2_1 3.000000e-001
Ln3_2_1 n3_2_1 n3_2_2 2.000000e-009
Cn3_2_1 n3_2_2 0 5.000000e-013
Rn3_2_2 n3_2_2 n3_2_3 3.000000e-001
Ln3_2_2 n3_2_3 n3_2_4 2.000000e-009
Cn3_2_2 n3_2_4 0 5.000000e-013
Rn3_2_3 n3_2_4 n3_2_5 3.000000e-001
Ln3_2_3 n3_2_5 n3_2_6 2.000000e-009
Cn3_2_3 n3_2_6 0 5.000000e-013
Rn3_2_4 n3_2_6 n3_2_7 3.000000e-001
Ln3_2_4 n3_2_7 n3_2 2.000000e-009
Cn3_2_4 n3_2 0 5.000000e-013

Rn3_3_1 n2_2 n3_3_1 3.000000e-001
Ln3_3_1 n3_3_1 n3_3_2 2.000000e-009
Cn3_3_1 n3_3_2 0 5.000000e-013
Rn3_3_2 n3_3_2 n3_3_3 3.000000e-001
Ln3_3_2 n3_3_3 n3_3_4 2.000000e-009
Cn3_3_2 n3_3_4 0 5.000000e-013
Rn3_3_3 n3_3_4 n3_3_5 3.000000e-001
Ln3_3_3 n3_3_5 n3_3_6 2.000000e-009
Cn3_3_3 n3_3_6 0 5.000000e-013
Rn3_3_4 n3_3_6 n3_3_7 3.000000e-001
Ln3_3_4 n3_3_7 n3_3 2.000000e-009
Cn3_3_4 n3_3 0 5.000000e-013

Rn3_4_1 n2_2 n3_4_1 3.000000e-001
Ln3_4_1 n3_4_1 n3_4_2 2.000000e-009
Cn3_4_1 n3_4_2 0 5.000000e-013
Rn3_4_2 n3_4_2 n3_4_3 3.000000e-001
Ln3_4_2 n3_4_3 n3_4_4 2.000000e-009
Cn3_4_2 n3_4_4 0 5.000000e-013
Rn3_4_3 n3_4_4 n3_4_5 3.000000e-001
Ln3_4_3 n3_4_5 n3_4_6 2.000000e-009
Cn3_4_3 n3_4_6 0 5.000000e-013
Rn3_4_4 n3_4_6 n3_4_7 3.000000e-001
Ln3_4_4 n3_4_7 n3_4 2.000000e-009
Cn3_4_4 n3_4 0 5.000000e-013

Rn4_1_1 n3_1 n4_1_1 3.000000e-001
Ln4_1_1 n4_1_1 n4_1_2 2.000000e-009
Cn4_1_1 n4_1_2 0 5.000000e-013
Rn4_1_2 n4_1_2 n4_1_3 3.000000e-001
Ln4_1_2 n4_1_3 n4_1_4 2.000000e-009
Cn4_1_2 n4_1_4 0 5.000000e-013
Rn4_1_3 n4_1_4 n4_1_5 3.000000e-001
Ln4_1_3 n4_1_5 n4_1_6 2.000000e-009
Cn4_1_3 n4_1_6 0 5.000000e-013
Rn4_1_4 n4_1_6 n4_1_7 3.000000e-001
Ln4_1_4 n4_1_7 n4_1 2.000000e-009
Cn4_1_4 n4_1 0 5.000000e-013

Rn4_2_1 n3_1 n4_2_1 3.000000e-001
Ln4_2_1 n4_2_1 n4_2_2 2.000000e-009
Cn4_2_1 n4_2_2 0 5.000000e-013
Rn4_2_2 n4_2_2 n4_2_3 3.000000e-001
Ln4_2_2 n4_2_3 n4_2_4 2.000000e-009
Cn4_2_2 n4_2_4 0 5.000000e-013
Rn4_2_3 n4_2_4 n4_2_5 3.000000e-001
Ln4_2_3 n4_2_5 n4_2_6 2.000000e-009
Cn4_2_3 n4_2_6 0 5.000000e-013
Rn4_2_4 n4_2_6 n4_2_7 3.000000e-001
Ln4_2_4 n4_2_7 n4_2 2.000000e-009
Cn4_2_4 n4_2 0 5.000000e-013

Rn4_3_1 n3_2 n4_3_1 3.000000e-001
Ln4_3_1 n4_3_1 n4_3_2 2.000000e-009
Cn4_3_1 n4_3_2 0 5.000000e-013
Rn4_3_2 n4_3_2 n4_3_3 3.000000e-001
Ln4_3_2 n4_3_3 n4_3_4 2.000000e-009
Cn4_3_2 n4_3_4 0 5.000000e-013
Rn4_3_3 n4_3_4 n4_3_5 3.000000e-001
Ln4_3_3 n4_3_5 n4_3_6 2.000000e-009
Cn4_3_3 n4_3_6 0 5.000000e-013
Rn4_3_4 n4_3_6 n4_3_7 3.000000e-001
Ln4_3_4 n4_3_7 n4_3 2.000000e-009
Cn4_3_4 n4_3 0 5.000000e-013

Rn4_4_1 n3_2 n4_4_1 3.000000e-001
Ln4_4_1 n4_4_1 n4_4_2 2.000000e-009
Cn4_4_1 n4_4_2 0 5.000000e-013
Rn4_4_2 n4_4_2 n4_4_3 3.000000e-001
Ln4_4_2 n4_4_3 n4_4_4 2.000000e-009
Cn4_4_2 n4_4_4 0 5.000000e-013
Rn4_4_3 n4_4_4 n4_4_5 3.000000e-001
Ln4_4_3 n4_4_5 n4_4_6 2.000000e-009
Cn4_4_3 n4_4_6 0 5.000000e-013
Rn4_4_4 n4_4_6 n4_4_7 3.000000e-001
Ln4_4_4 n4_4_7 n4_4 2.000000e-009
Cn4_4_4 n4_4 0 5.000000e-013

Rn4_5_1 n3_3 n4_5_1 3.000000e-001
Ln4_5_1 n4_5_1 n4_5_2 2.000000e-009
Cn4_5_1 n4_5_2 0 5.000000e-013
Rn4_5_2 n4_5_2 n4_5_3 3.000000e-001
Ln4_5_2 n4_5_3 n4_5_4 2.000000e-009
Cn4_5_2 n4_5_4 0 5.000000e-013
Rn4_5_3 n4_5_4 n4_5_5 3.000000e-001
Ln4_5_3 n4_5_5 n4_5_6 2.000000e-009
Cn4_5_3 n4_5_6 0 5.000000e-013
Rn4_5_4 n4_5_6 n4_5_7 3.000000e-001
Ln4_5_4 n4_5_7 n4_5 2.000000e-009
Cn4_5_4 n4_5 0 5.000000e-013

Rn4_6_1 n3_3 n4_6_1 3.000000e-001
Ln4_6_1 n4_6_1 n4_6_2 2.000000e-009
Cn4_6_1 n4_6_2 0 5.000000e-013
Rn4_6_2 n4_6_2 n4_6_3 3.000000e-001
Ln4_6_2 n4_6_3 n4_6_4 2.000000e-009
Cn4_6_2 n4_6_4 0 5.000000e-013
Rn4_6_3 n4_6_4 n4_6_5 3.000000e-001
Ln4_6_3 n4_6_5 n4_6_6 2.000000e-009
Cn4_6_3 n4_6_6 0 5.000000e-013
Rn4_6_4 n4_6_6 n4_6_7 3.000000e-001
Ln4_6_4 n4_6_7 n4_6 2.000000e-009
Cn4_6_4 n4_6 0 5.000000e-013

Rn4_7_1 n3_4 n4_7_1 3.000000e-001
Ln4_7_1 n4_7_1 n4_7_2 2.000000e-009
Cn4_7_1 n4_7_2 0 5.000000e-013
Rn4_7_2 n4_7_2 n4_7_3 3.000000e-001
Ln4_7_2 n4_7_3 n4_7_4 2.000000e-009
Cn4_7_2 n4_7_4 0 5.000000e-013
Rn4_7_3 n4_7_4 n4_7_5 3.000000e-001
Ln4_7_3 n4_7_5 n4_7_6 2.000000e-009
Cn4_7_3 n4_7_6 0 5.000000e-013
Rn4_7_4 n4_7_6 n4_7_7 3.000000e-001
Ln4_7_4 n4_7_7 n4_7 2.000000e-009
Cn4_7_4 n4_7 0 5.000000e-013

Rn4_8_1 n3_4 n4_8_1 3.000000e-001
Ln4_8_1 n4_8_1 n4_8_2 2.000000e-009
Cn4_8_1 n4_8_2 0 5.000000e-013
Rn4_8_2 n4_8_2 n4_8_3 3.000000e-001
Ln4_8_2 n4_8_3 n4_8_4 2.000000e-009
Cn4_8_2 n4_8_4 0 5.000000e-013
Rn4_8_3 n4_8_4 n4_8_5 3.000000e-001
Ln4_8_3 n4_8_5 n4_8_6 2.000000e-009
Cn4_8_3 n4_8_6 0 5.000000e-013
Rn4_8_4 n4_8_6 n4_8_7 3.000000e-001
Ln4_8_4 n4_8_7 n4_8 2.000000e-009
Cn4_8_4 n4_8 0 5.000000e-013

Rn5_1_1 n4_1 n5_1_1 3.000000e-001
Ln5_1_1 n5_1_1 n5_1_2 2.000000e-009
Cn5_1_1 n5_1_2 0 5.000000e-013
Rn5_1_2 n5_1_2 n5_1_3 3.000000e-001
Ln5_1_2 n5_1_3 n5_1_4 2.000000e-009
Cn5_1_2 n5_1_4 0 5.000000e-013
Rn5_1_3 n5_1_4 n5_1_5 3.000000e-001
Ln5_1_3 n5_1_5 n5_1_6 2.000000e-009
Cn5_1_3 n5_1_6 0 5.000000e-013
Rn5_1_4 n5_1_6 n5_1_7 3.000000e-001
Ln5_1_4 n5_1_7 n5_1 2.000000e-009
Cn5_1_4 n5_1 0 5.000000e-013

Rn5_2_1 n4_1 n5_2_1 3.000000e-001
Ln5_2_1 n5_2_1 n5_2_2 2.000000e-009
Cn5_2_1 n5_2_2 0 5.000000e-013
Rn5_2_2 n5_2_2 n5_2_3 3.000000e-001
Ln5_2_2 n5_2_3 n5_2_4 2.000000e-009
Cn5_2_2 n5_2_4 0 5.000000e-013
Rn5_2_3 n5_2_4 n5_2_5 3.000000e-001
Ln5_2_3 n5_2_5 n5_2_6 2.000000e-009
Cn5_2_3 n5_2_6 0 5.000000e-013
Rn5_2_4 n5_2_6 n5_2_7 3.000000e-001
Ln5_2_4 n5_2_7 n5_2 2.000000e-009
Cn5_2_4 n5_2 0 5.000000e-013

Rn5_3_1 n4_2 n5_3_1 3.000000e-001
Ln5_3_1 n5_3_1 n5_3_2 2.000000e-009
Cn5_3_1 n5_3_2 0 5.000000e-013
Rn5_3_2 n5_3_2 n5_3_3 3.000000e-001
Ln5_3_2 n5_3_3 n5_3_4 2.000000e-009
Cn5_3_2 n5_3_4 0 5.000000e-013
Rn5_3_3 n5_3_4 n5_3_5 3.000000e-001
Ln5_3_3 n5_3_5 n5_3_6 2.000000e-009
Cn5_3_3 n5_3_6 0 5.000000e-013
Rn5_3_4 n5_3_6 n5_3_7 3.000000e-001
Ln5_3_4 n5_3_7 n5_3 2.000000e-009
Cn5_3_4 n5_3 0 5.000000e-013

Rn5_4_1 n4_2 n5_4_1 3.000000e-001
Ln5_4_1 n5_4_1 n5_4_2 2.000000e-009
Cn5_4_1 n5_4_2 0 5.000000e-013
Rn5_4_2 n5_4_2 n5_4_3 3.000000e-001
Ln5_4_2 n5_4_3 n5_4_4 2.000000e-009
Cn5_4_2 n5_4_4 0 5.000000e-013
Rn5_4_3 n5_4_4 n5_4_5 3.000000e-001
Ln5_4_3 n5_4_5 n5_4_6 2.000000e-009
Cn5_4_3 n5_4_6 0 5.000000e-013
Rn5_4_4 n5_4_6 n5_4_7 3.000000e-001
Ln5_4_4 n5_4_7 n5_4 2.000000e-009
Cn5_4_4 n5_4 0 5.000000e-013

Rn5_5_1 n4_3 n5_5_1 3.000000e-001
Ln5_5_1 n5_5_1 n5_5_2 2.000000e-009
Cn5_5_1 n5_5_2 0 5.000000e-013
Rn5_5_2 n5_5_2 n5_5_3 3.000000e-001
Ln5_5_2 n5_5_3 n5_5_4 2.000000e-009
Cn5_5_2 n5_5_4 0 5.000000e-013
Rn5_5_3 n5_5_4 n5_5_5 3.000000e-001
Ln5_5_3 n5_5_5 n5_5_6 2.000000e-009
Cn5_5_3 n5_5_6 0 5.000000e-013
Rn5_5_4 n5_5_6 n5_5_7 3.000000e-001
Ln5_5_4 n5_5_7 n5_5 2.000000e-009
Cn5_5_4 n5_5 0 5.000000e-013

Rn5_6_1 n4_3 n5_6_1 3.000000e-001
Ln5_6_1 n5_6_1 n5_6_2 2.000000e-009
Cn5_6_1 n5_6_2 0 5.000000e-013
Rn5_6_2 n5_6_2 n5_6_3 3.000000e-001
Ln5_6_2 n5_6_3 n5_6_4 2.000000e-009
Cn5_6_2 n5_6_4 0 5.000000e-013
Rn5_6_3 n5_6_4 n5_6_5 3.000000e-001
Ln5_6_3 n5_6_5 n5_6_6 2.000000e-009
Cn5_6_3 n5_6_6 0 5.000000e-013
Rn5_6_4 n5_6_6 n5_6_7 3.000000e-001
Ln5_6_4 n5_6_7 n5_6 2.000000e-009
Cn5_6_4 n5_6 0 5.000000e-013

Rn5_7_1 n4_4 n5_7_1 3.000000e-001
Ln5_7_1 n5_7_1 n5_7_2 2.000000e-009
Cn5_7_1 n5_7_2 0 5.000000e-013
Rn5_7_2 n5_7_2 n5_7_3 3.000000e-001
Ln5_7_2 n5_7_3 n5_7_4 2.000000e-009
Cn5_7_2 n5_7_4 0 5.000000e-013
Rn5_7_3 n5_7_4 n5_7_5 3.000000e-001
Ln5_7_3 n5_7_5 n5_7_6 2.000000e-009
Cn5_7_3 n5_7_6 0 5.000000e-013
Rn5_7_4 n5_7_6 n5_7_7 3.000000e-001
Ln5_7_4 n5_7_7 n5_7 2.000000e-009
Cn5_7_4 n5_7 0 5.000000e-013

Rn5_8_1 n4_4 n5_8_1 3.000000e-001
Ln5_8_1 n5_8_1 n5_8_2 2.000000e-009
Cn5_8_1 n5_8_2 0 5.000000e-013
Rn5_8_2 n5_8_2 n5_8_3 3.000000e-001
Ln5_8_2 n5_8_3 n5_8_4 2.000000e-009
Cn5_8_2 n5_8_4 0 5.000000e-013
Rn5_8_3 n5_8_4 n5_8_5 3.000000e-001
Ln5_8_3 n5_8_5 n5_8_6 2.000000e-009
Cn5_8_3 n5_8_6 0 5.000000e-013
Rn5_8_4 n5_8_6 n5_8_7 3.000000e-001
Ln5_8_4 n5_8_7 n5_8 2.000000e-009
Cn5_8_4 n5_8 0 5.000000e-013

Rn5_9_1 n4_5 n5_9_1 3.000000e-001
Ln5_9_1 n5_9_1 n5_9_2 2.000000e-009
Cn5_9_1 n5_9_2 0 5.000000e-013
Rn5_9_2 n5_9_2 n5_9_3 3.000000e-001
Ln5_9_2 n5_9_3 n5_9_4 2.000000e-009
Cn5_9_2 n5_9_4 0 5.000000e-013
Rn5_9_3 n5_9_4 n5_9_5 3.000000e-001
Ln5_9_3 n5_9_5 n5_9_6 2.000000e-009
Cn5_9_3 n5_9_6 0 5.000000e-013
Rn5_9_4 n5_9_6 n5_9_7 3.000000e-001
Ln5_9_4 n5_9_7 n5_9 2.000000e-009
Cn5_9_4 n5_9 0 5.000000e-013

Rn5_10_1 n4_5 n5_10_1 3.000000e-001
Ln5_10_1 n5_10_1 n5_10_2 2.000000e-009
Cn5_10_1 n5_10_2 0 5.000000e-013
Rn5_10_2 n5_10_2 n5_10_3 3.000000e-001
Ln5_10_2 n5_10_3 n5_10_4 2.000000e-009
Cn5_10_2 n5_10_4 0 5.000000e-013
Rn5_10_3 n5_10_4 n5_10_5 3.000000e-001
Ln5_10_3 n5_10_5 n5_10_6 2.000000e-009
Cn5_10_3 n5_10_6 0 5.000000e-013
Rn5_10_4 n5_10_6 n5_10_7 3.000000e-001
Ln5_10_4 n5_10_7 n5_10 2.000000e-009
Cn5_10_4 n5_10 0 5.000000e-013

Rn5_11_1 n4_6 n5_11_1 3.000000e-001
Ln5_11_1 n5_11_1 n5_11_2 2.000000e-009
Cn5_11_1 n5_11_2 0 5.000000e-013
Rn5_11_2 n5_11_2 n5_11_3 3.000000e-001
Ln5_11_2 n5_11_3 n5_11_4 2.000000e-009
Cn5_11_2 n5_11_4 0 5.000000e-013
Rn5_11_3 n5_11_4 n5_11_5 3.000000e-001
Ln5_11_3 n5_11_5 n5_11_6 2.000000e-009
Cn5_11_3 n5_11_6 0 5.000000e-013
Rn5_11_4 n5_11_6 n5_11_7 3.000000e-001
Ln5_11_4 n5_11_7 n5_11 2.000000e-009
Cn5_11_4 n5_11 0 5.000000e-013

Rn5_12_1 n4_6 n5_12_1 3.000000e-001
Ln5_12_1 n5_12_1 n5_12_2 2.000000e-009
Cn5_12_1 n5_12_2 0 5.000000e-013
Rn5_12_2 n5_12_2 n5_12_3 3.000000e-001
Ln5_12_2 n5_12_3 n5_12_4 2.000000e-009
Cn5_12_2 n5_12_4 0 5.000000e-013
Rn5_12_3 n5_12_4 n5_12_5 3.000000e-001
Ln5_12_3 n5_12_5 n5_12_6 2.000000e-009
Cn5_12_3 n5_12_6 0 5.000000e-013
Rn5_12_4 n5_12_6 n5_12_7 3.000000e-001
Ln5_12_4 n5_12_7 n5_12 2.000000e-009
Cn5_12_4 n5_12 0 5.000000e-013

Rn5_13_1 n4_7 n5_13_1 3.000000e-001
Ln5_13_1 n5_13_1 n5_13_2 2.000000e-009
Cn5_13_1 n5_13_2 0 5.000000e-013
Rn5_13_2 n5_13_2 n5_13_3 3.000000e-001
Ln5_13_2 n5_13_3 n5_13_4 2.000000e-009
Cn5_13_2 n5_13_4 0 5.000000e-013
Rn5_13_3 n5_13_4 n5_13_5 3.000000e-001
Ln5_13_3 n5_13_5 n5_13_6 2.000000e-009
Cn5_13_3 n5_13_6 0 5.000000e-013
Rn5_13_4 n5_13_6 n5_13_7 3.000000e-001
Ln5_13_4 n5_13_7 n5_13 2.000000e-009
Cn5_13_4 n5_13 0 5.000000e-013

Rn5_14_1 n4_7 n5_14_1 3.000000e-001
Ln5_14_1 n5_14_1 n5_14_2 2.000000e-009
Cn5_14_1 n5_14_2 0 5.000000e-013
Rn5_14_2 n5_14_2 n5_14_3 3.000000e-001
Ln5_14_2 n5_14_3 n5_14_4 2.000000e-009
Cn5_14_2 n5_14_4 0 5.000000e-013
Rn5_14_3 n5_14_4 n5_14_5 3.000000e-001
Ln5_14_3 n5_14_5 n5_14_6 2.000000e-009
Cn5_14_3 n5_14_6 0 5.000000e-013
Rn5_14_4 n5_14_6 n5_14_7 3.000000e-001
Ln5_14_4 n5_14_7 n5_14 2.000000e-009
Cn5_14_4 n5_14 0 5.000000e-013

Rn5_15_1 n4_8 n5_15_1 3.000000e-001
Ln5_15_1 n5_15_1 n5_15_2 2.000000e-009
Cn5_15_1 n5_15_2 0 5.000000e-013
Rn5_15_2 n5_15_2 n5_15_3 3.000000e-001
Ln5_15_2 n5_15_3 n5_15_4 2.000000e-009
Cn5_15_2 n5_15_4 0 5.000000e-013
Rn5_15_3 n5_15_4 n5_15_5 3.000000e-001
Ln5_15_3 n5_15_5 n5_15_6 2.000000e-009
Cn5_15_3 n5_15_6 0 5.000000e-013
Rn5_15_4 n5_15_6 n5_15_7 3.000000e-001
Ln5_15_4 n5_15_7 n5_15 2.000000e-009
Cn5_15_4 n5_15 0 5.000000e-013

Rn5_16_1 n4_8 n5_16_1 3.000000e-001
Ln5_16_1 n5_16_1 n5_16_2 2.000000e-009
Cn5_16_1 n5_16_2 0 5.000000e-013
Rn5_16_2 n5_16_2 n5_16_3 3.000000e-001
Ln5_16_2 n5_16_3 n5_16_4 2.000000e-009
Cn5_16_2 n5_16_4 0 5.000000e-013
Rn5_16_3 n5_16_4 n5_16_5 3.000000e-001
Ln5_16_3 n5_16_5 n5_16_6 2.000000e-009
Cn5_16_3 n5_16_6 0 5.000000e-013
Rn5_16_4 n5_16_6 n5_16_7 3.000000e-001
Ln5_16_4 n5_16_7 n5_16 2.000000e-009
Cn5_16_4 n5_16 0 5.000000e-013

Rn6_1_1 n5_1 n6_1_1 3.000000e-001
Ln6_1_1 n6_1_1 n6_1_2 2.000000e-009
Cn6_1_1 n6_1_2 0 5.000000e-013
Rn6_1_2 n6_1_2 n6_1_3 3.000000e-001
Ln6_1_2 n6_1_3 n6_1_4 2.000000e-009
Cn6_1_2 n6_1_4 0 5.000000e-013
Rn6_1_3 n6_1_4 n6_1_5 3.000000e-001
Ln6_1_3 n6_1_5 n6_1_6 2.000000e-009
Cn6_1_3 n6_1_6 0 5.000000e-013
Rn6_1_4 n6_1_6 n6_1_7 3.000000e-001
Ln6_1_4 n6_1_7 n6_1 2.000000e-009
Cn6_1_4 n6_1 0 5.000000e-013

Rn6_2_1 n5_1 n6_2_1 3.000000e-001
Ln6_2_1 n6_2_1 n6_2_2 2.000000e-009
Cn6_2_1 n6_2_2 0 5.000000e-013
Rn6_2_2 n6_2_2 n6_2_3 3.000000e-001
Ln6_2_2 n6_2_3 n6_2_4 2.000000e-009
Cn6_2_2 n6_2_4 0 5.000000e-013
Rn6_2_3 n6_2_4 n6_2_5 3.000000e-001
Ln6_2_3 n6_2_5 n6_2_6 2.000000e-009
Cn6_2_3 n6_2_6 0 5.000000e-013
Rn6_2_4 n6_2_6 n6_2_7 3.000000e-001
Ln6_2_4 n6_2_7 n6_2 2.000000e-009
Cn6_2_4 n6_2 0 5.000000e-013

Rn6_3_1 n5_2 n6_3_1 3.000000e-001
Ln6_3_1 n6_3_1 n6_3_2 2.000000e-009
Cn6_3_1 n6_3_2 0 5.000000e-013
Rn6_3_2 n6_3_2 n6_3_3 3.000000e-001
Ln6_3_2 n6_3_3 n6_3_4 2.000000e-009
Cn6_3_2 n6_3_4 0 5.000000e-013
Rn6_3_3 n6_3_4 n6_3_5 3.000000e-001
Ln6_3_3 n6_3_5 n6_3_6 2.000000e-009
Cn6_3_3 n6_3_6 0 5.000000e-013
Rn6_3_4 n6_3_6 n6_3_7 3.000000e-001
Ln6_3_4 n6_3_7 n6_3 2.000000e-009
Cn6_3_4 n6_3 0 5.000000e-013

Rn6_4_1 n5_2 n6_4_1 3.000000e-001
Ln6_4_1 n6_4_1 n6_4_2 2.000000e-009
Cn6_4_1 n6_4_2 0 5.000000e-013
Rn6_4_2 n6_4_2 n6_4_3 3.000000e-001
Ln6_4_2 n6_4_3 n6_4_4 2.000000e-009
Cn6_4_2 n6_4_4 0 5.000000e-013
Rn6_4_3 n6_4_4 n6_4_5 3.000000e-001
Ln6_4_3 n6_4_5 n6_4_6 2.000000e-009
Cn6_4_3 n6_4_6 0 5.000000e-013
Rn6_4_4 n6_4_6 n6_4_7 3.000000e-001
Ln6_4_4 n6_4_7 n6_4 2.000000e-009
Cn6_4_4 n6_4 0 5.000000e-013

Rn6_5_1 n5_3 n6_5_1 3.000000e-001
Ln6_5_1 n6_5_1 n6_5_2 2.000000e-009
Cn6_5_1 n6_5_2 0 5.000000e-013
Rn6_5_2 n6_5_2 n6_5_3 3.000000e-001
Ln6_5_2 n6_5_3 n6_5_4 2.000000e-009
Cn6_5_2 n6_5_4 0 5.000000e-013
Rn6_5_3 n6_5_4 n6_5_5 3.000000e-001
Ln6_5_3 n6_5_5 n6_5_6 2.000000e-009
Cn6_5_3 n6_5_6 0 5.000000e-013
Rn6_5_4 n6_5_6 n6_5_7 3.000000e-001
Ln6_5_4 n6_5_7 n6_5 2.000000e-009
Cn6_5_4 n6_5 0 5.000000e-013

Rn6_6_1 n5_3 n6_6_1 3.000000e-001
Ln6_6_1 n6_6_1 n6_6_2 2.000000e-009
Cn6_6_1 n6_6_2 0 5.000000e-013
Rn6_6_2 n6_6_2 n6_6_3 3.000000e-001
Ln6_6_2 n6_6_3 n6_6_4 2.000000e-009
Cn6_6_2 n6_6_4 0 5.000000e-013
Rn6_6_3 n6_6_4 n6_6_5 3.000000e-001
Ln6_6_3 n6_6_5 n6_6_6 2.000000e-009
Cn6_6_3 n6_6_6 0 5.000000e-013
Rn6_6_4 n6_6_6 n6_6_7 3.000000e-001
Ln6_6_4 n6_6_7 n6_6 2.000000e-009
Cn6_6_4 n6_6 0 5.000000e-013

Rn6_7_1 n5_4 n6_7_1 3.000000e-001
Ln6_7_1 n6_7_1 n6_7_2 2.000000e-009
Cn6_7_1 n6_7_2 0 5.000000e-013
Rn6_7_2 n6_7_2 n6_7_3 3.000000e-001
Ln6_7_2 n6_7_3 n6_7_4 2.000000e-009
Cn6_7_2 n6_7_4 0 5.000000e-013
Rn6_7_3 n6_7_4 n6_7_5 3.000000e-001
Ln6_7_3 n6_7_5 n6_7_6 2.000000e-009
Cn6_7_3 n6_7_6 0 5.000000e-013
Rn6_7_4 n6_7_6 n6_7_7 3.000000e-001
Ln6_7_4 n6_7_7 n6_7 2.000000e-009
Cn6_7_4 n6_7 0 5.000000e-013

Rn6_8_1 n5_4 n6_8_1 3.000000e-001
Ln6_8_1 n6_8_1 n6_8_2 2.000000e-009
Cn6_8_1 n6_8_2 0 5.000000e-013
Rn6_8_2 n6_8_2 n6_8_3 3.000000e-001
Ln6_8_2 n6_8_3 n6_8_4 2.000000e-009
Cn6_8_2 n6_8_4 0 5.000000e-013
Rn6_8_3 n6_8_4 n6_8_5 3.000000e-001
Ln6_8_3 n6_8_5 n6_8_6 2.000000e-009
Cn6_8_3 n6_8_6 0 5.000000e-013
Rn6_8_4 n6_8_6 n6_8_7 3.000000e-001
Ln6_8_4 n6_8_7 n6_8 2.000000e-009
Cn6_8_4 n6_8 0 5.000000e-013

Rn6_9_1 n5_5 n6_9_1 3.000000e-001
Ln6_9_1 n6_9_1 n6_9_2 2.000000e-009
Cn6_9_1 n6_9_2 0 5.000000e-013
Rn6_9_2 n6_9_2 n6_9_3 3.000000e-001
Ln6_9_2 n6_9_3 n6_9_4 2.000000e-009
Cn6_9_2 n6_9_4 0 5.000000e-013
Rn6_9_3 n6_9_4 n6_9_5 3.000000e-001
Ln6_9_3 n6_9_5 n6_9_6 2.000000e-009
Cn6_9_3 n6_9_6 0 5.000000e-013
Rn6_9_4 n6_9_6 n6_9_7 3.000000e-001
Ln6_9_4 n6_9_7 n6_9 2.000000e-009
Cn6_9_4 n6_9 0 5.000000e-013

Rn6_10_1 n5_5 n6_10_1 3.000000e-001
Ln6_10_1 n6_10_1 n6_10_2 2.000000e-009
Cn6_10_1 n6_10_2 0 5.000000e-013
Rn6_10_2 n6_10_2 n6_10_3 3.000000e-001
Ln6_10_2 n6_10_3 n6_10_4 2.000000e-009
Cn6_10_2 n6_10_4 0 5.000000e-013
Rn6_10_3 n6_10_4 n6_10_5 3.000000e-001
Ln6_10_3 n6_10_5 n6_10_6 2.000000e-009
Cn6_10_3 n6_10_6 0 5.000000e-013
Rn6_10_4 n6_10_6 n6_10_7 3.000000e-001
Ln6_10_4 n6_10_7 n6_10 2.000000e-009
Cn6_10_4 n6_10 0 5.000000e-013

Rn6_11_1 n5_6 n6_11_1 3.000000e-001
Ln6_11_1 n6_11_1 n6_11_2 2.000000e-009
Cn6_11_1 n6_11_2 0 5.000000e-013
Rn6_11_2 n6_11_2 n6_11_3 3.000000e-001
Ln6_11_2 n6_11_3 n6_11_4 2.000000e-009
Cn6_11_2 n6_11_4 0 5.000000e-013
Rn6_11_3 n6_11_4 n6_11_5 3.000000e-001
Ln6_11_3 n6_11_5 n6_11_6 2.000000e-009
Cn6_11_3 n6_11_6 0 5.000000e-013
Rn6_11_4 n6_11_6 n6_11_7 3.000000e-001
Ln6_11_4 n6_11_7 n6_11 2.000000e-009
Cn6_11_4 n6_11 0 5.000000e-013

Rn6_12_1 n5_6 n6_12_1 3.000000e-001
Ln6_12_1 n6_12_1 n6_12_2 2.000000e-009
Cn6_12_1 n6_12_2 0 5.000000e-013
Rn6_12_2 n6_12_2 n6_12_3 3.000000e-001
Ln6_12_2 n6_12_3 n6_12_4 2.000000e-009
Cn6_12_2 n6_12_4 0 5.000000e-013
Rn6_12_3 n6_12_4 n6_12_5 3.000000e-001
Ln6_12_3 n6_12_5 n6_12_6 2.000000e-009
Cn6_12_3 n6_12_6 0 5.000000e-013
Rn6_12_4 n6_12_6 n6_12_7 3.000000e-001
Ln6_12_4 n6_12_7 n6_12 2.000000e-009
Cn6_12_4 n6_12 0 5.000000e-013

Rn6_13_1 n5_7 n6_13_1 3.000000e-001
Ln6_13_1 n6_13_1 n6_13_2 2.000000e-009
Cn6_13_1 n6_13_2 0 5.000000e-013
Rn6_13_2 n6_13_2 n6_13_3 3.000000e-001
Ln6_13_2 n6_13_3 n6_13_4 2.000000e-009
Cn6_13_2 n6_13_4 0 5.000000e-013
Rn6_13_3 n6_13_4 n6_13_5 3.000000e-001
Ln6_13_3 n6_13_5 n6_13_6 2.000000e-009
Cn6_13_3 n6_13_6 0 5.000000e-013
Rn6_13_4 n6_13_6 n6_13_7 3.000000e-001
Ln6_13_4 n6_13_7 n6_13 2.000000e-009
Cn6_13_4 n6_13 0 5.000000e-013

Rn6_14_1 n5_7 n6_14_1 3.000000e-001
Ln6_14_1 n6_14_1 n6_14_2 2.000000e-009
Cn6_14_1 n6_14_2 0 5.000000e-013
Rn6_14_2 n6_14_2 n6_14_3 3.000000e-001
Ln6_14_2 n6_14_3 n6_14_4 2.000000e-009
Cn6_14_2 n6_14_4 0 5.000000e-013
Rn6_14_3 n6_14_4 n6_14_5 3.000000e-001
Ln6_14_3 n6_14_5 n6_14_6 2.000000e-009
Cn6_14_3 n6_14_6 0 5.000000e-013
Rn6_14_4 n6_14_6 n6_14_7 3.000000e-001
Ln6_14_4 n6_14_7 n6_14 2.000000e-009
Cn6_14_4 n6_14 0 5.000000e-013

Rn6_15_1 n5_8 n6_15_1 3.000000e-001
Ln6_15_1 n6_15_1 n6_15_2 2.000000e-009
Cn6_15_1 n6_15_2 0 5.000000e-013
Rn6_15_2 n6_15_2 n6_15_3 3.000000e-001
Ln6_15_2 n6_15_3 n6_15_4 2.000000e-009
Cn6_15_2 n6_15_4 0 5.000000e-013
Rn6_15_3 n6_15_4 n6_15_5 3.000000e-001
Ln6_15_3 n6_15_5 n6_15_6 2.000000e-009
Cn6_15_3 n6_15_6 0 5.000000e-013
Rn6_15_4 n6_15_6 n6_15_7 3.000000e-001
Ln6_15_4 n6_15_7 n6_15 2.000000e-009
Cn6_15_4 n6_15 0 5.000000e-013

Rn6_16_1 n5_8 n6_16_1 3.000000e-001
Ln6_16_1 n6_16_1 n6_16_2 2.000000e-009
Cn6_16_1 n6_16_2 0 5.000000e-013
Rn6_16_2 n6_16_2 n6_16_3 3.000000e-001
Ln6_16_2 n6_16_3 n6_16_4 2.000000e-009
Cn6_16_2 n6_16_4 0 5.000000e-013
Rn6_16_3 n6_16_4 n6_16_5 3.000000e-001
Ln6_16_3 n6_16_5 n6_16_6 2.000000e-009
Cn6_16_3 n6_16_6 0 5.000000e-013
Rn6_16_4 n6_16_6 n6_16_7 3.000000e-001
Ln6_16_4 n6_16_7 n6_16 2.000000e-009
Cn6_16_4 n6_16 0 5.000000e-013

Rn6_17_1 n5_9 n6_17_1 3.000000e-001
Ln6_17_1 n6_17_1 n6_17_2 2.000000e-009
Cn6_17_1 n6_17_2 0 5.000000e-013
Rn6_17_2 n6_17_2 n6_17_3 3.000000e-001
Ln6_17_2 n6_17_3 n6_17_4 2.000000e-009
Cn6_17_2 n6_17_4 0 5.000000e-013
Rn6_17_3 n6_17_4 n6_17_5 3.000000e-001
Ln6_17_3 n6_17_5 n6_17_6 2.000000e-009
Cn6_17_3 n6_17_6 0 5.000000e-013
Rn6_17_4 n6_17_6 n6_17_7 3.000000e-001
Ln6_17_4 n6_17_7 n6_17 2.000000e-009
Cn6_17_4 n6_17 0 5.000000e-013

Rn6_18_1 n5_9 n6_18_1 3.000000e-001
Ln6_18_1 n6_18_1 n6_18_2 2.000000e-009
Cn6_18_1 n6_18_2 0 5.000000e-013
Rn6_18_2 n6_18_2 n6_18_3 3.000000e-001
Ln6_18_2 n6_18_3 n6_18_4 2.000000e-009
Cn6_18_2 n6_18_4 0 5.000000e-013
Rn6_18_3 n6_18_4 n6_18_5 3.000000e-001
Ln6_18_3 n6_18_5 n6_18_6 2.000000e-009
Cn6_18_3 n6_18_6 0 5.000000e-013
Rn6_18_4 n6_18_6 n6_18_7 3.000000e-001
Ln6_18_4 n6_18_7 n6_18 2.000000e-009
Cn6_18_4 n6_18 0 5.000000e-013

Rn6_19_1 n5_10 n6_19_1 3.000000e-001
Ln6_19_1 n6_19_1 n6_19_2 2.000000e-009
Cn6_19_1 n6_19_2 0 5.000000e-013
Rn6_19_2 n6_19_2 n6_19_3 3.000000e-001
Ln6_19_2 n6_19_3 n6_19_4 2.000000e-009
Cn6_19_2 n6_19_4 0 5.000000e-013
Rn6_19_3 n6_19_4 n6_19_5 3.000000e-001
Ln6_19_3 n6_19_5 n6_19_6 2.000000e-009
Cn6_19_3 n6_19_6 0 5.000000e-013
Rn6_19_4 n6_19_6 n6_19_7 3.000000e-001
Ln6_19_4 n6_19_7 n6_19 2.000000e-009
Cn6_19_4 n6_19 0 5.000000e-013

Rn6_20_1 n5_10 n6_20_1 3.000000e-001
Ln6_20_1 n6_20_1 n6_20_2 2.000000e-009
Cn6_20_1 n6_20_2 0 5.000000e-013
Rn6_20_2 n6_20_2 n6_20_3 3.000000e-001
Ln6_20_2 n6_20_3 n6_20_4 2.000000e-009
Cn6_20_2 n6_20_4 0 5.000000e-013
Rn6_20_3 n6_20_4 n6_20_5 3.000000e-001
Ln6_20_3 n6_20_5 n6_20_6 2.000000e-009
Cn6_20_3 n6_20_6 0 5.000000e-013
Rn6_20_4 n6_20_6 n6_20_7 3.000000e-001
Ln6_20_4 n6_20_7 n6_20 2.000000e-009
Cn6_20_4 n6_20 0 5.000000e-013

Rn6_21_1 n5_11 n6_21_1 3.000000e-001
Ln6_21_1 n6_21_1 n6_21_2 2.000000e-009
Cn6_21_1 n6_21_2 0 5.000000e-013
Rn6_21_2 n6_21_2 n6_21_3 3.000000e-001
Ln6_21_2 n6_21_3 n6_21_4 2.000000e-009
Cn6_21_2 n6_21_4 0 5.000000e-013
Rn6_21_3 n6_21_4 n6_21_5 3.000000e-001
Ln6_21_3 n6_21_5 n6_21_6 2.000000e-009
Cn6_21_3 n6_21_6 0 5.000000e-013
Rn6_21_4 n6_21_6 n6_21_7 3.000000e-001
Ln6_21_4 n6_21_7 n6_21 2.000000e-009
Cn6_21_4 n6_21 0 5.000000e-013

Rn6_22_1 n5_11 n6_22_1 3.000000e-001
Ln6_22_1 n6_22_1 n6_22_2 2.000000e-009
Cn6_22_1 n6_22_2 0 5.000000e-013
Rn6_22_2 n6_22_2 n6_22_3 3.000000e-001
Ln6_22_2 n6_22_3 n6_22_4 2.000000e-009
Cn6_22_2 n6_22_4 0 5.000000e-013
Rn6_22_3 n6_22_4 n6_22_5 3.000000e-001
Ln6_22_3 n6_22_5 n6_22_6 2.000000e-009
Cn6_22_3 n6_22_6 0 5.000000e-013
Rn6_22_4 n6_22_6 n6_22_7 3.000000e-001
Ln6_22_4 n6_22_7 n6_22 2.000000e-009
Cn6_22_4 n6_22 0 5.000000e-013

Rn6_23_1 n5_12 n6_23_1 3.000000e-001
Ln6_23_1 n6_23_1 n6_23_2 2.000000e-009
Cn6_23_1 n6_23_2 0 5.000000e-013
Rn6_23_2 n6_23_2 n6_23_3 3.000000e-001
Ln6_23_2 n6_23_3 n6_23_4 2.000000e-009
Cn6_23_2 n6_23_4 0 5.000000e-013
Rn6_23_3 n6_23_4 n6_23_5 3.000000e-001
Ln6_23_3 n6_23_5 n6_23_6 2.000000e-009
Cn6_23_3 n6_23_6 0 5.000000e-013
Rn6_23_4 n6_23_6 n6_23_7 3.000000e-001
Ln6_23_4 n6_23_7 n6_23 2.000000e-009
Cn6_23_4 n6_23 0 5.000000e-013

Rn6_24_1 n5_12 n6_24_1 3.000000e-001
Ln6_24_1 n6_24_1 n6_24_2 2.000000e-009
Cn6_24_1 n6_24_2 0 5.000000e-013
Rn6_24_2 n6_24_2 n6_24_3 3.000000e-001
Ln6_24_2 n6_24_3 n6_24_4 2.000000e-009
Cn6_24_2 n6_24_4 0 5.000000e-013
Rn6_24_3 n6_24_4 n6_24_5 3.000000e-001
Ln6_24_3 n6_24_5 n6_24_6 2.000000e-009
Cn6_24_3 n6_24_6 0 5.000000e-013
Rn6_24_4 n6_24_6 n6_24_7 3.000000e-001
Ln6_24_4 n6_24_7 n6_24 2.000000e-009
Cn6_24_4 n6_24 0 5.000000e-013

Rn6_25_1 n5_13 n6_25_1 3.000000e-001
Ln6_25_1 n6_25_1 n6_25_2 2.000000e-009
Cn6_25_1 n6_25_2 0 5.000000e-013
Rn6_25_2 n6_25_2 n6_25_3 3.000000e-001
Ln6_25_2 n6_25_3 n6_25_4 2.000000e-009
Cn6_25_2 n6_25_4 0 5.000000e-013
Rn6_25_3 n6_25_4 n6_25_5 3.000000e-001
Ln6_25_3 n6_25_5 n6_25_6 2.000000e-009
Cn6_25_3 n6_25_6 0 5.000000e-013
Rn6_25_4 n6_25_6 n6_25_7 3.000000e-001
Ln6_25_4 n6_25_7 n6_25 2.000000e-009
Cn6_25_4 n6_25 0 5.000000e-013

Rn6_26_1 n5_13 n6_26_1 3.000000e-001
Ln6_26_1 n6_26_1 n6_26_2 2.000000e-009
Cn6_26_1 n6_26_2 0 5.000000e-013
Rn6_26_2 n6_26_2 n6_26_3 3.000000e-001
Ln6_26_2 n6_26_3 n6_26_4 2.000000e-009
Cn6_26_2 n6_26_4 0 5.000000e-013
Rn6_26_3 n6_26_4 n6_26_5 3.000000e-001
Ln6_26_3 n6_26_5 n6_26_6 2.000000e-009
Cn6_26_3 n6_26_6 0 5.000000e-013
Rn6_26_4 n6_26_6 n6_26_7 3.000000e-001
Ln6_26_4 n6_26_7 n6_26 2.000000e-009
Cn6_26_4 n6_26 0 5.000000e-013

Rn6_27_1 n5_14 n6_27_1 3.000000e-001
Ln6_27_1 n6_27_1 n6_27_2 2.000000e-009
Cn6_27_1 n6_27_2 0 5.000000e-013
Rn6_27_2 n6_27_2 n6_27_3 3.000000e-001
Ln6_27_2 n6_27_3 n6_27_4 2.000000e-009
Cn6_27_2 n6_27_4 0 5.000000e-013
Rn6_27_3 n6_27_4 n6_27_5 3.000000e-001
Ln6_27_3 n6_27_5 n6_27_6 2.000000e-009
Cn6_27_3 n6_27_6 0 5.000000e-013
Rn6_27_4 n6_27_6 n6_27_7 3.000000e-001
Ln6_27_4 n6_27_7 n6_27 2.000000e-009
Cn6_27_4 n6_27 0 5.000000e-013

Rn6_28_1 n5_14 n6_28_1 3.000000e-001
Ln6_28_1 n6_28_1 n6_28_2 2.000000e-009
Cn6_28_1 n6_28_2 0 5.000000e-013
Rn6_28_2 n6_28_2 n6_28_3 3.000000e-001
Ln6_28_2 n6_28_3 n6_28_4 2.000000e-009
Cn6_28_2 n6_28_4 0 5.000000e-013
Rn6_28_3 n6_28_4 n6_28_5 3.000000e-001
Ln6_28_3 n6_28_5 n6_28_6 2.000000e-009
Cn6_28_3 n6_28_6 0 5.000000e-013
Rn6_28_4 n6_28_6 n6_28_7 3.000000e-001
Ln6_28_4 n6_28_7 n6_28 2.000000e-009
Cn6_28_4 n6_28 0 5.000000e-013

Rn6_29_1 n5_15 n6_29_1 3.000000e-001
Ln6_29_1 n6_29_1 n6_29_2 2.000000e-009
Cn6_29_1 n6_29_2 0 5.000000e-013
Rn6_29_2 n6_29_2 n6_29_3 3.000000e-001
Ln6_29_2 n6_29_3 n6_29_4 2.000000e-009
Cn6_29_2 n6_29_4 0 5.000000e-013
Rn6_29_3 n6_29_4 n6_29_5 3.000000e-001
Ln6_29_3 n6_29_5 n6_29_6 2.000000e-009
Cn6_29_3 n6_29_6 0 5.000000e-013
Rn6_29_4 n6_29_6 n6_29_7 3.000000e-001
Ln6_29_4 n6_29_7 n6_29 2.000000e-009
Cn6_29_4 n6_29 0 5.000000e-013

Rn6_30_1 n5_15 n6_30_1 3.000000e-001
Ln6_30_1 n6_30_1 n6_30_2 2.000000e-009
Cn6_30_1 n6_30_2 0 5.000000e-013
Rn6_30_2 n6_30_2 n6_30_3 3.000000e-001
Ln6_30_2 n6_30_3 n6_30_4 2.000000e-009
Cn6_30_2 n6_30_4 0 5.000000e-013
Rn6_30_3 n6_30_4 n6_30_5 3.000000e-001
Ln6_30_3 n6_30_5 n6_30_6 2.000000e-009
Cn6_30_3 n6_30_6 0 5.000000e-013
Rn6_30_4 n6_30_6 n6_30_7 3.000000e-001
Ln6_30_4 n6_30_7 n6_30 2.000000e-009
Cn6_30_4 n6_30 0 5.000000e-013

Rn6_31_1 n5_16 n6_31_1 3.000000e-001
Ln6_31_1 n6_31_1 n6_31_2 2.000000e-009
Cn6_31_1 n6_31_2 0 5.000000e-013
Rn6_31_2 n6_31_2 n6_31_3 3.000000e-001
Ln6_31_2 n6_31_3 n6_31_4 2.000000e-009
Cn6_31_2 n6_31_4 0 5.000000e-013
Rn6_31_3 n6_31_4 n6_31_5 3.000000e-001
Ln6_31_3 n6_31_5 n6_31_6 2.000000e-009
Cn6_31_3 n6_31_6 0 5.000000e-013
Rn6_31_4 n6_31_6 n6_31_7 3.000000e-001
Ln6_31_4 n6_31_7 n6_31 2.000000e-009
Cn6_31_4 n6_31 0 5.000000e-013

Rn6_32_1 n5_16 n6_32_1 3.000000e-001
Ln6_32_1 n6_32_1 n6_32_2 2.000000e-009
Cn6_32_1 n6_32_2 0 5.000000e-013
Rn6_32_2 n6_32_2 n6_32_3 3.000000e-001
Ln6_32_2 n6_32_3 n6_32_4 2.000000e-009
Cn6_32_2 n6_32_4 0 5.000000e-013
Rn6_32_3 n6_32_4 n6_32_5 3.000000e-001
Ln6_32_3 n6_32_5 n6_32_6 2.000000e-009
Cn6_32_3 n6_32_6 0 5.000000e-013
Rn6_32_4 n6_32_6 n6_32_7 3.000000e-001
Ln6_32_4 n6_32_7 n6_32 2.000000e-009
Cn6_32_4 n6_32 0 5.000000e-013

Rn7_1_1 n6_1 n7_1_1 3.000000e-001
Ln7_1_1 n7_1_1 n7_1_2 2.000000e-009
Cn7_1_1 n7_1_2 0 5.000000e-013
Rn7_1_2 n7_1_2 n7_1_3 3.000000e-001
Ln7_1_2 n7_1_3 n7_1_4 2.000000e-009
Cn7_1_2 n7_1_4 0 5.000000e-013
Rn7_1_3 n7_1_4 n7_1_5 3.000000e-001
Ln7_1_3 n7_1_5 n7_1_6 2.000000e-009
Cn7_1_3 n7_1_6 0 5.000000e-013
Rn7_1_4 n7_1_6 n7_1_7 3.000000e-001
Ln7_1_4 n7_1_7 n7_1 2.000000e-009
Cn7_1_4 n7_1 0 5.000000e-013
CLoadn7_1_1 n7_1 0 1.000000e-012

Rn7_2_1 n6_1 n7_2_1 3.000000e-001
Ln7_2_1 n7_2_1 n7_2_2 2.000000e-009
Cn7_2_1 n7_2_2 0 5.000000e-013
Rn7_2_2 n7_2_2 n7_2_3 3.000000e-001
Ln7_2_2 n7_2_3 n7_2_4 2.000000e-009
Cn7_2_2 n7_2_4 0 5.000000e-013
Rn7_2_3 n7_2_4 n7_2_5 3.000000e-001
Ln7_2_3 n7_2_5 n7_2_6 2.000000e-009
Cn7_2_3 n7_2_6 0 5.000000e-013
Rn7_2_4 n7_2_6 n7_2_7 3.000000e-001
Ln7_2_4 n7_2_7 n7_2 2.000000e-009
Cn7_2_4 n7_2 0 5.000000e-013
CLoadn7_2_2 n7_2 0 1.000000e-012

Rn7_3_1 n6_2 n7_3_1 3.000000e-001
Ln7_3_1 n7_3_1 n7_3_2 2.000000e-009
Cn7_3_1 n7_3_2 0 5.000000e-013
Rn7_3_2 n7_3_2 n7_3_3 3.000000e-001
Ln7_3_2 n7_3_3 n7_3_4 2.000000e-009
Cn7_3_2 n7_3_4 0 5.000000e-013
Rn7_3_3 n7_3_4 n7_3_5 3.000000e-001
Ln7_3_3 n7_3_5 n7_3_6 2.000000e-009
Cn7_3_3 n7_3_6 0 5.000000e-013
Rn7_3_4 n7_3_6 n7_3_7 3.000000e-001
Ln7_3_4 n7_3_7 n7_3 2.000000e-009
Cn7_3_4 n7_3 0 5.000000e-013
CLoadn7_3_3 n7_3 0 1.000000e-012

Rn7_4_1 n6_2 n7_4_1 3.000000e-001
Ln7_4_1 n7_4_1 n7_4_2 2.000000e-009
Cn7_4_1 n7_4_2 0 5.000000e-013
Rn7_4_2 n7_4_2 n7_4_3 3.000000e-001
Ln7_4_2 n7_4_3 n7_4_4 2.000000e-009
Cn7_4_2 n7_4_4 0 5.000000e-013
Rn7_4_3 n7_4_4 n7_4_5 3.000000e-001
Ln7_4_3 n7_4_5 n7_4_6 2.000000e-009
Cn7_4_3 n7_4_6 0 5.000000e-013
Rn7_4_4 n7_4_6 n7_4_7 3.000000e-001
Ln7_4_4 n7_4_7 n7_4 2.000000e-009
Cn7_4_4 n7_4 0 5.000000e-013
CLoadn7_4_4 n7_4 0 1.000000e-012

Rn7_5_1 n6_3 n7_5_1 3.000000e-001
Ln7_5_1 n7_5_1 n7_5_2 2.000000e-009
Cn7_5_1 n7_5_2 0 5.000000e-013
Rn7_5_2 n7_5_2 n7_5_3 3.000000e-001
Ln7_5_2 n7_5_3 n7_5_4 2.000000e-009
Cn7_5_2 n7_5_4 0 5.000000e-013
Rn7_5_3 n7_5_4 n7_5_5 3.000000e-001
Ln7_5_3 n7_5_5 n7_5_6 2.000000e-009
Cn7_5_3 n7_5_6 0 5.000000e-013
Rn7_5_4 n7_5_6 n7_5_7 3.000000e-001
Ln7_5_4 n7_5_7 n7_5 2.000000e-009
Cn7_5_4 n7_5 0 5.000000e-013
CLoadn7_5_5 n7_5 0 1.000000e-012

Rn7_6_1 n6_3 n7_6_1 3.000000e-001
Ln7_6_1 n7_6_1 n7_6_2 2.000000e-009
Cn7_6_1 n7_6_2 0 5.000000e-013
Rn7_6_2 n7_6_2 n7_6_3 3.000000e-001
Ln7_6_2 n7_6_3 n7_6_4 2.000000e-009
Cn7_6_2 n7_6_4 0 5.000000e-013
Rn7_6_3 n7_6_4 n7_6_5 3.000000e-001
Ln7_6_3 n7_6_5 n7_6_6 2.000000e-009
Cn7_6_3 n7_6_6 0 5.000000e-013
Rn7_6_4 n7_6_6 n7_6_7 3.000000e-001
Ln7_6_4 n7_6_7 n7_6 2.000000e-009
Cn7_6_4 n7_6 0 5.000000e-013
CLoadn7_6_6 n7_6 0 1.000000e-012

Rn7_7_1 n6_4 n7_7_1 3.000000e-001
Ln7_7_1 n7_7_1 n7_7_2 2.000000e-009
Cn7_7_1 n7_7_2 0 5.000000e-013
Rn7_7_2 n7_7_2 n7_7_3 3.000000e-001
Ln7_7_2 n7_7_3 n7_7_4 2.000000e-009
Cn7_7_2 n7_7_4 0 5.000000e-013
Rn7_7_3 n7_7_4 n7_7_5 3.000000e-001
Ln7_7_3 n7_7_5 n7_7_6 2.000000e-009
Cn7_7_3 n7_7_6 0 5.000000e-013
Rn7_7_4 n7_7_6 n7_7_7 3.000000e-001
Ln7_7_4 n7_7_7 n7_7 2.000000e-009
Cn7_7_4 n7_7 0 5.000000e-013
CLoadn7_7_7 n7_7 0 1.000000e-012

Rn7_8_1 n6_4 n7_8_1 3.000000e-001
Ln7_8_1 n7_8_1 n7_8_2 2.000000e-009
Cn7_8_1 n7_8_2 0 5.000000e-013
Rn7_8_2 n7_8_2 n7_8_3 3.000000e-001
Ln7_8_2 n7_8_3 n7_8_4 2.000000e-009
Cn7_8_2 n7_8_4 0 5.000000e-013
Rn7_8_3 n7_8_4 n7_8_5 3.000000e-001
Ln7_8_3 n7_8_5 n7_8_6 2.000000e-009
Cn7_8_3 n7_8_6 0 5.000000e-013
Rn7_8_4 n7_8_6 n7_8_7 3.000000e-001
Ln7_8_4 n7_8_7 n7_8 2.000000e-009
Cn7_8_4 n7_8 0 5.000000e-013
CLoadn7_8_8 n7_8 0 1.000000e-012

Rn7_9_1 n6_5 n7_9_1 3.000000e-001
Ln7_9_1 n7_9_1 n7_9_2 2.000000e-009
Cn7_9_1 n7_9_2 0 5.000000e-013
Rn7_9_2 n7_9_2 n7_9_3 3.000000e-001
Ln7_9_2 n7_9_3 n7_9_4 2.000000e-009
Cn7_9_2 n7_9_4 0 5.000000e-013
Rn7_9_3 n7_9_4 n7_9_5 3.000000e-001
Ln7_9_3 n7_9_5 n7_9_6 2.000000e-009
Cn7_9_3 n7_9_6 0 5.000000e-013
Rn7_9_4 n7_9_6 n7_9_7 3.000000e-001
Ln7_9_4 n7_9_7 n7_9 2.000000e-009
Cn7_9_4 n7_9 0 5.000000e-013
CLoadn7_9_9 n7_9 0 1.000000e-012

Rn7_10_1 n6_5 n7_10_1 3.000000e-001
Ln7_10_1 n7_10_1 n7_10_2 2.000000e-009
Cn7_10_1 n7_10_2 0 5.000000e-013
Rn7_10_2 n7_10_2 n7_10_3 3.000000e-001
Ln7_10_2 n7_10_3 n7_10_4 2.000000e-009
Cn7_10_2 n7_10_4 0 5.000000e-013
Rn7_10_3 n7_10_4 n7_10_5 3.000000e-001
Ln7_10_3 n7_10_5 n7_10_6 2.000000e-009
Cn7_10_3 n7_10_6 0 5.000000e-013
Rn7_10_4 n7_10_6 n7_10_7 3.000000e-001
Ln7_10_4 n7_10_7 n7_10 2.000000e-009
Cn7_10_4 n7_10 0 5.000000e-013
CLoadn7_10_10 n7_10 0 1.000000e-012

Rn7_11_1 n6_6 n7_11_1 3.000000e-001
Ln7_11_1 n7_11_1 n7_11_2 2.000000e-009
Cn7_11_1 n7_11_2 0 5.000000e-013
Rn7_11_2 n7_11_2 n7_11_3 3.000000e-001
Ln7_11_2 n7_11_3 n7_11_4 2.000000e-009
Cn7_11_2 n7_11_4 0 5.000000e-013
Rn7_11_3 n7_11_4 n7_11_5 3.000000e-001
Ln7_11_3 n7_11_5 n7_11_6 2.000000e-009
Cn7_11_3 n7_11_6 0 5.000000e-013
Rn7_11_4 n7_11_6 n7_11_7 3.000000e-001
Ln7_11_4 n7_11_7 n7_11 2.000000e-009
Cn7_11_4 n7_11 0 5.000000e-013
CLoadn7_11_11 n7_11 0 1.000000e-012

Rn7_12_1 n6_6 n7_12_1 3.000000e-001
Ln7_12_1 n7_12_1 n7_12_2 2.000000e-009
Cn7_12_1 n7_12_2 0 5.000000e-013
Rn7_12_2 n7_12_2 n7_12_3 3.000000e-001
Ln7_12_2 n7_12_3 n7_12_4 2.000000e-009
Cn7_12_2 n7_12_4 0 5.000000e-013
Rn7_12_3 n7_12_4 n7_12_5 3.000000e-001
Ln7_12_3 n7_12_5 n7_12_6 2.000000e-009
Cn7_12_3 n7_12_6 0 5.000000e-013
Rn7_12_4 n7_12_6 n7_12_7 3.000000e-001
Ln7_12_4 n7_12_7 n7_12 2.000000e-009
Cn7_12_4 n7_12 0 5.000000e-013
CLoadn7_12_12 n7_12 0 1.000000e-012

Rn7_13_1 n6_7 n7_13_1 3.000000e-001
Ln7_13_1 n7_13_1 n7_13_2 2.000000e-009
Cn7_13_1 n7_13_2 0 5.000000e-013
Rn7_13_2 n7_13_2 n7_13_3 3.000000e-001
Ln7_13_2 n7_13_3 n7_13_4 2.000000e-009
Cn7_13_2 n7_13_4 0 5.000000e-013
Rn7_13_3 n7_13_4 n7_13_5 3.000000e-001
Ln7_13_3 n7_13_5 n7_13_6 2.000000e-009
Cn7_13_3 n7_13_6 0 5.000000e-013
Rn7_13_4 n7_13_6 n7_13_7 3.000000e-001
Ln7_13_4 n7_13_7 n7_13 2.000000e-009
Cn7_13_4 n7_13 0 5.000000e-013
CLoadn7_13_13 n7_13 0 1.000000e-012

Rn7_14_1 n6_7 n7_14_1 3.000000e-001
Ln7_14_1 n7_14_1 n7_14_2 2.000000e-009
Cn7_14_1 n7_14_2 0 5.000000e-013
Rn7_14_2 n7_14_2 n7_14_3 3.000000e-001
Ln7_14_2 n7_14_3 n7_14_4 2.000000e-009
Cn7_14_2 n7_14_4 0 5.000000e-013
Rn7_14_3 n7_14_4 n7_14_5 3.000000e-001
Ln7_14_3 n7_14_5 n7_14_6 2.000000e-009
Cn7_14_3 n7_14_6 0 5.000000e-013
Rn7_14_4 n7_14_6 n7_14_7 3.000000e-001
Ln7_14_4 n7_14_7 n7_14 2.000000e-009
Cn7_14_4 n7_14 0 5.000000e-013
CLoadn7_14_14 n7_14 0 1.000000e-012

Rn7_15_1 n6_8 n7_15_1 3.000000e-001
Ln7_15_1 n7_15_1 n7_15_2 2.000000e-009
Cn7_15_1 n7_15_2 0 5.000000e-013
Rn7_15_2 n7_15_2 n7_15_3 3.000000e-001
Ln7_15_2 n7_15_3 n7_15_4 2.000000e-009
Cn7_15_2 n7_15_4 0 5.000000e-013
Rn7_15_3 n7_15_4 n7_15_5 3.000000e-001
Ln7_15_3 n7_15_5 n7_15_6 2.000000e-009
Cn7_15_3 n7_15_6 0 5.000000e-013
Rn7_15_4 n7_15_6 n7_15_7 3.000000e-001
Ln7_15_4 n7_15_7 n7_15 2.000000e-009
Cn7_15_4 n7_15 0 5.000000e-013
CLoadn7_15_15 n7_15 0 1.000000e-012

Rn7_16_1 n6_8 n7_16_1 3.000000e-001
Ln7_16_1 n7_16_1 n7_16_2 2.000000e-009
Cn7_16_1 n7_16_2 0 5.000000e-013
Rn7_16_2 n7_16_2 n7_16_3 3.000000e-001
Ln7_16_2 n7_16_3 n7_16_4 2.000000e-009
Cn7_16_2 n7_16_4 0 5.000000e-013
Rn7_16_3 n7_16_4 n7_16_5 3.000000e-001
Ln7_16_3 n7_16_5 n7_16_6 2.000000e-009
Cn7_16_3 n7_16_6 0 5.000000e-013
Rn7_16_4 n7_16_6 n7_16_7 3.000000e-001
Ln7_16_4 n7_16_7 n7_16 2.000000e-009
Cn7_16_4 n7_16 0 5.000000e-013
CLoadn7_16_16 n7_16 0 1.000000e-012

Rn7_17_1 n6_9 n7_17_1 3.000000e-001
Ln7_17_1 n7_17_1 n7_17_2 2.000000e-009
Cn7_17_1 n7_17_2 0 5.000000e-013
Rn7_17_2 n7_17_2 n7_17_3 3.000000e-001
Ln7_17_2 n7_17_3 n7_17_4 2.000000e-009
Cn7_17_2 n7_17_4 0 5.000000e-013
Rn7_17_3 n7_17_4 n7_17_5 3.000000e-001
Ln7_17_3 n7_17_5 n7_17_6 2.000000e-009
Cn7_17_3 n7_17_6 0 5.000000e-013
Rn7_17_4 n7_17_6 n7_17_7 3.000000e-001
Ln7_17_4 n7_17_7 n7_17 2.000000e-009
Cn7_17_4 n7_17 0 5.000000e-013
CLoadn7_17_17 n7_17 0 1.000000e-012

Rn7_18_1 n6_9 n7_18_1 3.000000e-001
Ln7_18_1 n7_18_1 n7_18_2 2.000000e-009
Cn7_18_1 n7_18_2 0 5.000000e-013
Rn7_18_2 n7_18_2 n7_18_3 3.000000e-001
Ln7_18_2 n7_18_3 n7_18_4 2.000000e-009
Cn7_18_2 n7_18_4 0 5.000000e-013
Rn7_18_3 n7_18_4 n7_18_5 3.000000e-001
Ln7_18_3 n7_18_5 n7_18_6 2.000000e-009
Cn7_18_3 n7_18_6 0 5.000000e-013
Rn7_18_4 n7_18_6 n7_18_7 3.000000e-001
Ln7_18_4 n7_18_7 n7_18 2.000000e-009
Cn7_18_4 n7_18 0 5.000000e-013
CLoadn7_18_18 n7_18 0 1.000000e-012

Rn7_19_1 n6_10 n7_19_1 3.000000e-001
Ln7_19_1 n7_19_1 n7_19_2 2.000000e-009
Cn7_19_1 n7_19_2 0 5.000000e-013
Rn7_19_2 n7_19_2 n7_19_3 3.000000e-001
Ln7_19_2 n7_19_3 n7_19_4 2.000000e-009
Cn7_19_2 n7_19_4 0 5.000000e-013
Rn7_19_3 n7_19_4 n7_19_5 3.000000e-001
Ln7_19_3 n7_19_5 n7_19_6 2.000000e-009
Cn7_19_3 n7_19_6 0 5.000000e-013
Rn7_19_4 n7_19_6 n7_19_7 3.000000e-001
Ln7_19_4 n7_19_7 n7_19 2.000000e-009
Cn7_19_4 n7_19 0 5.000000e-013
CLoadn7_19_19 n7_19 0 1.000000e-012

Rn7_20_1 n6_10 n7_20_1 3.000000e-001
Ln7_20_1 n7_20_1 n7_20_2 2.000000e-009
Cn7_20_1 n7_20_2 0 5.000000e-013
Rn7_20_2 n7_20_2 n7_20_3 3.000000e-001
Ln7_20_2 n7_20_3 n7_20_4 2.000000e-009
Cn7_20_2 n7_20_4 0 5.000000e-013
Rn7_20_3 n7_20_4 n7_20_5 3.000000e-001
Ln7_20_3 n7_20_5 n7_20_6 2.000000e-009
Cn7_20_3 n7_20_6 0 5.000000e-013
Rn7_20_4 n7_20_6 n7_20_7 3.000000e-001
Ln7_20_4 n7_20_7 n7_20 2.000000e-009
Cn7_20_4 n7_20 0 5.000000e-013
CLoadn7_20_20 n7_20 0 1.000000e-012

Rn7_21_1 n6_11 n7_21_1 3.000000e-001
Ln7_21_1 n7_21_1 n7_21_2 2.000000e-009
Cn7_21_1 n7_21_2 0 5.000000e-013
Rn7_21_2 n7_21_2 n7_21_3 3.000000e-001
Ln7_21_2 n7_21_3 n7_21_4 2.000000e-009
Cn7_21_2 n7_21_4 0 5.000000e-013
Rn7_21_3 n7_21_4 n7_21_5 3.000000e-001
Ln7_21_3 n7_21_5 n7_21_6 2.000000e-009
Cn7_21_3 n7_21_6 0 5.000000e-013
Rn7_21_4 n7_21_6 n7_21_7 3.000000e-001
Ln7_21_4 n7_21_7 n7_21 2.000000e-009
Cn7_21_4 n7_21 0 5.000000e-013
CLoadn7_21_21 n7_21 0 1.000000e-012

Rn7_22_1 n6_11 n7_22_1 3.000000e-001
Ln7_22_1 n7_22_1 n7_22_2 2.000000e-009
Cn7_22_1 n7_22_2 0 5.000000e-013
Rn7_22_2 n7_22_2 n7_22_3 3.000000e-001
Ln7_22_2 n7_22_3 n7_22_4 2.000000e-009
Cn7_22_2 n7_22_4 0 5.000000e-013
Rn7_22_3 n7_22_4 n7_22_5 3.000000e-001
Ln7_22_3 n7_22_5 n7_22_6 2.000000e-009
Cn7_22_3 n7_22_6 0 5.000000e-013
Rn7_22_4 n7_22_6 n7_22_7 3.000000e-001
Ln7_22_4 n7_22_7 n7_22 2.000000e-009
Cn7_22_4 n7_22 0 5.000000e-013
CLoadn7_22_22 n7_22 0 1.000000e-012

Rn7_23_1 n6_12 n7_23_1 3.000000e-001
Ln7_23_1 n7_23_1 n7_23_2 2.000000e-009
Cn7_23_1 n7_23_2 0 5.000000e-013
Rn7_23_2 n7_23_2 n7_23_3 3.000000e-001
Ln7_23_2 n7_23_3 n7_23_4 2.000000e-009
Cn7_23_2 n7_23_4 0 5.000000e-013
Rn7_23_3 n7_23_4 n7_23_5 3.000000e-001
Ln7_23_3 n7_23_5 n7_23_6 2.000000e-009
Cn7_23_3 n7_23_6 0 5.000000e-013
Rn7_23_4 n7_23_6 n7_23_7 3.000000e-001
Ln7_23_4 n7_23_7 n7_23 2.000000e-009
Cn7_23_4 n7_23 0 5.000000e-013
CLoadn7_23_23 n7_23 0 1.000000e-012

Rn7_24_1 n6_12 n7_24_1 3.000000e-001
Ln7_24_1 n7_24_1 n7_24_2 2.000000e-009
Cn7_24_1 n7_24_2 0 5.000000e-013
Rn7_24_2 n7_24_2 n7_24_3 3.000000e-001
Ln7_24_2 n7_24_3 n7_24_4 2.000000e-009
Cn7_24_2 n7_24_4 0 5.000000e-013
Rn7_24_3 n7_24_4 n7_24_5 3.000000e-001
Ln7_24_3 n7_24_5 n7_24_6 2.000000e-009
Cn7_24_3 n7_24_6 0 5.000000e-013
Rn7_24_4 n7_24_6 n7_24_7 3.000000e-001
Ln7_24_4 n7_24_7 n7_24 2.000000e-009
Cn7_24_4 n7_24 0 5.000000e-013
CLoadn7_24_24 n7_24 0 1.000000e-012

Rn7_25_1 n6_13 n7_25_1 3.000000e-001
Ln7_25_1 n7_25_1 n7_25_2 2.000000e-009
Cn7_25_1 n7_25_2 0 5.000000e-013
Rn7_25_2 n7_25_2 n7_25_3 3.000000e-001
Ln7_25_2 n7_25_3 n7_25_4 2.000000e-009
Cn7_25_2 n7_25_4 0 5.000000e-013
Rn7_25_3 n7_25_4 n7_25_5 3.000000e-001
Ln7_25_3 n7_25_5 n7_25_6 2.000000e-009
Cn7_25_3 n7_25_6 0 5.000000e-013
Rn7_25_4 n7_25_6 n7_25_7 3.000000e-001
Ln7_25_4 n7_25_7 n7_25 2.000000e-009
Cn7_25_4 n7_25 0 5.000000e-013
CLoadn7_25_25 n7_25 0 1.000000e-012

Rn7_26_1 n6_13 n7_26_1 3.000000e-001
Ln7_26_1 n7_26_1 n7_26_2 2.000000e-009
Cn7_26_1 n7_26_2 0 5.000000e-013
Rn7_26_2 n7_26_2 n7_26_3 3.000000e-001
Ln7_26_2 n7_26_3 n7_26_4 2.000000e-009
Cn7_26_2 n7_26_4 0 5.000000e-013
Rn7_26_3 n7_26_4 n7_26_5 3.000000e-001
Ln7_26_3 n7_26_5 n7_26_6 2.000000e-009
Cn7_26_3 n7_26_6 0 5.000000e-013
Rn7_26_4 n7_26_6 n7_26_7 3.000000e-001
Ln7_26_4 n7_26_7 n7_26 2.000000e-009
Cn7_26_4 n7_26 0 5.000000e-013
CLoadn7_26_26 n7_26 0 1.000000e-012

Rn7_27_1 n6_14 n7_27_1 3.000000e-001
Ln7_27_1 n7_27_1 n7_27_2 2.000000e-009
Cn7_27_1 n7_27_2 0 5.000000e-013
Rn7_27_2 n7_27_2 n7_27_3 3.000000e-001
Ln7_27_2 n7_27_3 n7_27_4 2.000000e-009
Cn7_27_2 n7_27_4 0 5.000000e-013
Rn7_27_3 n7_27_4 n7_27_5 3.000000e-001
Ln7_27_3 n7_27_5 n7_27_6 2.000000e-009
Cn7_27_3 n7_27_6 0 5.000000e-013
Rn7_27_4 n7_27_6 n7_27_7 3.000000e-001
Ln7_27_4 n7_27_7 n7_27 2.000000e-009
Cn7_27_4 n7_27 0 5.000000e-013
CLoadn7_27_27 n7_27 0 1.000000e-012

Rn7_28_1 n6_14 n7_28_1 3.000000e-001
Ln7_28_1 n7_28_1 n7_28_2 2.000000e-009
Cn7_28_1 n7_28_2 0 5.000000e-013
Rn7_28_2 n7_28_2 n7_28_3 3.000000e-001
Ln7_28_2 n7_28_3 n7_28_4 2.000000e-009
Cn7_28_2 n7_28_4 0 5.000000e-013
Rn7_28_3 n7_28_4 n7_28_5 3.000000e-001
Ln7_28_3 n7_28_5 n7_28_6 2.000000e-009
Cn7_28_3 n7_28_6 0 5.000000e-013
Rn7_28_4 n7_28_6 n7_28_7 3.000000e-001
Ln7_28_4 n7_28_7 n7_28 2.000000e-009
Cn7_28_4 n7_28 0 5.000000e-013
CLoadn7_28_28 n7_28 0 1.000000e-012

Rn7_29_1 n6_15 n7_29_1 3.000000e-001
Ln7_29_1 n7_29_1 n7_29_2 2.000000e-009
Cn7_29_1 n7_29_2 0 5.000000e-013
Rn7_29_2 n7_29_2 n7_29_3 3.000000e-001
Ln7_29_2 n7_29_3 n7_29_4 2.000000e-009
Cn7_29_2 n7_29_4 0 5.000000e-013
Rn7_29_3 n7_29_4 n7_29_5 3.000000e-001
Ln7_29_3 n7_29_5 n7_29_6 2.000000e-009
Cn7_29_3 n7_29_6 0 5.000000e-013
Rn7_29_4 n7_29_6 n7_29_7 3.000000e-001
Ln7_29_4 n7_29_7 n7_29 2.000000e-009
Cn7_29_4 n7_29 0 5.000000e-013
CLoadn7_29_29 n7_29 0 1.000000e-012

Rn7_30_1 n6_15 n7_30_1 3.000000e-001
Ln7_30_1 n7_30_1 n7_30_2 2.000000e-009
Cn7_30_1 n7_30_2 0 5.000000e-013
Rn7_30_2 n7_30_2 n7_30_3 3.000000e-001
Ln7_30_2 n7_30_3 n7_30_4 2.000000e-009
Cn7_30_2 n7_30_4 0 5.000000e-013
Rn7_30_3 n7_30_4 n7_30_5 3.000000e-001
Ln7_30_3 n7_30_5 n7_30_6 2.000000e-009
Cn7_30_3 n7_30_6 0 5.000000e-013
Rn7_30_4 n7_30_6 n7_30_7 3.000000e-001
Ln7_30_4 n7_30_7 n7_30 2.000000e-009
Cn7_30_4 n7_30 0 5.000000e-013
CLoadn7_30_30 n7_30 0 1.000000e-012

Rn7_31_1 n6_16 n7_31_1 3.000000e-001
Ln7_31_1 n7_31_1 n7_31_2 2.000000e-009
Cn7_31_1 n7_31_2 0 5.000000e-013
Rn7_31_2 n7_31_2 n7_31_3 3.000000e-001
Ln7_31_2 n7_31_3 n7_31_4 2.000000e-009
Cn7_31_2 n7_31_4 0 5.000000e-013
Rn7_31_3 n7_31_4 n7_31_5 3.000000e-001
Ln7_31_3 n7_31_5 n7_31_6 2.000000e-009
Cn7_31_3 n7_31_6 0 5.000000e-013
Rn7_31_4 n7_31_6 n7_31_7 3.000000e-001
Ln7_31_4 n7_31_7 n7_31 2.000000e-009
Cn7_31_4 n7_31 0 5.000000e-013
CLoadn7_31_31 n7_31 0 1.000000e-012

Rn7_32_1 n6_16 n7_32_1 3.000000e-001
Ln7_32_1 n7_32_1 n7_32_2 2.000000e-009
Cn7_32_1 n7_32_2 0 5.000000e-013
Rn7_32_2 n7_32_2 n7_32_3 3.000000e-001
Ln7_32_2 n7_32_3 n7_32_4 2.000000e-009
Cn7_32_2 n7_32_4 0 5.000000e-013
Rn7_32_3 n7_32_4 n7_32_5 3.000000e-001
Ln7_32_3 n7_32_5 n7_32_6 2.000000e-009
Cn7_32_3 n7_32_6 0 5.000000e-013
Rn7_32_4 n7_32_6 n7_32_7 3.000000e-001
Ln7_32_4 n7_32_7 n7_32 2.000000e-009
Cn7_32_4 n7_32 0 5.000000e-013
CLoadn7_32_32 n7_32 0 1.000000e-012

Rn7_33_1 n6_17 n7_33_1 3.000000e-001
Ln7_33_1 n7_33_1 n7_33_2 2.000000e-009
Cn7_33_1 n7_33_2 0 5.000000e-013
Rn7_33_2 n7_33_2 n7_33_3 3.000000e-001
Ln7_33_2 n7_33_3 n7_33_4 2.000000e-009
Cn7_33_2 n7_33_4 0 5.000000e-013
Rn7_33_3 n7_33_4 n7_33_5 3.000000e-001
Ln7_33_3 n7_33_5 n7_33_6 2.000000e-009
Cn7_33_3 n7_33_6 0 5.000000e-013
Rn7_33_4 n7_33_6 n7_33_7 3.000000e-001
Ln7_33_4 n7_33_7 n7_33 2.000000e-009
Cn7_33_4 n7_33 0 5.000000e-013
CLoadn7_33_33 n7_33 0 1.000000e-012

Rn7_34_1 n6_17 n7_34_1 3.000000e-001
Ln7_34_1 n7_34_1 n7_34_2 2.000000e-009
Cn7_34_1 n7_34_2 0 5.000000e-013
Rn7_34_2 n7_34_2 n7_34_3 3.000000e-001
Ln7_34_2 n7_34_3 n7_34_4 2.000000e-009
Cn7_34_2 n7_34_4 0 5.000000e-013
Rn7_34_3 n7_34_4 n7_34_5 3.000000e-001
Ln7_34_3 n7_34_5 n7_34_6 2.000000e-009
Cn7_34_3 n7_34_6 0 5.000000e-013
Rn7_34_4 n7_34_6 n7_34_7 3.000000e-001
Ln7_34_4 n7_34_7 n7_34 2.000000e-009
Cn7_34_4 n7_34 0 5.000000e-013
CLoadn7_34_34 n7_34 0 1.000000e-012

Rn7_35_1 n6_18 n7_35_1 3.000000e-001
Ln7_35_1 n7_35_1 n7_35_2 2.000000e-009
Cn7_35_1 n7_35_2 0 5.000000e-013
Rn7_35_2 n7_35_2 n7_35_3 3.000000e-001
Ln7_35_2 n7_35_3 n7_35_4 2.000000e-009
Cn7_35_2 n7_35_4 0 5.000000e-013
Rn7_35_3 n7_35_4 n7_35_5 3.000000e-001
Ln7_35_3 n7_35_5 n7_35_6 2.000000e-009
Cn7_35_3 n7_35_6 0 5.000000e-013
Rn7_35_4 n7_35_6 n7_35_7 3.000000e-001
Ln7_35_4 n7_35_7 n7_35 2.000000e-009
Cn7_35_4 n7_35 0 5.000000e-013
CLoadn7_35_35 n7_35 0 1.000000e-012

Rn7_36_1 n6_18 n7_36_1 3.000000e-001
Ln7_36_1 n7_36_1 n7_36_2 2.000000e-009
Cn7_36_1 n7_36_2 0 5.000000e-013
Rn7_36_2 n7_36_2 n7_36_3 3.000000e-001
Ln7_36_2 n7_36_3 n7_36_4 2.000000e-009
Cn7_36_2 n7_36_4 0 5.000000e-013
Rn7_36_3 n7_36_4 n7_36_5 3.000000e-001
Ln7_36_3 n7_36_5 n7_36_6 2.000000e-009
Cn7_36_3 n7_36_6 0 5.000000e-013
Rn7_36_4 n7_36_6 n7_36_7 3.000000e-001
Ln7_36_4 n7_36_7 n7_36 2.000000e-009
Cn7_36_4 n7_36 0 5.000000e-013
CLoadn7_36_36 n7_36 0 1.000000e-012

Rn7_37_1 n6_19 n7_37_1 3.000000e-001
Ln7_37_1 n7_37_1 n7_37_2 2.000000e-009
Cn7_37_1 n7_37_2 0 5.000000e-013
Rn7_37_2 n7_37_2 n7_37_3 3.000000e-001
Ln7_37_2 n7_37_3 n7_37_4 2.000000e-009
Cn7_37_2 n7_37_4 0 5.000000e-013
Rn7_37_3 n7_37_4 n7_37_5 3.000000e-001
Ln7_37_3 n7_37_5 n7_37_6 2.000000e-009
Cn7_37_3 n7_37_6 0 5.000000e-013
Rn7_37_4 n7_37_6 n7_37_7 3.000000e-001
Ln7_37_4 n7_37_7 n7_37 2.000000e-009
Cn7_37_4 n7_37 0 5.000000e-013
CLoadn7_37_37 n7_37 0 1.000000e-012

Rn7_38_1 n6_19 n7_38_1 3.000000e-001
Ln7_38_1 n7_38_1 n7_38_2 2.000000e-009
Cn7_38_1 n7_38_2 0 5.000000e-013
Rn7_38_2 n7_38_2 n7_38_3 3.000000e-001
Ln7_38_2 n7_38_3 n7_38_4 2.000000e-009
Cn7_38_2 n7_38_4 0 5.000000e-013
Rn7_38_3 n7_38_4 n7_38_5 3.000000e-001
Ln7_38_3 n7_38_5 n7_38_6 2.000000e-009
Cn7_38_3 n7_38_6 0 5.000000e-013
Rn7_38_4 n7_38_6 n7_38_7 3.000000e-001
Ln7_38_4 n7_38_7 n7_38 2.000000e-009
Cn7_38_4 n7_38 0 5.000000e-013
CLoadn7_38_38 n7_38 0 1.000000e-012

Rn7_39_1 n6_20 n7_39_1 3.000000e-001
Ln7_39_1 n7_39_1 n7_39_2 2.000000e-009
Cn7_39_1 n7_39_2 0 5.000000e-013
Rn7_39_2 n7_39_2 n7_39_3 3.000000e-001
Ln7_39_2 n7_39_3 n7_39_4 2.000000e-009
Cn7_39_2 n7_39_4 0 5.000000e-013
Rn7_39_3 n7_39_4 n7_39_5 3.000000e-001
Ln7_39_3 n7_39_5 n7_39_6 2.000000e-009
Cn7_39_3 n7_39_6 0 5.000000e-013
Rn7_39_4 n7_39_6 n7_39_7 3.000000e-001
Ln7_39_4 n7_39_7 n7_39 2.000000e-009
Cn7_39_4 n7_39 0 5.000000e-013
CLoadn7_39_39 n7_39 0 1.000000e-012

Rn7_40_1 n6_20 n7_40_1 3.000000e-001
Ln7_40_1 n7_40_1 n7_40_2 2.000000e-009
Cn7_40_1 n7_40_2 0 5.000000e-013
Rn7_40_2 n7_40_2 n7_40_3 3.000000e-001
Ln7_40_2 n7_40_3 n7_40_4 2.000000e-009
Cn7_40_2 n7_40_4 0 5.000000e-013
Rn7_40_3 n7_40_4 n7_40_5 3.000000e-001
Ln7_40_3 n7_40_5 n7_40_6 2.000000e-009
Cn7_40_3 n7_40_6 0 5.000000e-013
Rn7_40_4 n7_40_6 n7_40_7 3.000000e-001
Ln7_40_4 n7_40_7 n7_40 2.000000e-009
Cn7_40_4 n7_40 0 5.000000e-013
CLoadn7_40_40 n7_40 0 1.000000e-012

Rn7_41_1 n6_21 n7_41_1 3.000000e-001
Ln7_41_1 n7_41_1 n7_41_2 2.000000e-009
Cn7_41_1 n7_41_2 0 5.000000e-013
Rn7_41_2 n7_41_2 n7_41_3 3.000000e-001
Ln7_41_2 n7_41_3 n7_41_4 2.000000e-009
Cn7_41_2 n7_41_4 0 5.000000e-013
Rn7_41_3 n7_41_4 n7_41_5 3.000000e-001
Ln7_41_3 n7_41_5 n7_41_6 2.000000e-009
Cn7_41_3 n7_41_6 0 5.000000e-013
Rn7_41_4 n7_41_6 n7_41_7 3.000000e-001
Ln7_41_4 n7_41_7 n7_41 2.000000e-009
Cn7_41_4 n7_41 0 5.000000e-013
CLoadn7_41_41 n7_41 0 1.000000e-012

Rn7_42_1 n6_21 n7_42_1 3.000000e-001
Ln7_42_1 n7_42_1 n7_42_2 2.000000e-009
Cn7_42_1 n7_42_2 0 5.000000e-013
Rn7_42_2 n7_42_2 n7_42_3 3.000000e-001
Ln7_42_2 n7_42_3 n7_42_4 2.000000e-009
Cn7_42_2 n7_42_4 0 5.000000e-013
Rn7_42_3 n7_42_4 n7_42_5 3.000000e-001
Ln7_42_3 n7_42_5 n7_42_6 2.000000e-009
Cn7_42_3 n7_42_6 0 5.000000e-013
Rn7_42_4 n7_42_6 n7_42_7 3.000000e-001
Ln7_42_4 n7_42_7 n7_42 2.000000e-009
Cn7_42_4 n7_42 0 5.000000e-013
CLoadn7_42_42 n7_42 0 1.000000e-012

Rn7_43_1 n6_22 n7_43_1 3.000000e-001
Ln7_43_1 n7_43_1 n7_43_2 2.000000e-009
Cn7_43_1 n7_43_2 0 5.000000e-013
Rn7_43_2 n7_43_2 n7_43_3 3.000000e-001
Ln7_43_2 n7_43_3 n7_43_4 2.000000e-009
Cn7_43_2 n7_43_4 0 5.000000e-013
Rn7_43_3 n7_43_4 n7_43_5 3.000000e-001
Ln7_43_3 n7_43_5 n7_43_6 2.000000e-009
Cn7_43_3 n7_43_6 0 5.000000e-013
Rn7_43_4 n7_43_6 n7_43_7 3.000000e-001
Ln7_43_4 n7_43_7 n7_43 2.000000e-009
Cn7_43_4 n7_43 0 5.000000e-013
CLoadn7_43_43 n7_43 0 1.000000e-012

Rn7_44_1 n6_22 n7_44_1 3.000000e-001
Ln7_44_1 n7_44_1 n7_44_2 2.000000e-009
Cn7_44_1 n7_44_2 0 5.000000e-013
Rn7_44_2 n7_44_2 n7_44_3 3.000000e-001
Ln7_44_2 n7_44_3 n7_44_4 2.000000e-009
Cn7_44_2 n7_44_4 0 5.000000e-013
Rn7_44_3 n7_44_4 n7_44_5 3.000000e-001
Ln7_44_3 n7_44_5 n7_44_6 2.000000e-009
Cn7_44_3 n7_44_6 0 5.000000e-013
Rn7_44_4 n7_44_6 n7_44_7 3.000000e-001
Ln7_44_4 n7_44_7 n7_44 2.000000e-009
Cn7_44_4 n7_44 0 5.000000e-013
CLoadn7_44_44 n7_44 0 1.000000e-012

Rn7_45_1 n6_23 n7_45_1 3.000000e-001
Ln7_45_1 n7_45_1 n7_45_2 2.000000e-009
Cn7_45_1 n7_45_2 0 5.000000e-013
Rn7_45_2 n7_45_2 n7_45_3 3.000000e-001
Ln7_45_2 n7_45_3 n7_45_4 2.000000e-009
Cn7_45_2 n7_45_4 0 5.000000e-013
Rn7_45_3 n7_45_4 n7_45_5 3.000000e-001
Ln7_45_3 n7_45_5 n7_45_6 2.000000e-009
Cn7_45_3 n7_45_6 0 5.000000e-013
Rn7_45_4 n7_45_6 n7_45_7 3.000000e-001
Ln7_45_4 n7_45_7 n7_45 2.000000e-009
Cn7_45_4 n7_45 0 5.000000e-013
CLoadn7_45_45 n7_45 0 1.000000e-012

Rn7_46_1 n6_23 n7_46_1 3.000000e-001
Ln7_46_1 n7_46_1 n7_46_2 2.000000e-009
Cn7_46_1 n7_46_2 0 5.000000e-013
Rn7_46_2 n7_46_2 n7_46_3 3.000000e-001
Ln7_46_2 n7_46_3 n7_46_4 2.000000e-009
Cn7_46_2 n7_46_4 0 5.000000e-013
Rn7_46_3 n7_46_4 n7_46_5 3.000000e-001
Ln7_46_3 n7_46_5 n7_46_6 2.000000e-009
Cn7_46_3 n7_46_6 0 5.000000e-013
Rn7_46_4 n7_46_6 n7_46_7 3.000000e-001
Ln7_46_4 n7_46_7 n7_46 2.000000e-009
Cn7_46_4 n7_46 0 5.000000e-013
CLoadn7_46_46 n7_46 0 1.000000e-012

Rn7_47_1 n6_24 n7_47_1 3.000000e-001
Ln7_47_1 n7_47_1 n7_47_2 2.000000e-009
Cn7_47_1 n7_47_2 0 5.000000e-013
Rn7_47_2 n7_47_2 n7_47_3 3.000000e-001
Ln7_47_2 n7_47_3 n7_47_4 2.000000e-009
Cn7_47_2 n7_47_4 0 5.000000e-013
Rn7_47_3 n7_47_4 n7_47_5 3.000000e-001
Ln7_47_3 n7_47_5 n7_47_6 2.000000e-009
Cn7_47_3 n7_47_6 0 5.000000e-013
Rn7_47_4 n7_47_6 n7_47_7 3.000000e-001
Ln7_47_4 n7_47_7 n7_47 2.000000e-009
Cn7_47_4 n7_47 0 5.000000e-013
CLoadn7_47_47 n7_47 0 1.000000e-012

Rn7_48_1 n6_24 n7_48_1 3.000000e-001
Ln7_48_1 n7_48_1 n7_48_2 2.000000e-009
Cn7_48_1 n7_48_2 0 5.000000e-013
Rn7_48_2 n7_48_2 n7_48_3 3.000000e-001
Ln7_48_2 n7_48_3 n7_48_4 2.000000e-009
Cn7_48_2 n7_48_4 0 5.000000e-013
Rn7_48_3 n7_48_4 n7_48_5 3.000000e-001
Ln7_48_3 n7_48_5 n7_48_6 2.000000e-009
Cn7_48_3 n7_48_6 0 5.000000e-013
Rn7_48_4 n7_48_6 n7_48_7 3.000000e-001
Ln7_48_4 n7_48_7 n7_48 2.000000e-009
Cn7_48_4 n7_48 0 5.000000e-013
CLoadn7_48_48 n7_48 0 1.000000e-012

Rn7_49_1 n6_25 n7_49_1 3.000000e-001
Ln7_49_1 n7_49_1 n7_49_2 2.000000e-009
Cn7_49_1 n7_49_2 0 5.000000e-013
Rn7_49_2 n7_49_2 n7_49_3 3.000000e-001
Ln7_49_2 n7_49_3 n7_49_4 2.000000e-009
Cn7_49_2 n7_49_4 0 5.000000e-013
Rn7_49_3 n7_49_4 n7_49_5 3.000000e-001
Ln7_49_3 n7_49_5 n7_49_6 2.000000e-009
Cn7_49_3 n7_49_6 0 5.000000e-013
Rn7_49_4 n7_49_6 n7_49_7 3.000000e-001
Ln7_49_4 n7_49_7 n7_49 2.000000e-009
Cn7_49_4 n7_49 0 5.000000e-013
CLoadn7_49_49 n7_49 0 1.000000e-012

Rn7_50_1 n6_25 n7_50_1 3.000000e-001
Ln7_50_1 n7_50_1 n7_50_2 2.000000e-009
Cn7_50_1 n7_50_2 0 5.000000e-013
Rn7_50_2 n7_50_2 n7_50_3 3.000000e-001
Ln7_50_2 n7_50_3 n7_50_4 2.000000e-009
Cn7_50_2 n7_50_4 0 5.000000e-013
Rn7_50_3 n7_50_4 n7_50_5 3.000000e-001
Ln7_50_3 n7_50_5 n7_50_6 2.000000e-009
Cn7_50_3 n7_50_6 0 5.000000e-013
Rn7_50_4 n7_50_6 n7_50_7 3.000000e-001
Ln7_50_4 n7_50_7 n7_50 2.000000e-009
Cn7_50_4 n7_50 0 5.000000e-013
CLoadn7_50_50 n7_50 0 1.000000e-012

Rn7_51_1 n6_26 n7_51_1 3.000000e-001
Ln7_51_1 n7_51_1 n7_51_2 2.000000e-009
Cn7_51_1 n7_51_2 0 5.000000e-013
Rn7_51_2 n7_51_2 n7_51_3 3.000000e-001
Ln7_51_2 n7_51_3 n7_51_4 2.000000e-009
Cn7_51_2 n7_51_4 0 5.000000e-013
Rn7_51_3 n7_51_4 n7_51_5 3.000000e-001
Ln7_51_3 n7_51_5 n7_51_6 2.000000e-009
Cn7_51_3 n7_51_6 0 5.000000e-013
Rn7_51_4 n7_51_6 n7_51_7 3.000000e-001
Ln7_51_4 n7_51_7 n7_51 2.000000e-009
Cn7_51_4 n7_51 0 5.000000e-013
CLoadn7_51_51 n7_51 0 1.000000e-012

Rn7_52_1 n6_26 n7_52_1 3.000000e-001
Ln7_52_1 n7_52_1 n7_52_2 2.000000e-009
Cn7_52_1 n7_52_2 0 5.000000e-013
Rn7_52_2 n7_52_2 n7_52_3 3.000000e-001
Ln7_52_2 n7_52_3 n7_52_4 2.000000e-009
Cn7_52_2 n7_52_4 0 5.000000e-013
Rn7_52_3 n7_52_4 n7_52_5 3.000000e-001
Ln7_52_3 n7_52_5 n7_52_6 2.000000e-009
Cn7_52_3 n7_52_6 0 5.000000e-013
Rn7_52_4 n7_52_6 n7_52_7 3.000000e-001
Ln7_52_4 n7_52_7 n7_52 2.000000e-009
Cn7_52_4 n7_52 0 5.000000e-013
CLoadn7_52_52 n7_52 0 1.000000e-012

Rn7_53_1 n6_27 n7_53_1 3.000000e-001
Ln7_53_1 n7_53_1 n7_53_2 2.000000e-009
Cn7_53_1 n7_53_2 0 5.000000e-013
Rn7_53_2 n7_53_2 n7_53_3 3.000000e-001
Ln7_53_2 n7_53_3 n7_53_4 2.000000e-009
Cn7_53_2 n7_53_4 0 5.000000e-013
Rn7_53_3 n7_53_4 n7_53_5 3.000000e-001
Ln7_53_3 n7_53_5 n7_53_6 2.000000e-009
Cn7_53_3 n7_53_6 0 5.000000e-013
Rn7_53_4 n7_53_6 n7_53_7 3.000000e-001
Ln7_53_4 n7_53_7 n7_53 2.000000e-009
Cn7_53_4 n7_53 0 5.000000e-013
CLoadn7_53_53 n7_53 0 1.000000e-012

Rn7_54_1 n6_27 n7_54_1 3.000000e-001
Ln7_54_1 n7_54_1 n7_54_2 2.000000e-009
Cn7_54_1 n7_54_2 0 5.000000e-013
Rn7_54_2 n7_54_2 n7_54_3 3.000000e-001
Ln7_54_2 n7_54_3 n7_54_4 2.000000e-009
Cn7_54_2 n7_54_4 0 5.000000e-013
Rn7_54_3 n7_54_4 n7_54_5 3.000000e-001
Ln7_54_3 n7_54_5 n7_54_6 2.000000e-009
Cn7_54_3 n7_54_6 0 5.000000e-013
Rn7_54_4 n7_54_6 n7_54_7 3.000000e-001
Ln7_54_4 n7_54_7 n7_54 2.000000e-009
Cn7_54_4 n7_54 0 5.000000e-013
CLoadn7_54_54 n7_54 0 1.000000e-012

Rn7_55_1 n6_28 n7_55_1 3.000000e-001
Ln7_55_1 n7_55_1 n7_55_2 2.000000e-009
Cn7_55_1 n7_55_2 0 5.000000e-013
Rn7_55_2 n7_55_2 n7_55_3 3.000000e-001
Ln7_55_2 n7_55_3 n7_55_4 2.000000e-009
Cn7_55_2 n7_55_4 0 5.000000e-013
Rn7_55_3 n7_55_4 n7_55_5 3.000000e-001
Ln7_55_3 n7_55_5 n7_55_6 2.000000e-009
Cn7_55_3 n7_55_6 0 5.000000e-013
Rn7_55_4 n7_55_6 n7_55_7 3.000000e-001
Ln7_55_4 n7_55_7 n7_55 2.000000e-009
Cn7_55_4 n7_55 0 5.000000e-013
CLoadn7_55_55 n7_55 0 1.000000e-012

Rn7_56_1 n6_28 n7_56_1 3.000000e-001
Ln7_56_1 n7_56_1 n7_56_2 2.000000e-009
Cn7_56_1 n7_56_2 0 5.000000e-013
Rn7_56_2 n7_56_2 n7_56_3 3.000000e-001
Ln7_56_2 n7_56_3 n7_56_4 2.000000e-009
Cn7_56_2 n7_56_4 0 5.000000e-013
Rn7_56_3 n7_56_4 n7_56_5 3.000000e-001
Ln7_56_3 n7_56_5 n7_56_6 2.000000e-009
Cn7_56_3 n7_56_6 0 5.000000e-013
Rn7_56_4 n7_56_6 n7_56_7 3.000000e-001
Ln7_56_4 n7_56_7 n7_56 2.000000e-009
Cn7_56_4 n7_56 0 5.000000e-013
CLoadn7_56_56 n7_56 0 1.000000e-012

Rn7_57_1 n6_29 n7_57_1 3.000000e-001
Ln7_57_1 n7_57_1 n7_57_2 2.000000e-009
Cn7_57_1 n7_57_2 0 5.000000e-013
Rn7_57_2 n7_57_2 n7_57_3 3.000000e-001
Ln7_57_2 n7_57_3 n7_57_4 2.000000e-009
Cn7_57_2 n7_57_4 0 5.000000e-013
Rn7_57_3 n7_57_4 n7_57_5 3.000000e-001
Ln7_57_3 n7_57_5 n7_57_6 2.000000e-009
Cn7_57_3 n7_57_6 0 5.000000e-013
Rn7_57_4 n7_57_6 n7_57_7 3.000000e-001
Ln7_57_4 n7_57_7 n7_57 2.000000e-009
Cn7_57_4 n7_57 0 5.000000e-013
CLoadn7_57_57 n7_57 0 1.000000e-012

Rn7_58_1 n6_29 n7_58_1 3.000000e-001
Ln7_58_1 n7_58_1 n7_58_2 2.000000e-009
Cn7_58_1 n7_58_2 0 5.000000e-013
Rn7_58_2 n7_58_2 n7_58_3 3.000000e-001
Ln7_58_2 n7_58_3 n7_58_4 2.000000e-009
Cn7_58_2 n7_58_4 0 5.000000e-013
Rn7_58_3 n7_58_4 n7_58_5 3.000000e-001
Ln7_58_3 n7_58_5 n7_58_6 2.000000e-009
Cn7_58_3 n7_58_6 0 5.000000e-013
Rn7_58_4 n7_58_6 n7_58_7 3.000000e-001
Ln7_58_4 n7_58_7 n7_58 2.000000e-009
Cn7_58_4 n7_58 0 5.000000e-013
CLoadn7_58_58 n7_58 0 1.000000e-012

Rn7_59_1 n6_30 n7_59_1 3.000000e-001
Ln7_59_1 n7_59_1 n7_59_2 2.000000e-009
Cn7_59_1 n7_59_2 0 5.000000e-013
Rn7_59_2 n7_59_2 n7_59_3 3.000000e-001
Ln7_59_2 n7_59_3 n7_59_4 2.000000e-009
Cn7_59_2 n7_59_4 0 5.000000e-013
Rn7_59_3 n7_59_4 n7_59_5 3.000000e-001
Ln7_59_3 n7_59_5 n7_59_6 2.000000e-009
Cn7_59_3 n7_59_6 0 5.000000e-013
Rn7_59_4 n7_59_6 n7_59_7 3.000000e-001
Ln7_59_4 n7_59_7 n7_59 2.000000e-009
Cn7_59_4 n7_59 0 5.000000e-013
CLoadn7_59_59 n7_59 0 1.000000e-012

Rn7_60_1 n6_30 n7_60_1 3.000000e-001
Ln7_60_1 n7_60_1 n7_60_2 2.000000e-009
Cn7_60_1 n7_60_2 0 5.000000e-013
Rn7_60_2 n7_60_2 n7_60_3 3.000000e-001
Ln7_60_2 n7_60_3 n7_60_4 2.000000e-009
Cn7_60_2 n7_60_4 0 5.000000e-013
Rn7_60_3 n7_60_4 n7_60_5 3.000000e-001
Ln7_60_3 n7_60_5 n7_60_6 2.000000e-009
Cn7_60_3 n7_60_6 0 5.000000e-013
Rn7_60_4 n7_60_6 n7_60_7 3.000000e-001
Ln7_60_4 n7_60_7 n7_60 2.000000e-009
Cn7_60_4 n7_60 0 5.000000e-013
CLoadn7_60_60 n7_60 0 1.000000e-012

Rn7_61_1 n6_31 n7_61_1 3.000000e-001
Ln7_61_1 n7_61_1 n7_61_2 2.000000e-009
Cn7_61_1 n7_61_2 0 5.000000e-013
Rn7_61_2 n7_61_2 n7_61_3 3.000000e-001
Ln7_61_2 n7_61_3 n7_61_4 2.000000e-009
Cn7_61_2 n7_61_4 0 5.000000e-013
Rn7_61_3 n7_61_4 n7_61_5 3.000000e-001
Ln7_61_3 n7_61_5 n7_61_6 2.000000e-009
Cn7_61_3 n7_61_6 0 5.000000e-013
Rn7_61_4 n7_61_6 n7_61_7 3.000000e-001
Ln7_61_4 n7_61_7 n7_61 2.000000e-009
Cn7_61_4 n7_61 0 5.000000e-013
CLoadn7_61_61 n7_61 0 1.000000e-012

Rn7_62_1 n6_31 n7_62_1 3.000000e-001
Ln7_62_1 n7_62_1 n7_62_2 2.000000e-009
Cn7_62_1 n7_62_2 0 5.000000e-013
Rn7_62_2 n7_62_2 n7_62_3 3.000000e-001
Ln7_62_2 n7_62_3 n7_62_4 2.000000e-009
Cn7_62_2 n7_62_4 0 5.000000e-013
Rn7_62_3 n7_62_4 n7_62_5 3.000000e-001
Ln7_62_3 n7_62_5 n7_62_6 2.000000e-009
Cn7_62_3 n7_62_6 0 5.000000e-013
Rn7_62_4 n7_62_6 n7_62_7 3.000000e-001
Ln7_62_4 n7_62_7 n7_62 2.000000e-009
Cn7_62_4 n7_62 0 5.000000e-013
CLoadn7_62_62 n7_62 0 1.000000e-012

Rn7_63_1 n6_32 n7_63_1 3.000000e-001
Ln7_63_1 n7_63_1 n7_63_2 2.000000e-009
Cn7_63_1 n7_63_2 0 5.000000e-013
Rn7_63_2 n7_63_2 n7_63_3 3.000000e-001
Ln7_63_2 n7_63_3 n7_63_4 2.000000e-009
Cn7_63_2 n7_63_4 0 5.000000e-013
Rn7_63_3 n7_63_4 n7_63_5 3.000000e-001
Ln7_63_3 n7_63_5 n7_63_6 2.000000e-009
Cn7_63_3 n7_63_6 0 5.000000e-013
Rn7_63_4 n7_63_6 n7_63_7 3.000000e-001
Ln7_63_4 n7_63_7 n7_63 2.000000e-009
Cn7_63_4 n7_63 0 5.000000e-013
CLoadn7_63_63 n7_63 0 1.000000e-012

Rn7_64_1 n6_32 n7_64_1 3.000000e-001
Ln7_64_1 n7_64_1 n7_64_2 2.000000e-009
Cn7_64_1 n7_64_2 0 5.000000e-013
Rn7_64_2 n7_64_2 n7_64_3 3.000000e-001
Ln7_64_2 n7_64_3 n7_64_4 2.000000e-009
Cn7_64_2 n7_64_4 0 5.000000e-013
Rn7_64_3 n7_64_4 n7_64_5 3.000000e-001
Ln7_64_3 n7_64_5 n7_64_6 2.000000e-009
Cn7_64_3 n7_64_6 0 5.000000e-013
Rn7_64_4 n7_64_6 n7_64_7 3.000000e-001
Ln7_64_4 n7_64_7 n7_64 2.000000e-009
Cn7_64_4 n7_64 0 5.000000e-013
CLoadn7_64_64 n7_64 0 1.000000e-012

.OP
.AC		LIN		5000	0		15e+9
.PRINT  AC VR(n7_64) VI(n7_64)
.probe	v(n7_64)
.End
